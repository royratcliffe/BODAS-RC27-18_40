/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA39AicSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA39AicSCB"
    VALUE
    0x808060F1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA39AicSCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA39AicSCG"
    VALUE
    0x808060F2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA39OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA39OR"
    VALUE
    0x808060F3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA39SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA39SCB"
    VALUE
    0x808060F4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA39SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA39SCG"
    VALUE
    0x808060F5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA39ShuntSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA39ShuntSCB"
    VALUE
    0x808060F6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA40OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA40OR"
    VALUE
    0x808060F7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA40SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA40SCB"
    VALUE
    0x808060F8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA40SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA40SCG"
    VALUE
    0x808060F9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA41OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA41OR"
    VALUE
    0x808060FA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA41SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA41SCB"
    VALUE
    0x808060FB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA41SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA41SCG"
    VALUE
    0x808060FC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA42OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA42OR"
    VALUE
    0x808060FD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA42SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA42SCB"
    VALUE
    0x808060FE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA42SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA42SCG"
    VALUE
    0x808060FF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA43AicSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA43AicSCB"
    VALUE
    0x80806100
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA43AicSCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA43AicSCG"
    VALUE
    0x80806101
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA43OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA43OR"
    VALUE
    0x80806102
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA43SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA43SCB"
    VALUE
    0x80806103
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA43SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA43SCG"
    VALUE
    0x80806104
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA43ShuntSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA43ShuntSCB"
    VALUE
    0x80806105
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA44OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA44OL"
    VALUE
    0x80806106
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA44SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA44SCB"
    VALUE
    0x80806107
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA44SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA44SCG"
    VALUE
    0x80806108
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA57OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA57OR"
    VALUE
    0x80806109
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA57SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA57SCB"
    VALUE
    0x8080610A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA57SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA57SCG"
    VALUE
    0x8080610B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA59OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA59OL"
    VALUE
    0x8080610C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA59SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA59SCB"
    VALUE
    0x8080610D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA59SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA59SCG"
    VALUE
    0x8080610E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK10OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK10OR"
    VALUE
    0x8080610F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK10SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK10SCB"
    VALUE
    0x80806110
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK10SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK10SCG"
    VALUE
    0x80806111
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK11OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK11OR"
    VALUE
    0x80806112
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK11SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK11SCB"
    VALUE
    0x80806113
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK11SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK11SCG"
    VALUE
    0x80806114
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK30AicSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK30AicSCB"
    VALUE
    0x80806115
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK30AicSCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK30AicSCG"
    VALUE
    0x80806116
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK30OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK30OR"
    VALUE
    0x80806117
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK30SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK30SCB"
    VALUE
    0x80806118
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK30SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK30SCG"
    VALUE
    0x80806119
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK30ShuntSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK30ShuntSCB"
    VALUE
    0x8080611A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK31OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK31OR"
    VALUE
    0x8080611B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK31SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK31SCB"
    VALUE
    0x8080611C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK31SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK31SCG"
    VALUE
    0x8080611D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK32OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK32OR"
    VALUE
    0x8080611E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK32SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK32SCB"
    VALUE
    0x8080611F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK32SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK32SCG"
    VALUE
    0x80806120
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK33OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK33OR"
    VALUE
    0x80806121
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK33SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK33SCB"
    VALUE
    0x80806122
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK33SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK33SCG"
    VALUE
    0x80806123
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK34OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK34OR"
    VALUE
    0x80806124
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK34SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK34SCB"
    VALUE
    0x80806125
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK34SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK34SCG"
    VALUE
    0x80806126
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK35OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK35OR"
    VALUE
    0x80806127
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK35SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK35SCB"
    VALUE
    0x80806128
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK35SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK35SCG"
    VALUE
    0x80806129
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK36OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK36OR"
    VALUE
    0x8080612A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK36SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK36SCB"
    VALUE
    0x8080612B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK36SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK36SCG"
    VALUE
    0x8080612C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK37AicSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK37AicSCB"
    VALUE
    0x8080612D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK37AicSCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK37AicSCG"
    VALUE
    0x8080612E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK37OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK37OR"
    VALUE
    0x8080612F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK37SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK37SCB"
    VALUE
    0x80806130
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK37SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK37SCG"
    VALUE
    0x80806131
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK37ShuntSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK37ShuntSCB"
    VALUE
    0x80806132
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK38AicSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK38AicSCB"
    VALUE
    0x80806133
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK38AicSCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK38AicSCG"
    VALUE
    0x80806134
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK38OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK38OR"
    VALUE
    0x80806135
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK38SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK38SCB"
    VALUE
    0x80806136
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK38SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK38SCG"
    VALUE
    0x80806137
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK38ShuntSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK38ShuntSCB"
    VALUE
    0x80806138
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK39AicSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK39AicSCB"
    VALUE
    0x80806139
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK39AicSCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK39AicSCG"
    VALUE
    0x8080613A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK39OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK39OR"
    VALUE
    0x8080613B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK39SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK39SCB"
    VALUE
    0x8080613C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK39SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK39SCG"
    VALUE
    0x8080613D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK39ShuntSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK39ShuntSCB"
    VALUE
    0x8080613E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK40AicSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK40AicSCB"
    VALUE
    0x8080613F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK40AicSCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK40AicSCG"
    VALUE
    0x80806140
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK40OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK40OR"
    VALUE
    0x80806141
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK40SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK40SCB"
    VALUE
    0x80806142
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK40SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK40SCG"
    VALUE
    0x80806143
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK40ShuntSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK40ShuntSCB"
    VALUE
    0x80806144
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK41AicSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK41AicSCB"
    VALUE
    0x80806145
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK41AicSCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK41AicSCG"
    VALUE
    0x80806146
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK41OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK41OR"
    VALUE
    0x80806147
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK41SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK41SCB"
    VALUE
    0x80806148
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK41SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK41SCG"
    VALUE
    0x80806149
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK41ShuntSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK41ShuntSCB"
    VALUE
    0x8080614A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK42AicSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK42AicSCB"
    VALUE
    0x8080614B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK42AicSCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK42AicSCG"
    VALUE
    0x8080614C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK42OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK42OR"
    VALUE
    0x8080614D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK42SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK42SCB"
    VALUE
    0x8080614E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK42SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK42SCG"
    VALUE
    0x8080614F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK42ShuntSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK42ShuntSCB"
    VALUE
    0x80806150
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK43OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK43OR"
    VALUE
    0x80806151
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK43SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK43SCB"
    VALUE
    0x80806152
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK43SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK43SCG"
    VALUE
    0x80806153
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK44AicSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK44AicSCB"
    VALUE
    0x80806154
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK44AicSCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK44AicSCG"
    VALUE
    0x80806155
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK44OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK44OR"
    VALUE
    0x80806156
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK44SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK44SCB"
    VALUE
    0x80806157
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK44SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK44SCG"
    VALUE
    0x80806158
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK44ShuntSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK44ShuntSCB"
    VALUE
    0x80806159
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK45AicSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK45AicSCB"
    VALUE
    0x8080615A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK45AicSCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK45AicSCG"
    VALUE
    0x8080615B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK45OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK45OR"
    VALUE
    0x8080615C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK45SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK45SCB"
    VALUE
    0x8080615D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK45SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK45SCG"
    VALUE
    0x8080615E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK45ShuntSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK45ShuntSCB"
    VALUE
    0x8080615F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK52OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK52OR"
    VALUE
    0x80806160
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK52SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK52SCB"
    VALUE
    0x80806161
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK52SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK52SCG"
    VALUE
    0x80806162
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK53OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK53OR"
    VALUE
    0x80806163
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK53SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK53SCB"
    VALUE
    0x80806164
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK53SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK53SCG"
    VALUE
    0x80806165
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK54AicSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK54AicSCB"
    VALUE
    0x80806166
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK54AicSCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK54AicSCG"
    VALUE
    0x80806167
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK54OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK54OR"
    VALUE
    0x80806168
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK54SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK54SCB"
    VALUE
    0x80806169
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK54SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK54SCG"
    VALUE
    0x8080616A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK54ShuntSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK54ShuntSCB"
    VALUE
    0x8080616B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK55AicSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK55AicSCB"
    VALUE
    0x8080616C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK55AicSCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK55AicSCG"
    VALUE
    0x8080616D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK55OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK55OR"
    VALUE
    0x8080616E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK55SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK55SCB"
    VALUE
    0x8080616F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK55SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK55SCG"
    VALUE
    0x80806170
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK55ShuntSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK55ShuntSCB"
    VALUE
    0x80806171
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK56OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK56OR"
    VALUE
    0x80806172
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK56SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK56SCB"
    VALUE
    0x80806173
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK56SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK56SCG"
    VALUE
    0x80806174
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK57OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK57OR"
    VALUE
    0x80806175
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK57SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK57SCB"
    VALUE
    0x80806176
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK57SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK57SCG"
    VALUE
    0x80806177
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK58OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK58OR"
    VALUE
    0x80806178
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK58SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK58SCB"
    VALUE
    0x80806179
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK58SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK58SCG"
    VALUE
    0x8080617A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK59OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK59OR"
    VALUE
    0x8080617B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK59SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK59SCB"
    VALUE
    0x8080617C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK59SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK59SCG"
    VALUE
    0x8080617D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK60OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK60OR"
    VALUE
    0x8080617E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK60SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK60SCB"
    VALUE
    0x8080617F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK60SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK60SCG"
    VALUE
    0x80806180
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK61AicSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK61AicSCB"
    VALUE
    0x80806181
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK61AicSCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK61AicSCG"
    VALUE
    0x80806182
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK61OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK61OR"
    VALUE
    0x80806183
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK61SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK61SCB"
    VALUE
    0x80806184
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK61SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK61SCG"
    VALUE
    0x80806185
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK61ShuntSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK61ShuntSCB"
    VALUE
    0x80806186
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK62OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK62OR"
    VALUE
    0x80806187
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK62SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK62SCB"
    VALUE
    0x80806188
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK62SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK62SCG"
    VALUE
    0x80806189
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK63AicSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK63AicSCB"
    VALUE
    0x8080618A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK63AicSCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK63AicSCG"
    VALUE
    0x8080618B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK63OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK63OR"
    VALUE
    0x8080618C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK63SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK63SCB"
    VALUE
    0x8080618D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK63SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK63SCG"
    VALUE
    0x8080618E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK63ShuntSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK63ShuntSCB"
    VALUE
    0x8080618F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK64AicSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK64AicSCB"
    VALUE
    0x80806190
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK64AicSCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK64AicSCG"
    VALUE
    0x80806191
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK64OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK64OR"
    VALUE
    0x80806192
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK64SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK64SCB"
    VALUE
    0x80806193
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK64SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK64SCG"
    VALUE
    0x80806194
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK64ShuntSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK64ShuntSCB"
    VALUE
    0x80806195
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK65AicSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK65AicSCB"
    VALUE
    0x80806196
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK65AicSCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK65AicSCG"
    VALUE
    0x80806197
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK65OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK65OR"
    VALUE
    0x80806198
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK65SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK65SCB"
    VALUE
    0x80806199
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK65SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK65SCG"
    VALUE
    0x8080619A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK65ShuntSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK65ShuntSCB"
    VALUE
    0x8080619B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK74OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK74OR"
    VALUE
    0x8080619C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK74SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK74SCB"
    VALUE
    0x8080619D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK74SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK74SCG"
    VALUE
    0x8080619E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK75OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK75OR"
    VALUE
    0x8080619F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK75SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK75SCB"
    VALUE
    0x808061A0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK75SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK75SCG"
    VALUE
    0x808061A1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK76OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK76OR"
    VALUE
    0x808061A2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK76SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK76SCB"
    VALUE
    0x808061A3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK76SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK76SCG"
    VALUE
    0x808061A4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK77OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK77OR"
    VALUE
    0x808061A5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK77SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK77SCB"
    VALUE
    0x808061A6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK77SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK77SCG"
    VALUE
    0x808061A7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK78OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK78OR"
    VALUE
    0x808061A8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK78SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK78SCB"
    VALUE
    0x808061A9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK78SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK78SCG"
    VALUE
    0x808061AA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_DvUBAT_FWs_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_DvUBAT_FWs"
    VALUE
    0x808061AB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_OVErr_VPR6_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_OVErr_VPR6"
    VALUE
    0x808061AC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_OVWarn_VPR6_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_OVWarn_VPR6"
    VALUE
    0x808061AD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3"
    VALUE
    0x808061AE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2"
    VALUE
    0x808061AF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_OV_UBAT_MON_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_OV_UBAT_MON"
    VALUE
    0x808061B0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_OV_UBRM24_FLEXIN_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_OV_UBRM24_FLEXIN"
    VALUE
    0x808061B1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_OV_UBRM24_LOADS_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_OV_UBRM24_LOADS"
    VALUE
    0x808061B2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_OV_UBRM24_MON_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_OV_UBRM24_MON"
    VALUE
    0x808061B3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_OV_VDD5_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_OV_VDD5"
    VALUE
    0x808061B4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_OV_VDD5_IN_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_OV_VDD5_IN"
    VALUE
    0x808061B5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_OV_VPR6_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_OV_VPR6"
    VALUE
    0x808061B6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_OV_VSS3_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_OV_VSS3"
    VALUE
    0x808061B7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_OV_VSS4_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_OV_VSS4"
    VALUE
    0x808061B8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_Temp1_HTErr_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_Temp1_HTErr"
    VALUE
    0x808061B9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_Temp1_HTWarn_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_Temp1_HTWarn"
    VALUE
    0x808061BA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_Temp2_HTErr_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_Temp2_HTErr"
    VALUE
    0x808061BB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_Temp2_HTWarn_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_Temp2_HTWarn"
    VALUE
    0x808061BC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3"
    VALUE
    0x808061BD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2"
    VALUE
    0x808061BE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_UV_VDD5_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_UV_VDD5"
    VALUE
    0x808061BF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_UV_VDD5_IN_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_UV_VDD5_IN"
    VALUE
    0x808061C0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_UV_VPR6_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_UV_VPR6"
    VALUE
    0x808061C1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_UV_VSS3_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_UV_VSS3"
    VALUE
    0x808061C2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_UV_VSS4_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_UV_VSS4"
    VALUE
    0x808061C3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA01OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA01OL"
    VALUE
    0x808061C4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA01OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA01OT"
    VALUE
    0x808061C5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA01SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA01SCB"
    VALUE
    0x808061C6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA01SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA01SCG"
    VALUE
    0x808061C7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA02OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA02OL"
    VALUE
    0x808061C8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA02OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA02OR"
    VALUE
    0x808061C9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA02OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA02OT"
    VALUE
    0x808061CA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA02SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA02SCB"
    VALUE
    0x808061CB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA02SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA02SCG"
    VALUE
    0x808061CC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA03OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA03OL"
    VALUE
    0x808061CD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA03OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA03OT"
    VALUE
    0x808061CE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA03SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA03SCB"
    VALUE
    0x808061CF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA03SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA03SCG"
    VALUE
    0x808061D0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA04OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA04OL"
    VALUE
    0x808061D1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA04OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA04OT"
    VALUE
    0x808061D2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA04SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA04SCB"
    VALUE
    0x808061D3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA04SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA04SCG"
    VALUE
    0x808061D4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA05OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA05OL"
    VALUE
    0x808061D5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA05OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA05OR"
    VALUE
    0x808061D6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA05OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA05OT"
    VALUE
    0x808061D7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA05SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA05SCB"
    VALUE
    0x808061D8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA05SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA05SCG"
    VALUE
    0x808061D9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA06OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA06OL"
    VALUE
    0x808061DA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA06OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA06OR"
    VALUE
    0x808061DB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA06OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA06OT"
    VALUE
    0x808061DC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA06SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA06SCB"
    VALUE
    0x808061DD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA06SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA06SCG"
    VALUE
    0x808061DE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA07OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA07OL"
    VALUE
    0x808061DF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA07OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA07OT"
    VALUE
    0x808061E0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA07SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA07SCB"
    VALUE
    0x808061E1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA07SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA07SCG"
    VALUE
    0x808061E2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA08OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA08OL"
    VALUE
    0x808061E3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA08OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA08OT"
    VALUE
    0x808061E4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA08SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA08SCB"
    VALUE
    0x808061E5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA08SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA08SCG"
    VALUE
    0x808061E6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA09OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA09OL"
    VALUE
    0x808061E7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA09OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA09OR"
    VALUE
    0x808061E8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA09OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA09OT"
    VALUE
    0x808061E9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA09SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA09SCB"
    VALUE
    0x808061EA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA09SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA09SCG"
    VALUE
    0x808061EB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA10OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA10OL"
    VALUE
    0x808061EC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA10OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA10OT"
    VALUE
    0x808061ED
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA10SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA10SCB"
    VALUE
    0x808061EE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA10SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA10SCG"
    VALUE
    0x808061EF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA11OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA11OL"
    VALUE
    0x808061F0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA11OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA11OT"
    VALUE
    0x808061F1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA11SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA11SCB"
    VALUE
    0x808061F2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA11SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA11SCG"
    VALUE
    0x808061F3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA12OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA12OR"
    VALUE
    0x808061F4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA12SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA12SCB"
    VALUE
    0x808061F5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA12SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA12SCG"
    VALUE
    0x808061F6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA16OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA16OL"
    VALUE
    0x808061F7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA16OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA16OT"
    VALUE
    0x808061F8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA16SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA16SCB"
    VALUE
    0x808061F9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA16SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA16SCG"
    VALUE
    0x808061FA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA17OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA17OL"
    VALUE
    0x808061FB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA17OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA17OR"
    VALUE
    0x808061FC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA17OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA17OT"
    VALUE
    0x808061FD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA17SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA17SCB"
    VALUE
    0x808061FE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA17SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA17SCG"
    VALUE
    0x808061FF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA18OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA18OL"
    VALUE
    0x80806200
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA18OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA18OT"
    VALUE
    0x80806201
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA18SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA18SCB"
    VALUE
    0x80806202
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA18SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA18SCG"
    VALUE
    0x80806203
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA19OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA19OL"
    VALUE
    0x80806204
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA19OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA19OR"
    VALUE
    0x80806205
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA19OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA19OT"
    VALUE
    0x80806206
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA19SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA19SCB"
    VALUE
    0x80806207
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA19SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA19SCG"
    VALUE
    0x80806208
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA20OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA20OL"
    VALUE
    0x80806209
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA20OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA20OR"
    VALUE
    0x8080620A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA20OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA20OT"
    VALUE
    0x8080620B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA20SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA20SCB"
    VALUE
    0x8080620C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA20SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA20SCG"
    VALUE
    0x8080620D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA31OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA31OL"
    VALUE
    0x8080620E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA31OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA31OR"
    VALUE
    0x8080620F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA31OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA31OT"
    VALUE
    0x80806210
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA31SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA31SCB"
    VALUE
    0x80806211
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA31SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA31SCG"
    VALUE
    0x80806212
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA32OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA32OL"
    VALUE
    0x80806213
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA32OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA32OR"
    VALUE
    0x80806214
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA32OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA32OT"
    VALUE
    0x80806215
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA32SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA32SCB"
    VALUE
    0x80806216
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA32SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA32SCG"
    VALUE
    0x80806217
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA33OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA33OL"
    VALUE
    0x80806218
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA33OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA33OR"
    VALUE
    0x80806219
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA33OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA33OT"
    VALUE
    0x8080621A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA33SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA33SCB"
    VALUE
    0x8080621B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA33SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA33SCG"
    VALUE
    0x8080621C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA34OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA34OL"
    VALUE
    0x8080621D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA34OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA34OR"
    VALUE
    0x8080621E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA34OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA34OT"
    VALUE
    0x8080621F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA34SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA34SCB"
    VALUE
    0x80806220
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA34SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA34SCG"
    VALUE
    0x80806221
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA35OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA35OL"
    VALUE
    0x80806222
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA35OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA35OR"
    VALUE
    0x80806223
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA35OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA35OT"
    VALUE
    0x80806224
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA35SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA35SCB"
    VALUE
    0x80806225
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA35SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA35SCG"
    VALUE
    0x80806226
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA46OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA46OL"
    VALUE
    0x80806227
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA46OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA46OR"
    VALUE
    0x80806228
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA46OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA46OT"
    VALUE
    0x80806229
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA46SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA46SCB"
    VALUE
    0x8080622A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA46SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA46SCG"
    VALUE
    0x8080622B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA47OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA47OL"
    VALUE
    0x8080622C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA47OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA47OR"
    VALUE
    0x8080622D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA47OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA47OT"
    VALUE
    0x8080622E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA47SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA47SCB"
    VALUE
    0x8080622F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA47SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA47SCG"
    VALUE
    0x80806230
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA48OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA48OL"
    VALUE
    0x80806231
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA48OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA48OR"
    VALUE
    0x80806232
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA48OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA48OT"
    VALUE
    0x80806233
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA48SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA48SCB"
    VALUE
    0x80806234
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA48SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA48SCG"
    VALUE
    0x80806235
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA49OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA49OL"
    VALUE
    0x80806236
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA49OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA49OT"
    VALUE
    0x80806237
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA49SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA49SCB"
    VALUE
    0x80806238
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA49SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA49SCG"
    VALUE
    0x80806239
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA50OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA50OL"
    VALUE
    0x8080623A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA50OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA50OT"
    VALUE
    0x8080623B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA50SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA50SCB"
    VALUE
    0x8080623C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA50SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA50SCG"
    VALUE
    0x8080623D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA51OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA51OL"
    VALUE
    0x8080623E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA51OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA51OR"
    VALUE
    0x8080623F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA51OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA51OT"
    VALUE
    0x80806240
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA51SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA51SCB"
    VALUE
    0x80806241
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA51SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA51SCG"
    VALUE
    0x80806242
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA52OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA52OL"
    VALUE
    0x80806243
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA52OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA52OR"
    VALUE
    0x80806244
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA52OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA52OT"
    VALUE
    0x80806245
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA52SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA52SCB"
    VALUE
    0x80806246
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA52SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA52SCG"
    VALUE
    0x80806247
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA53OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA53OL"
    VALUE
    0x80806248
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA53OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA53OR"
    VALUE
    0x80806249
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA53OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA53OT"
    VALUE
    0x8080624A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA53SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA53SCB"
    VALUE
    0x8080624B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA53SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA53SCG"
    VALUE
    0x8080624C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA54OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA54OL"
    VALUE
    0x8080624D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA54OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA54OR"
    VALUE
    0x8080624E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA54OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA54OT"
    VALUE
    0x8080624F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA54SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA54SCB"
    VALUE
    0x80806250
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA54SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA54SCG"
    VALUE
    0x80806251
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA55OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA55OL"
    VALUE
    0x80806252
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA55OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA55OT"
    VALUE
    0x80806253
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA55SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA55SCB"
    VALUE
    0x80806254
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA55SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA55SCG"
    VALUE
    0x80806255
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA56OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA56OL"
    VALUE
    0x80806256
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA56OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA56OT"
    VALUE
    0x80806257
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA56SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA56SCB"
    VALUE
    0x80806258
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA56SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA56SCG"
    VALUE
    0x80806259
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA58OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA58OL"
    VALUE
    0x8080625A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA58OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA58OT"
    VALUE
    0x8080625B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA58SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA58SCB"
    VALUE
    0x8080625C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA58SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA58SCG"
    VALUE
    0x8080625D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK07OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK07OL"
    VALUE
    0x8080625E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK07OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK07OR"
    VALUE
    0x8080625F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK07OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK07OT"
    VALUE
    0x80806260
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK07SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK07SCB"
    VALUE
    0x80806261
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK07SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK07SCG"
    VALUE
    0x80806262
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK08OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK08OL"
    VALUE
    0x80806263
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK08OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK08OR"
    VALUE
    0x80806264
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK08OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK08OT"
    VALUE
    0x80806265
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK08SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK08SCB"
    VALUE
    0x80806266
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK08SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK08SCG"
    VALUE
    0x80806267
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK09OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK09OL"
    VALUE
    0x80806268
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK09OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK09OR"
    VALUE
    0x80806269
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK09OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK09OT"
    VALUE
    0x8080626A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK09SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK09SCB"
    VALUE
    0x8080626B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK09SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK09SCG"
    VALUE
    0x8080626C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK12OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK12OL"
    VALUE
    0x8080626D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK12OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK12OT"
    VALUE
    0x8080626E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK12SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK12SCB"
    VALUE
    0x8080626F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK12SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK12SCG"
    VALUE
    0x80806270
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK13OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK13OL"
    VALUE
    0x80806271
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK13OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK13OT"
    VALUE
    0x80806272
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK13SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK13SCB"
    VALUE
    0x80806273
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK13SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK13SCG"
    VALUE
    0x80806274
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK14OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK14OL"
    VALUE
    0x80806275
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK14OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK14OR"
    VALUE
    0x80806276
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK14OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK14OT"
    VALUE
    0x80806277
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK14SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK14SCB"
    VALUE
    0x80806278
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK14SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK14SCG"
    VALUE
    0x80806279
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK15OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK15OL"
    VALUE
    0x8080627A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK15OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK15OR"
    VALUE
    0x8080627B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK15OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK15OT"
    VALUE
    0x8080627C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK15SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK15SCB"
    VALUE
    0x8080627D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK15SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK15SCG"
    VALUE
    0x8080627E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK16OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK16OL"
    VALUE
    0x8080627F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK16OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK16OR"
    VALUE
    0x80806280
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK16OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK16OT"
    VALUE
    0x80806281
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK16SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK16SCB"
    VALUE
    0x80806282
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK16SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK16SCG"
    VALUE
    0x80806283
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK17OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK17OL"
    VALUE
    0x80806284
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK17OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK17OR"
    VALUE
    0x80806285
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK17OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK17OT"
    VALUE
    0x80806286
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK17SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK17SCB"
    VALUE
    0x80806287
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK17SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK17SCG"
    VALUE
    0x80806288
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK25OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK25OR"
    VALUE
    0x80806289
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK25SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK25SCB"
    VALUE
    0x8080628A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK25SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK25SCG"
    VALUE
    0x8080628B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK29OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK29OL"
    VALUE
    0x8080628C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK29OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK29OR"
    VALUE
    0x8080628D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK29OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK29OT"
    VALUE
    0x8080628E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK29SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK29SCB"
    VALUE
    0x8080628F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK29SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK29SCG"
    VALUE
    0x80806290
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK51OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK51OL"
    VALUE
    0x80806291
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK51OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK51OT"
    VALUE
    0x80806292
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK51SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK51SCB"
    VALUE
    0x80806293
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK51SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK51SCG"
    VALUE
    0x80806294
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK62OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK62OR"
    VALUE
    0x80806295
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK62SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK62SCB"
    VALUE
    0x80806296
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK62SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK62SCG"
    VALUE
    0x80806297
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK73OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK73OL"
    VALUE
    0x80806298
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK73OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK73OR"
    VALUE
    0x80806299
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK73OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK73OT"
    VALUE
    0x8080629A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK73SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK73SCB"
    VALUE
    0x8080629B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK73SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK73SCG"
    VALUE
    0x8080629C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK80OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK80OL"
    VALUE
    0x8080629D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK80OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK80OT"
    VALUE
    0x8080629E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK80SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK80SCB"
    VALUE
    0x8080629F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK80SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK80SCG"
    VALUE
    0x808062A0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK81OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK81OL"
    VALUE
    0x808062A1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK81OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK81OT"
    VALUE
    0x808062A2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK81SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK81SCB"
    VALUE
    0x808062A3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK81SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK81SCG"
    VALUE
    0x808062A4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK82OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK82OL"
    VALUE
    0x808062A5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK82OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK82OT"
    VALUE
    0x808062A6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK82SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK82SCB"
    VALUE
    0x808062A7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK82SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK82SCG"
    VALUE
    0x808062A8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK83OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK83OL"
    VALUE
    0x808062A9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK83OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK83OT"
    VALUE
    0x808062AA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK83SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK83SCB"
    VALUE
    0x808062AB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK83SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK83SCG"
    VALUE
    0x808062AC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK84OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK84OL"
    VALUE
    0x808062AD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK84OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK84OT"
    VALUE
    0x808062AE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK84SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK84SCB"
    VALUE
    0x808062AF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK84SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK84SCG"
    VALUE
    0x808062B0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK85OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK85OL"
    VALUE
    0x808062B1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK85OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK85OT"
    VALUE
    0x808062B2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK85SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK85SCB"
    VALUE
    0x808062B3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK85SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK85SCG"
    VALUE
    0x808062B4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK86OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK86OL"
    VALUE
    0x808062B5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK86OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK86OT"
    VALUE
    0x808062B6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK86SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK86SCB"
    VALUE
    0x808062B7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK86SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK86SCG"
    VALUE
    0x808062B8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK87OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK87OL"
    VALUE
    0x808062B9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK87OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK87OT"
    VALUE
    0x808062BA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK87SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK87SCB"
    VALUE
    0x808062BB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK87SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK87SCG"
    VALUE
    0x808062BC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_EventUpDownDebFault_C
    "assigned fault type / Fault type assignment for check DFC_bds_EventUpDownDebFault"
    VALUE
    0x808062BD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_DSMDummy_C
    "assigned fault type / Fault type assignment for check DFC_DSMDummy"
    VALUE
    0x808062BE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canGetDataNoBuf_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canGetDataNoBuf"
    VALUE
    0x808062BF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canGetDataParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canGetDataParam"
    VALUE
    0x808062C0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canGetDataboxNoInit_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canGetDataboxNoInit"
    VALUE
    0x808062C1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canGetDataboxParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canGetDataboxParam"
    VALUE
    0x808062C2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canGetRxBufStatusParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canGetRxBufStatusParam"
    VALUE
    0x808062C3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canGetStatusParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canGetStatusParam"
    VALUE
    0x808062C4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canGetTxBufStatusParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canGetTxBufStatusParam"
    VALUE
    0x808062C5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canInitParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canInitParam"
    VALUE
    0x808062C6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canInitRxDataboxOverlap_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canInitRxDataboxOverlap"
    VALUE
    0x808062C7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canInitRxDataboxParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canInitRxDataboxParam"
    VALUE
    0x808062C8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canInitTxDataboxParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canInitTxDataboxParam"
    VALUE
    0x808062C9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canIpduGroupControl_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canIpduGroupControl"
    VALUE
    0x808062CA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canIsDataboxFreeNoInit_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canIsDataboxFreeNoInit"
    VALUE
    0x808062CB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canIsDataboxFreeParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canIsDataboxFreeParam"
    VALUE
    0x808062CC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canIsTxEmptyParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canIsTxEmptyParam"
    VALUE
    0x808062CD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canRegBusOffCallbInvState_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canRegBusOffCallbInvState"
    VALUE
    0x808062CE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canRegBusOffCallbParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canRegBusOffCallbParam"
    VALUE
    0x808062CF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canRegRxBufInvState_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canRegRxBufInvState"
    VALUE
    0x808062D0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canRegRxBufOverlap_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canRegRxBufOverlap"
    VALUE
    0x808062D1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canRegRxBufParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canRegRxBufParam"
    VALUE
    0x808062D2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canRegRxCallbInvState_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canRegRxCallbInvState"
    VALUE
    0x808062D3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canRegRxCallbParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canRegRxCallbParam"
    VALUE
    0x808062D4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canRegRxDataboxInvNumb_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canRegRxDataboxInvNumb"
    VALUE
    0x808062D5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canRegRxDataboxInvState_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canRegRxDataboxInvState"
    VALUE
    0x808062D6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canRegRxDataboxOverlap_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canRegRxDataboxOverlap"
    VALUE
    0x808062D7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canRegRxDataboxParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canRegRxDataboxParam"
    VALUE
    0x808062D8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canRegTxBufInvState_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canRegTxBufInvState"
    VALUE
    0x808062D9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canRegTxBufOverlap_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canRegTxBufOverlap"
    VALUE
    0x808062DA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canRegTxBufParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canRegTxBufParam"
    VALUE
    0x808062DB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canRegTxDataboxInvNumb_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canRegTxDataboxInvNumb"
    VALUE
    0x808062DC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canRegTxDataboxInvState_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canRegTxDataboxInvState"
    VALUE
    0x808062DD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canRegTxDataboxOverlap_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canRegTxDataboxOverlap"
    VALUE
    0x808062DE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canRegTxDataboxParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canRegTxDataboxParam"
    VALUE
    0x808062DF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canResetTxBufParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canResetTxBufParam"
    VALUE
    0x808062E0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canSendDataBufOvfl_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canSendDataBufOvfl"
    VALUE
    0x808062E1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canSendDataParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canSendDataParam"
    VALUE
    0x808062E2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canSendDataboxNoInit_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canSendDataboxNoInit"
    VALUE
    0x808062E3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canSendDataboxParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canSendDataboxParam"
    VALUE
    0x808062E4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canSetTxCycleParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canSetTxCycleParam"
    VALUE
    0x808062E5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canStartParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canStartParam"
    VALUE
    0x808062E6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canStopParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canStopParam"
    VALUE
    0x808062E7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_can_ClearIpduGroup_C
    "assigned fault type / Fault type assignment for check DFC_rbr_can_ClearIpduGroup"
    VALUE
    0x808062E8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_can_ReceiveSignal_C
    "assigned fault type / Fault type assignment for check DFC_rbr_can_ReceiveSignal"
    VALUE
    0x808062E9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_can_SendSignal_C
    "assigned fault type / Fault type assignment for check DFC_rbr_can_SendSignal"
    VALUE
    0x808062EA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_can_SetIpduGroup_C
    "assigned fault type / Fault type assignment for check DFC_rbr_can_SetIpduGroup"
    VALUE
    0x808062EB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_dsmDTCJ1939_C
    "assigned fault type / Fault type assignment for check DFC_rbr_dsmDTCJ1939"
    VALUE
    0x808062EC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_dsmDelDTCJ1939_C
    "assigned fault type / Fault type assignment for check DFC_rbr_dsmDelDTCJ1939"
    VALUE
    0x808062ED
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_dsmDelErrors_C
    "assigned fault type / Fault type assignment for check DFC_rbr_dsmDelErrors"
    VALUE
    0x808062EE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_dsmGetDFES_C
    "assigned fault type / Fault type assignment for check DFC_rbr_dsmGetDFES"
    VALUE
    0x808062EF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_dsmGetDTCJ1939_C
    "assigned fault type / Fault type assignment for check DFC_rbr_dsmGetDTCJ1939"
    VALUE
    0x808062F0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_dsmGetErrors_C
    "assigned fault type / Fault type assignment for check DFC_rbr_dsmGetErrors"
    VALUE
    0x808062F1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_dsmGetNumErrors_C
    "assigned fault type / Fault type assignment for check DFC_rbr_dsmGetNumErrors"
    VALUE
    0x808062F2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_dsmInitQueueOverflow_C
    "assigned fault type / Fault type assignment for check DFC_rbr_dsmInitQueueOverflow"
    VALUE
    0x808062F3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_dsmNumDTCJ1939_C
    "assigned fault type / Fault type assignment for check DFC_rbr_dsmNumDTCJ1939"
    VALUE
    0x808062F4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_dsmTesterror_C
    "assigned fault type / Fault type assignment for check DFC_rbr_dsmTesterror"
    VALUE
    0x808062F5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_dsmUpdateDebError_C
    "assigned fault type / Fault type assignment for check DFC_rbr_dsmUpdateDebError"
    VALUE
    0x808062F6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_dsmUpdateError_C
    "assigned fault type / Fault type assignment for check DFC_rbr_dsmUpdateError"
    VALUE
    0x808062F7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_dsmgetDFCStatus_C
    "assigned fault type / Fault type assignment for check DFC_rbr_dsmgetDFCStatus"
    VALUE
    0x808062F8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_dsmtestErrorDFC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_dsmtestErrorDFC"
    VALUE
    0x808062F9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inAi_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inAi"
    VALUE
    0x808062FA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inAic_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inAic"
    VALUE
    0x808062FB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inAicCfg_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inAicCfg"
    VALUE
    0x808062FC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inAicGetStatus_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inAicGetStatus"
    VALUE
    0x808062FD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inAid_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inAid"
    VALUE
    0x808062FE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inAidCfg_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inAidCfg"
    VALUE
    0x808062FF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inAiv_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inAiv"
    VALUE
    0x80806300
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inAivCfg_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inAivCfg"
    VALUE
    0x80806301
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inAivGetStatus_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inAivGetStatus"
    VALUE
    0x80806302
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inDi_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inDi"
    VALUE
    0x80806303
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inFi_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inFi"
    VALUE
    0x80806304
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inFiCfg_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inFiCfg"
    VALUE
    0x80806305
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inFiGetStatus_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inFiGetStatus"
    VALUE
    0x80806306
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inFi_Buffered_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inFi_Buffered"
    VALUE
    0x80806307
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inPhase_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inPhase"
    VALUE
    0x80806308
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inPhaseGetStatus_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inPhaseGetStatus"
    VALUE
    0x80806309
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inPhaseResetCounter_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inPhaseResetCounter"
    VALUE
    0x8080630A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inRi_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inRi"
    VALUE
    0x8080630B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inRiCfg_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inRiCfg"
    VALUE
    0x8080630C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inRiCfgTemp_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inRiCfgTemp"
    VALUE
    0x8080630D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inRiGetStatus_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inRiGetStatus"
    VALUE
    0x8080630E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inRiGetTemp_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inRiGetTemp"
    VALUE
    0x8080630F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inSentCopyFDFifo_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inSentCopyFDFifo"
    VALUE
    0x80806310
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inSentDisable_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inSentDisable"
    VALUE
    0x80806311
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inSentEnable_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inSentEnable"
    VALUE
    0x80806312
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inSentGetErrorStatus_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inSentGetErrorStatus"
    VALUE
    0x80806313
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inSentGetFD_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inSentGetFD"
    VALUE
    0x80806314
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inSentGetSD_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inSentGetSD"
    VALUE
    0x80806315
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inSentGetSDDatabox_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inSentGetSDDatabox"
    VALUE
    0x80806316
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inSentGetStatus_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inSentGetStatus"
    VALUE
    0x80806317
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inSentInitSDDatabox_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inSentInitSDDatabox"
    VALUE
    0x80806318
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inSentRegisterCopyFDFifo_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inSentRegisterCopyFDFifo"
    VALUE
    0x80806319
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inSentRegisterFDFifo_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inSentRegisterFDFifo"
    VALUE
    0x8080631A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inSentRegisterSDDataboxes_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inSentRegisterSDDataboxes"
    VALUE
    0x8080631B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_isobusCanRxBufferOverflow_C
    "assigned fault type / Fault type assignment for check DFC_rbr_isobusCanRxBufferOverflow"
    VALUE
    0x8080631C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_isobusGetCaAddrParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_isobusGetCaAddrParam"
    VALUE
    0x8080631D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_isobusGetDiagnosticParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_isobusGetDiagnosticParam"
    VALUE
    0x8080631E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_isobusGetRxDataboxStatusParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_isobusGetRxDataboxStatusParam"
    VALUE
    0x8080631F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_isobusGetStatusParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_isobusGetStatusParam"
    VALUE
    0x80806320
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_isobusInitCommCaMissing_C
    "assigned fault type / Fault type assignment for check DFC_rbr_isobusInitCommCaMissing"
    VALUE
    0x80806321
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_isobusInitCommParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_isobusInitCommParam"
    VALUE
    0x80806322
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_isobusInitCommState_C
    "assigned fault type / Fault type assignment for check DFC_rbr_isobusInitCommState"
    VALUE
    0x80806323
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_isobusInitDiagnosticParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_isobusInitDiagnosticParam"
    VALUE
    0x80806324
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_isobusInitFailureListParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_isobusInitFailureListParam"
    VALUE
    0x80806325
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_isobusInitRxDataboxParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_isobusInitRxDataboxParam"
    VALUE
    0x80806326
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_isobusInitTxDataboxParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_isobusInitTxDataboxParam"
    VALUE
    0x80806327
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_isobusRegRxDataboxOverlap_C
    "assigned fault type / Fault type assignment for check DFC_rbr_isobusRegRxDataboxOverlap"
    VALUE
    0x80806328
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_isobusRegRxDataboxParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_isobusRegRxDataboxParam"
    VALUE
    0x80806329
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_isobusRegRxDataboxState_C
    "assigned fault type / Fault type assignment for check DFC_rbr_isobusRegRxDataboxState"
    VALUE
    0x8080632A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_isobusRegTxDataboxOverlap_C
    "assigned fault type / Fault type assignment for check DFC_rbr_isobusRegTxDataboxOverlap"
    VALUE
    0x8080632B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_isobusRegTxDataboxParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_isobusRegTxDataboxParam"
    VALUE
    0x8080632C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_isobusRegTxDataboxState_C
    "assigned fault type / Fault type assignment for check DFC_rbr_isobusRegTxDataboxState"
    VALUE
    0x8080632D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_isobusRegisterErrClrCallbackParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_isobusRegisterErrClrCallbackParam"
    VALUE
    0x8080632E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_isobusRegisterInstancesOverlap_C
    "assigned fault type / Fault type assignment for check DFC_rbr_isobusRegisterInstancesOverlap"
    VALUE
    0x8080632F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_isobusRegisterInstancesParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_isobusRegisterInstancesParam"
    VALUE
    0x80806330
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_isobusRegisterInstancesState_C
    "assigned fault type / Fault type assignment for check DFC_rbr_isobusRegisterInstancesState"
    VALUE
    0x80806331
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_isobusSendDataboxParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_isobusSendDataboxParam"
    VALUE
    0x80806332
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_isobusSendRequestPGNParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_isobusSendRequestPGNParam"
    VALUE
    0x80806333
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_isobusSetCaAddrCaUsed_C
    "assigned fault type / Fault type assignment for check DFC_rbr_isobusSetCaAddrCaUsed"
    VALUE
    0x80806334
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_isobusSetCaAddrComm_C
    "assigned fault type / Fault type assignment for check DFC_rbr_isobusSetCaAddrComm"
    VALUE
    0x80806335
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_isobusSetCaAddrInvCan_C
    "assigned fault type / Fault type assignment for check DFC_rbr_isobusSetCaAddrInvCan"
    VALUE
    0x80806336
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_isobusSetCaAddrParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_isobusSetCaAddrParam"
    VALUE
    0x80806337
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_isobusSetCaInfoParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_isobusSetCaInfoParam"
    VALUE
    0x80806338
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_isobusSetCaNameParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_isobusSetCaNameParam"
    VALUE
    0x80806339
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_isobusSftyCanTxErr_C
    "assigned fault type / Fault type assignment for check DFC_rbr_isobusSftyCanTxErr"
    VALUE
    0x8080633A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_lin_ReceiveSignal_C
    "assigned fault type / Fault type assignment for check DFC_rbr_lin_ReceiveSignal"
    VALUE
    0x8080633B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_lin_SendSignal_C
    "assigned fault type / Fault type assignment for check DFC_rbr_lin_SendSignal"
    VALUE
    0x8080633C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_lin_getStatus_C
    "assigned fault type / Fault type assignment for check DFC_rbr_lin_getStatus"
    VALUE
    0x8080633D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_lin_gotoSleep_C
    "assigned fault type / Fault type assignment for check DFC_rbr_lin_gotoSleep"
    VALUE
    0x8080633E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_lin_scheduleRequest_C
    "assigned fault type / Fault type assignment for check DFC_rbr_lin_scheduleRequest"
    VALUE
    0x8080633F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_lin_wakeUp_C
    "assigned fault type / Fault type assignment for check DFC_rbr_lin_wakeUp"
    VALUE
    0x80806340
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_memFlsCfgShr_C
    "assigned fault type / Fault type assignment for check DFC_rbr_memFlsCfgShr"
    VALUE
    0x80806341
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_memGetStatus_C
    "assigned fault type / Fault type assignment for check DFC_rbr_memGetStatus"
    VALUE
    0x80806342
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_memMarkBlock_C
    "assigned fault type / Fault type assignment for check DFC_rbr_memMarkBlock"
    VALUE
    0x80806343
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_memReadApi1Error_C
    "assigned fault type / Fault type assignment for check DFC_rbr_memReadApi1Error"
    VALUE
    0x80806344
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_memReadApi2Error_C
    "assigned fault type / Fault type assignment for check DFC_rbr_memReadApi2Error"
    VALUE
    0x80806345
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_memReadBlock_C
    "assigned fault type / Fault type assignment for check DFC_rbr_memReadBlock"
    VALUE
    0x80806346
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_memReadCalibInputError_C
    "assigned fault type / Fault type assignment for check DFC_rbr_memReadCalibInputError"
    VALUE
    0x80806347
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_memReadCalibOuputError_C
    "assigned fault type / Fault type assignment for check DFC_rbr_memReadCalibOuputError"
    VALUE
    0x80806348
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_memReadSystemError_C
    "assigned fault type / Fault type assignment for check DFC_rbr_memReadSystemError"
    VALUE
    0x80806349
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_memWriteBlock_C
    "assigned fault type / Fault type assignment for check DFC_rbr_memWriteBlock"
    VALUE
    0x8080634A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_moOV_FirstConstADC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_moOV_FirstConstADC"
    VALUE
    0x8080634B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_moOV_SecondConstADC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_moOV_SecondConstADC"
    VALUE
    0x8080634C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_moUV_FirstConstADC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_moUV_FirstConstADC"
    VALUE
    0x8080634D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_moUV_SecondConstADC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_moUV_SecondConstADC"
    VALUE
    0x8080634E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_INH_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_INH"
    VALUE
    0x8080634F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_INHLatch_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_INHLatch"
    VALUE
    0x80806350
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_adcPDD_fail_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_adcPDD_fail"
    VALUE
    0x80806351
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_memoryProtection_err_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_memoryProtection_err"
    VALUE
    0x80806352
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA02OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA02OC"
    VALUE
    0x80806353
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA02Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA02Unintended"
    VALUE
    0x80806354
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA03OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA03OC"
    VALUE
    0x80806355
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA03Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA03Unintended"
    VALUE
    0x80806356
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA04OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA04OC"
    VALUE
    0x80806357
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA04Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA04Unintended"
    VALUE
    0x80806358
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA05OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA05OC"
    VALUE
    0x80806359
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA05Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA05Unintended"
    VALUE
    0x8080635A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA07OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA07OC"
    VALUE
    0x8080635B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA07Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA07Unintended"
    VALUE
    0x8080635C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA08OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA08OC"
    VALUE
    0x8080635D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA08Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA08Unintended"
    VALUE
    0x8080635E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA09OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA09OC"
    VALUE
    0x8080635F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA09Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA09Unintended"
    VALUE
    0x80806360
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA10OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA10OC"
    VALUE
    0x80806361
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA10Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA10Unintended"
    VALUE
    0x80806362
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA17OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA17OC"
    VALUE
    0x80806363
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA17Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA17Unintended"
    VALUE
    0x80806364
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA18OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA18OC"
    VALUE
    0x80806365
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA18Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA18Unintended"
    VALUE
    0x80806366
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA19OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA19OC"
    VALUE
    0x80806367
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA19Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA19Unintended"
    VALUE
    0x80806368
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA20OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA20OC"
    VALUE
    0x80806369
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA20Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA20Unintended"
    VALUE
    0x8080636A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA31OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA31OC"
    VALUE
    0x8080636B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA31Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA31Unintended"
    VALUE
    0x8080636C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA32OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA32OC"
    VALUE
    0x8080636D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA32Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA32Unintended"
    VALUE
    0x8080636E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA33OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA33OC"
    VALUE
    0x8080636F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA33Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA33Unintended"
    VALUE
    0x80806370
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA34OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA34OC"
    VALUE
    0x80806371
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA34Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA34Unintended"
    VALUE
    0x80806372
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA35OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA35OC"
    VALUE
    0x80806373
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA35Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA35Unintended"
    VALUE
    0x80806374
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA46OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA46OC"
    VALUE
    0x80806375
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA46Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA46Unintended"
    VALUE
    0x80806376
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA47OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA47OC"
    VALUE
    0x80806377
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA47Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA47Unintended"
    VALUE
    0x80806378
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA48OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA48OC"
    VALUE
    0x80806379
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA48Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA48Unintended"
    VALUE
    0x8080637A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA51OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA51OC"
    VALUE
    0x8080637B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA51Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA51Unintended"
    VALUE
    0x8080637C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA52OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA52OC"
    VALUE
    0x8080637D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA52Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA52Unintended"
    VALUE
    0x8080637E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA53OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA53OC"
    VALUE
    0x8080637F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA53Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA53Unintended"
    VALUE
    0x80806380
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA54OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA54OC"
    VALUE
    0x80806381
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA54Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA54Unintended"
    VALUE
    0x80806382
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outAov_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outAov"
    VALUE
    0x80806383
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outAovCfg_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outAovCfg"
    VALUE
    0x80806384
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outAovCfgPI_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outAovCfgPI"
    VALUE
    0x80806385
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outAovGetStatus_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outAovGetStatus"
    VALUE
    0x80806386
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outAovGetVoltage_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outAovGetVoltage"
    VALUE
    0x80806387
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outAovResetError_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outAovResetError"
    VALUE
    0x80806388
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outDo_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outDo"
    VALUE
    0x80806389
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outDoCfgPwrLs_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outDoCfgPwrLs"
    VALUE
    0x8080638A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outDoDisable_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outDoDisable"
    VALUE
    0x8080638B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outDoGetCurrent_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outDoGetCurrent"
    VALUE
    0x8080638C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outDoGetStatus_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outDoGetStatus"
    VALUE
    0x8080638D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outDoResetError_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outDoResetError"
    VALUE
    0x8080638E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK07OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK07OC"
    VALUE
    0x8080638F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK07Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK07Unintended"
    VALUE
    0x80806390
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK08OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK08OC"
    VALUE
    0x80806391
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK08Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK08Unintended"
    VALUE
    0x80806392
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK09OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK09OC"
    VALUE
    0x80806393
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK09Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK09Unintended"
    VALUE
    0x80806394
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK12OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK12OC"
    VALUE
    0x80806395
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK12Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK12Unintended"
    VALUE
    0x80806396
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK13OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK13OC"
    VALUE
    0x80806397
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK13Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK13Unintended"
    VALUE
    0x80806398
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK14OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK14OC"
    VALUE
    0x80806399
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK14Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK14Unintended"
    VALUE
    0x8080639A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK15OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK15OC"
    VALUE
    0x8080639B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK15Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK15Unintended"
    VALUE
    0x8080639C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK16OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK16OC"
    VALUE
    0x8080639D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK16Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK16Unintended"
    VALUE
    0x8080639E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK17OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK17OC"
    VALUE
    0x8080639F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK17Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK17Unintended"
    VALUE
    0x808063A0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK29OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK29OC"
    VALUE
    0x808063A1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK29Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK29Unintended"
    VALUE
    0x808063A2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK51OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK51OC"
    VALUE
    0x808063A3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK51Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK51Unintended"
    VALUE
    0x808063A4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK73OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK73OC"
    VALUE
    0x808063A5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK73Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK73Unintended"
    VALUE
    0x808063A6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outPo_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outPo"
    VALUE
    0x808063A7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outPoCfg_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outPoCfg"
    VALUE
    0x808063A8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outPoCfgPeriod_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outPoCfgPeriod"
    VALUE
    0x808063A9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outPoCfgPwrLs_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outPoCfgPwrLs"
    VALUE
    0x808063AA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outPoDisable_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outPoDisable"
    VALUE
    0x808063AB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outPoGetCurrent_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outPoGetCurrent"
    VALUE
    0x808063AC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outPoGetStatus_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outPoGetStatus"
    VALUE
    0x808063AD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outPoResetError_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outPoResetError"
    VALUE
    0x808063AE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outPoc_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outPoc"
    VALUE
    0x808063AF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outPocCfg_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outPocCfg"
    VALUE
    0x808063B0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outPocCfgDither_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outPocCfgDither"
    VALUE
    0x808063B1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outPocCfgPI_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outPocCfgPI"
    VALUE
    0x808063B2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outPod_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outPod"
    VALUE
    0x808063B3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outPodCfg_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outPodCfg"
    VALUE
    0x808063B4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outPodCfgPeriod_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outPodCfgPeriod"
    VALUE
    0x808063B5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_rsmFfiApiCallErr_C
    "assigned fault type / Fault type assignment for check DFC_rbr_rsmFfiApiCallErr"
    VALUE
    0x808063B6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safout_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safout"
    VALUE
    0x808063B7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutCfg_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutCfg"
    VALUE
    0x808063B8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl1_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl1"
    VALUE
    0x808063B9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl10_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl10"
    VALUE
    0x808063BA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl10Dev_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl10Dev"
    VALUE
    0x808063BB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl10OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl10OR"
    VALUE
    0x808063BC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl11_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl11"
    VALUE
    0x808063BD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl11Dev_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl11Dev"
    VALUE
    0x808063BE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl11OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl11OR"
    VALUE
    0x808063BF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl12_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl12"
    VALUE
    0x808063C0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl12Dev_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl12Dev"
    VALUE
    0x808063C1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl12OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl12OR"
    VALUE
    0x808063C2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl13_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl13"
    VALUE
    0x808063C3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl13Dev_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl13Dev"
    VALUE
    0x808063C4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl13OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl13OR"
    VALUE
    0x808063C5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl14_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl14"
    VALUE
    0x808063C6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl14Dev_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl14Dev"
    VALUE
    0x808063C7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl14OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl14OR"
    VALUE
    0x808063C8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl15_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl15"
    VALUE
    0x808063C9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl15Dev_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl15Dev"
    VALUE
    0x808063CA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl15OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl15OR"
    VALUE
    0x808063CB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl16_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl16"
    VALUE
    0x808063CC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl16Dev_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl16Dev"
    VALUE
    0x808063CD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl16OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl16OR"
    VALUE
    0x808063CE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl17_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl17"
    VALUE
    0x808063CF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl17Dev_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl17Dev"
    VALUE
    0x808063D0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl17OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl17OR"
    VALUE
    0x808063D1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl18_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl18"
    VALUE
    0x808063D2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl18Dev_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl18Dev"
    VALUE
    0x808063D3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl18OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl18OR"
    VALUE
    0x808063D4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl1Dev_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl1Dev"
    VALUE
    0x808063D5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl1OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl1OR"
    VALUE
    0x808063D6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl2_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl2"
    VALUE
    0x808063D7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl2Dev_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl2Dev"
    VALUE
    0x808063D8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl2OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl2OR"
    VALUE
    0x808063D9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl3_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl3"
    VALUE
    0x808063DA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl3Dev_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl3Dev"
    VALUE
    0x808063DB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl3OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl3OR"
    VALUE
    0x808063DC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl4_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl4"
    VALUE
    0x808063DD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl4Dev_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl4Dev"
    VALUE
    0x808063DE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl4OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl4OR"
    VALUE
    0x808063DF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl5_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl5"
    VALUE
    0x808063E0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl5Dev_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl5Dev"
    VALUE
    0x808063E1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl5OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl5OR"
    VALUE
    0x808063E2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl6_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl6"
    VALUE
    0x808063E3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl6Dev_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl6Dev"
    VALUE
    0x808063E4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl6OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl6OR"
    VALUE
    0x808063E5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl7_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl7"
    VALUE
    0x808063E6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl7Dev_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl7Dev"
    VALUE
    0x808063E7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl7OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl7OR"
    VALUE
    0x808063E8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl8_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl8"
    VALUE
    0x808063E9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl8Dev_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl8Dev"
    VALUE
    0x808063EA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl8OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl8OR"
    VALUE
    0x808063EB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl9_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl9"
    VALUE
    0x808063EC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl9Dev_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl9Dev"
    VALUE
    0x808063ED
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl9OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl9OR"
    VALUE
    0x808063EE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutDevError_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutDevError"
    VALUE
    0x808063EF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutGetStatus_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutGetStatus"
    VALUE
    0x808063F0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutIgnoreError_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutIgnoreError"
    VALUE
    0x808063F1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutResetError_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutResetError"
    VALUE
    0x808063F2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutUnlock_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutUnlock"
    VALUE
    0x808063F3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safout_cfgDiag_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safout_cfgDiag"
    VALUE
    0x808063F4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_secAccessDenied_RC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_secAccessDenied_RC"
    VALUE
    0x808063F5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_secAccessDenied_WDBI_C
    "assigned fault type / Fault type assignment for check DFC_rbr_secAccessDenied_WDBI"
    VALUE
    0x808063F6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_secEvalRespKey_C
    "assigned fault type / Fault type assignment for check DFC_rbr_secEvalRespKey"
    VALUE
    0x808063F7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_secFlashingFailure_C
    "assigned fault type / Fault type assignment for check DFC_rbr_secFlashingFailure"
    VALUE
    0x808063F8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_secGetLevel_C
    "assigned fault type / Fault type assignment for check DFC_rbr_secGetLevel"
    VALUE
    0x808063F9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_secGetRnd_C
    "assigned fault type / Fault type assignment for check DFC_rbr_secGetRnd"
    VALUE
    0x808063FA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_secGetSeed_C
    "assigned fault type / Fault type assignment for check DFC_rbr_secGetSeed"
    VALUE
    0x808063FB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_secInvalidPassword_C
    "assigned fault type / Fault type assignment for check DFC_rbr_secInvalidPassword"
    VALUE
    0x808063FC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_secIsRequestAllowed_C
    "assigned fault type / Fault type assignment for check DFC_rbr_secIsRequestAllowed"
    VALUE
    0x808063FD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_secResetLevel_C
    "assigned fault type / Fault type assignment for check DFC_rbr_secResetLevel"
    VALUE
    0x808063FE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_secSaveSecret_C
    "assigned fault type / Fault type assignment for check DFC_rbr_secSaveSecret"
    VALUE
    0x808063FF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_secSetLevel_C
    "assigned fault type / Fault type assignment for check DFC_rbr_secSetLevel"
    VALUE
    0x80806400
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_sysAit_C
    "assigned fault type / Fault type assignment for check DFC_rbr_sysAit"
    VALUE
    0x80806401
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_sysAiv_C
    "assigned fault type / Fault type assignment for check DFC_rbr_sysAiv"
    VALUE
    0x80806402
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_sysDi_C
    "assigned fault type / Fault type assignment for check DFC_rbr_sysDi"
    VALUE
    0x80806403
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_sysDo_C
    "assigned fault type / Fault type assignment for check DFC_rbr_sysDo"
    VALUE
    0x80806404
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_sysGetVss_C
    "assigned fault type / Fault type assignment for check DFC_rbr_sysGetVss"
    VALUE
    0x80806405
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_sysInit_C
    "assigned fault type / Fault type assignment for check DFC_rbr_sysInit"
    VALUE
    0x80806406
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_sysOperHrIntegrityErr_C
    "assigned fault type / Fault type assignment for check DFC_rbr_sysOperHrIntegrityErr"
    VALUE
    0x80806407
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_sysOperHrsSaturated_C
    "assigned fault type / Fault type assignment for check DFC_rbr_sysOperHrsSaturated"
    VALUE
    0x80806408
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_sysSetVss_C
    "assigned fault type / Fault type assignment for check DFC_rbr_sysSetVss"
    VALUE
    0x80806409
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_sys_coreload_C
    "assigned fault type / Fault type assignment for check DFC_rbr_sys_coreload"
    VALUE
    0x8080640A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_sys_taskload_C
    "assigned fault type / Fault type assignment for check DFC_rbr_sys_taskload"
    VALUE
    0x8080640B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_OV_VSS1_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_OV_VSS1"
    VALUE
    0x8080640C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_OV_VSS2_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_OV_VSS2"
    VALUE
    0x8080640D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_UV_VSS1_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_UV_VSS1"
    VALUE
    0x8080640E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_UV_VSS2_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_UV_VSS2"
    VALUE
    0x8080640F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_CANSM_E_BUS_OFF_NETWORK_0_C
    "assigned fault type / Fault type assignment for check DFC_CANSM_E_BUS_OFF_NETWORK_0"
    VALUE
    0x80806410
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_CANSM_E_BUS_OFF_NETWORK_1_C
    "assigned fault type / Fault type assignment for check DFC_CANSM_E_BUS_OFF_NETWORK_1"
    VALUE
    0x80806411
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_CANSM_E_BUS_OFF_NETWORK_2_C
    "assigned fault type / Fault type assignment for check DFC_CANSM_E_BUS_OFF_NETWORK_2"
    VALUE
    0x80806412
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_CANSM_E_BUS_OFF_NETWORK_3_C
    "assigned fault type / Fault type assignment for check DFC_CANSM_E_BUS_OFF_NETWORK_3"
    VALUE
    0x80806413
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_CANTRCV_E_NO_TRCV_CONTROL_0_C
    "assigned fault type / Fault type assignment for check DFC_CANTRCV_E_NO_TRCV_CONTROL_0"
    VALUE
    0x80806414
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_CAN_E_TIMEOUT_C
    "assigned fault type / Fault type assignment for check DFC_CAN_E_TIMEOUT"
    VALUE
    0x80806415
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_COMM_E_NET_START_IND_CHANNEL_0_C
    "assigned fault type / Fault type assignment for check DFC_COMM_E_NET_START_IND_CHANNEL_0"
    VALUE
    0x80806416
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_COMM_E_NET_START_IND_CHANNEL_1_C
    "assigned fault type / Fault type assignment for check DFC_COMM_E_NET_START_IND_CHANNEL_1"
    VALUE
    0x80806417
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_COMM_E_NET_START_IND_CHANNEL_2_C
    "assigned fault type / Fault type assignment for check DFC_COMM_E_NET_START_IND_CHANNEL_2"
    VALUE
    0x80806418
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_COMM_E_NET_START_IND_CHANNEL_3_C
    "assigned fault type / Fault type assignment for check DFC_COMM_E_NET_START_IND_CHANNEL_3"
    VALUE
    0x80806419
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_COMM_E_NET_START_IND_CHANNEL_4_C
    "assigned fault type / Fault type assignment for check DFC_COMM_E_NET_START_IND_CHANNEL_4"
    VALUE
    0x8080641A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_COMM_E_NET_START_IND_CHANNEL_5_C
    "assigned fault type / Fault type assignment for check DFC_COMM_E_NET_START_IND_CHANNEL_5"
    VALUE
    0x8080641B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_LIN_E_TIMEOUT_C
    "assigned fault type / Fault type assignment for check DFC_LIN_E_TIMEOUT"
    VALUE
    0x8080641C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rba_MultiStackTrace_Threshold_C
    "assigned fault type / Fault type assignment for check DFC_rba_MultiStackTrace_Threshold"
    VALUE
    0x8080641D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_ETH_E_ACCESS_0_C
    "assigned fault type / Fault type assignment for check DFC_ETH_E_ACCESS_0"
    VALUE
    0x8080641E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_RBA_IOEXTLIB_KEEPALIVE_DRV_C
    "assigned fault type / Fault type assignment for check DFC_RBA_IOEXTLIB_KEEPALIVE_DRV"
    VALUE
    0x8080641F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_RBA_IOEXTLIB_KEEPALIVE_INI_C
    "assigned fault type / Fault type assignment for check DFC_RBA_IOEXTLIB_KEEPALIVE_INI"
    VALUE
    0x80806420
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rba_MRly_Diag_Stk_Event_C
    "assigned fault type / Fault type assignment for check DFC_rba_MRly_Diag_Stk_Event"
    VALUE
    0x80806421
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rba_MemDiagExtd_MemReadSngErr_C
    "assigned fault type / Fault type assignment for check DFC_rba_MemDiagExtd_MemReadSngErr"
    VALUE
    0x80806422
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rba_MemDiag_MemReadErr_C
    "assigned fault type / Fault type assignment for check DFC_rba_MemDiag_MemReadErr"
    VALUE
    0x80806423
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rba_MemDiag_MemWrErr_C
    "assigned fault type / Fault type assignment for check DFC_rba_MemDiag_MemWrErr"
    VALUE
    0x80806424
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rba_SyC_IrrSwOffTrigEngRun_Event_C
    "assigned fault type / Fault type assignment for check DFC_rba_SyC_IrrSwOffTrigEngRun_Event"
    VALUE
    0x80806425
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rba_T15_Diag_ComInVld_Event_C
    "assigned fault type / Fault type assignment for check DFC_rba_T15_Diag_ComInVld_Event"
    VALUE
    0x80806426
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rba_T15_Diag_ComOff_HwOn_Event_C
    "assigned fault type / Fault type assignment for check DFC_rba_T15_Diag_ComOff_HwOn_Event"
    VALUE
    0x80806427
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rba_T15_Diag_ComOn_HwOff_Event_C
    "assigned fault type / Fault type assignment for check DFC_rba_T15_Diag_ComOn_HwOff_Event"
    VALUE
    0x80806428
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM0_0_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM0_0"
    VALUE
    0x80806429
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM0_1_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM0_1"
    VALUE
    0x8080642A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM0_10_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM0_10"
    VALUE
    0x8080642B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM0_11_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM0_11"
    VALUE
    0x8080642C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM0_13_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM0_13"
    VALUE
    0x8080642D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM0_14_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM0_14"
    VALUE
    0x8080642E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM0_2_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM0_2"
    VALUE
    0x8080642F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM0_22_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM0_22"
    VALUE
    0x80806430
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM0_23_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM0_23"
    VALUE
    0x80806431
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM0_4_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM0_4"
    VALUE
    0x80806432
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM0_5_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM0_5"
    VALUE
    0x80806433
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM0_7_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM0_7"
    VALUE
    0x80806434
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM0_8_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM0_8"
    VALUE
    0x80806435
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM10_16_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM10_16"
    VALUE
    0x80806436
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM10_17_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM10_17"
    VALUE
    0x80806437
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM10_21_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM10_21"
    VALUE
    0x80806438
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM11_0_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM11_0"
    VALUE
    0x80806439
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM11_1_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM11_1"
    VALUE
    0x8080643A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM11_2_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM11_2"
    VALUE
    0x8080643B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM11_3_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM11_3"
    VALUE
    0x8080643C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM11_4_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM11_4"
    VALUE
    0x8080643D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM11_5_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM11_5"
    VALUE
    0x8080643E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM11_8_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM11_8"
    VALUE
    0x8080643F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM11_9_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM11_9"
    VALUE
    0x80806440
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM1_0_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM1_0"
    VALUE
    0x80806441
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM1_1_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM1_1"
    VALUE
    0x80806442
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM1_10_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM1_10"
    VALUE
    0x80806443
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM1_11_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM1_11"
    VALUE
    0x80806444
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM1_13_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM1_13"
    VALUE
    0x80806445
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM1_14_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM1_14"
    VALUE
    0x80806446
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM1_2_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM1_2"
    VALUE
    0x80806447
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM1_22_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM1_22"
    VALUE
    0x80806448
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM1_23_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM1_23"
    VALUE
    0x80806449
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM1_4_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM1_4"
    VALUE
    0x8080644A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM1_5_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM1_5"
    VALUE
    0x8080644B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM1_7_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM1_7"
    VALUE
    0x8080644C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM1_8_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM1_8"
    VALUE
    0x8080644D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM21_0_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM21_0"
    VALUE
    0x8080644E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM21_16_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM21_16"
    VALUE
    0x8080644F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM21_3_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM21_3"
    VALUE
    0x80806450
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM2_1_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM2_1"
    VALUE
    0x80806451
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM2_10_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM2_10"
    VALUE
    0x80806452
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM2_11_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM2_11"
    VALUE
    0x80806453
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM2_13_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM2_13"
    VALUE
    0x80806454
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM2_14_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM2_14"
    VALUE
    0x80806455
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM2_2_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM2_2"
    VALUE
    0x80806456
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM2_22_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM2_22"
    VALUE
    0x80806457
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM2_23_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM2_23"
    VALUE
    0x80806458
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM2_4_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM2_4"
    VALUE
    0x80806459
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM2_5_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM2_5"
    VALUE
    0x8080645A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM2_7_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM2_7"
    VALUE
    0x8080645B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM2_8_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM2_8"
    VALUE
    0x8080645C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM3_1_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM3_1"
    VALUE
    0x8080645D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM3_10_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM3_10"
    VALUE
    0x8080645E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM3_11_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM3_11"
    VALUE
    0x8080645F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM3_13_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM3_13"
    VALUE
    0x80806460
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM3_14_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM3_14"
    VALUE
    0x80806461
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM3_2_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM3_2"
    VALUE
    0x80806462
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM3_22_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM3_22"
    VALUE
    0x80806463
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM3_23_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM3_23"
    VALUE
    0x80806464
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM3_4_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM3_4"
    VALUE
    0x80806465
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM3_5_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM3_5"
    VALUE
    0x80806466
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM3_7_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM3_7"
    VALUE
    0x80806467
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM3_8_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM3_8"
    VALUE
    0x80806468
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM6_0_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM6_0"
    VALUE
    0x80806469
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM6_11_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM6_11"
    VALUE
    0x8080646A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM6_12_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM6_12"
    VALUE
    0x8080646B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM6_14_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM6_14"
    VALUE
    0x8080646C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM6_15_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM6_15"
    VALUE
    0x8080646D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM6_17_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM6_17"
    VALUE
    0x8080646E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM6_18_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM6_18"
    VALUE
    0x8080646F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM6_2_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM6_2"
    VALUE
    0x80806470
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM6_20_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM6_20"
    VALUE
    0x80806471
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM6_21_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM6_21"
    VALUE
    0x80806472
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM6_25_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM6_25"
    VALUE
    0x80806473
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM6_4_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM6_4"
    VALUE
    0x80806474
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM6_5_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM6_5"
    VALUE
    0x80806475
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM6_7_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM6_7"
    VALUE
    0x80806476
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM6_8_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM6_8"
    VALUE
    0x80806477
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM7_1_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM7_1"
    VALUE
    0x80806478
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM7_12_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM7_12"
    VALUE
    0x80806479
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM7_13_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM7_13"
    VALUE
    0x8080647A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM7_14_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM7_14"
    VALUE
    0x8080647B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM7_15_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM7_15"
    VALUE
    0x8080647C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM7_16_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM7_16"
    VALUE
    0x8080647D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM7_17_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM7_17"
    VALUE
    0x8080647E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM7_2_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM7_2"
    VALUE
    0x8080647F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM7_20_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM7_20"
    VALUE
    0x80806480
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM7_25_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM7_25"
    VALUE
    0x80806481
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM7_26_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM7_26"
    VALUE
    0x80806482
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM7_28_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM7_28"
    VALUE
    0x80806483
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM7_29_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM7_29"
    VALUE
    0x80806484
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM7_30_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM7_30"
    VALUE
    0x80806485
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM7_31_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM7_31"
    VALUE
    0x80806486
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM8_0_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM8_0"
    VALUE
    0x80806487
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM8_1_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM8_1"
    VALUE
    0x80806488
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM8_10_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM8_10"
    VALUE
    0x80806489
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM8_11_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM8_11"
    VALUE
    0x8080648A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM8_12_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM8_12"
    VALUE
    0x8080648B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM8_13_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM8_13"
    VALUE
    0x8080648C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM8_16_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM8_16"
    VALUE
    0x8080648D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM8_18_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM8_18"
    VALUE
    0x8080648E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM8_2_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM8_2"
    VALUE
    0x8080648F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM8_3_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM8_3"
    VALUE
    0x80806490
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM8_30_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM8_30"
    VALUE
    0x80806491
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM8_31_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM8_31"
    VALUE
    0x80806492
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM8_4_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM8_4"
    VALUE
    0x80806493
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM9_0_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM9_0"
    VALUE
    0x80806494
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM9_1_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM9_1"
    VALUE
    0x80806495
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM9_15_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM9_15"
    VALUE
    0x80806496
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM9_3_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM9_3"
    VALUE
    0x80806497
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MoCSOPICO_C
    "assigned fault type / Fault type assignment for check DFC_MoCSOPICO"
    VALUE
    0x80806498
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MoFVarPostBldSel_C
    "assigned fault type / Fault type assignment for check DFC_MoFVarPostBldSel"
    VALUE
    0x80806499
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MoSysCtrlReIni_C
    "assigned fault type / Fault type assignment for check DFC_MoSysCtrlReIni"
    VALUE
    0x8080649A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MoXEMMHwLTMCUFW_C
    "assigned fault type / Fault type assignment for check DFC_MoXEMMHwLTMCUFW"
    VALUE
    0x8080649B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MoXEMMHwLTMonBIST_C
    "assigned fault type / Fault type assignment for check DFC_MoXEMMHwLTMonBIST"
    VALUE
    0x8080649C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MoXEMMHwLTRegMonTest_C
    "assigned fault type / Fault type assignment for check DFC_MoXEMMHwLTRegMonTest"
    VALUE
    0x8080649D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MoXEMMHwLTStbySMUAlvTest_C
    "assigned fault type / Fault type assignment for check DFC_MoXEMMHwLTStbySMUAlvTest"
    VALUE
    0x8080649E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MoXEMMHwLTTempSens_C
    "assigned fault type / Fault type assignment for check DFC_MoXEMMHwLTTempSens"
    VALUE
    0x8080649F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MoXEMMHwLTUCBCfg_C
    "assigned fault type / Fault type assignment for check DFC_MoXEMMHwLTUCBCfg"
    VALUE
    0x808064A0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_OCWDAABEActv_C
    "assigned fault type / Fault type assignment for check DFC_OCWDAABEActv"
    VALUE
    0x808064A1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_OCWDACom_C
    "assigned fault type / Fault type assignment for check DFC_OCWDACom"
    VALUE
    0x808064A2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_OCWDAErrPin_C
    "assigned fault type / Fault type assignment for check DFC_OCWDAErrPin"
    VALUE
    0x808064A3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_SWReset_0_C
    "assigned fault type / Fault type assignment for check DFC_SWReset_0"
    VALUE
    0x808064A4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_SWReset_1_C
    "assigned fault type / Fault type assignment for check DFC_SWReset_1"
    VALUE
    0x808064A5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_SWReset_2_C
    "assigned fault type / Fault type assignment for check DFC_SWReset_2"
    VALUE
    0x808064A6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDebFault1_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDebFault1"
    VALUE
    0x808064A7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_MonEvtMSK0_C
    "Event filter mask of Monitoring - Mask Id mast have 0 at bit mask 0 positions"
    VALUE
    0x808012F6
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_MonEvtMSK1_C
    "Event filter mask of Monitoring - Mask Id mast have 1 at bit mask 1 positions"
    VALUE
    0x808012F8
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_MonRepeat_C
    "switch to ignore same kind of monitoring events, set to 0 to suppress identical events in a row"
    VALUE
    0x808012FA
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_numClsDlt_CA
    "Fault class parameter: Number of cycles for OBD delete counter"
    VAL_BLK
    0x808012FB
    ValA_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    
    MATRIX_DIM 4 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_numClsFaultCycl_CA
    "Fault class parameter: Number of cycles for fault counter"
    VAL_BLK
    0x808012FF
    ValA_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    
    MATRIX_DIM 4 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_numClsHealCycl_CA
    "Fault class parameter: Number of cycles for healing counter"
    VAL_BLK
    0x80801303
    ValA_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    
    MATRIX_DIM 4 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_numClsPndDlt_CA
    "Fault class parameter: Number of cycles for pending delete counter"
    VAL_BLK
    0x80801307
    ValA_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    
    MATRIX_DIM 4 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_numClsSvcDlt_CA
    "Fault class parameter: Number of cycles for delete counter"
    VAL_BLK
    0x8080130B
    ValA_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    
    MATRIX_DIM 4 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_numClsSVSFaultCycl_CA
    "Fault class parameter: Number of cycles for SVS lamp fault counter"
    VAL_BLK
    0x8080130F
    ValA_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    
    MATRIX_DIM 4 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_numClsSVSHealCycl_CA
    "Fault class parameter: Number of cycles for SVS lamp healing counter"
    VAL_BLK
    0x80801313
    ValA_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    
    MATRIX_DIM 4 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_numPDTC_C
    "Number of permanent DTCs (from 0 to configured maximum value)"
    VALUE
    0x80801317
    Val_Wu8
    4.000
    DFES_OneToOne
    0.00
    4.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_ThresSimCond.n_C
    ""
    VALUE
    0x80801318
    Val_Wu16
    16383.75
    DFES_nPID0C
    0.00
    16383.75

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_ThresSimCond.r_C
    ""
    VALUE
    0x8080131A
    Val_Wu8
    100.0
    DFES_rPID04
    0.00
    100.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_ThresSimCond.t_C
    ""
    VALUE
    0x8080131B
    Val_Wu8
    255.0
    DFES_tPID05
    -40.0
    215.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_tiDefCntr_C
    ""
    VALUE
    0x8080131C
    Val_Wu32
    65535.0000000
    DFES_tiDefCntr_compu
    0.00
    65535.0000000

    FORMAT "%13.7"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_tiDelEngRun_C
    ""
    VALUE
    0x80801320
    Val_Wu16
    65519.00
    DFES_Time_1min
    1.00
    65520.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_tiDelTstd_C
    ""
    VALUE
    0x80801322
    Val_Wu8
    1.00000000000
    DFES_Enable
    0.00
    1.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_xAsgnFrzFrDid_CA
    "Signal selection for freeze frame (DID based)"
    VAL_BLK
    0x80801326
    ValA_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    
    MATRIX_DIM 4 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_xClsDltTrg_CA
    "Fault class parameter: Trigger type for OBD delete counter"
    VAL_BLK
    0x8080132E
    ValA_Wu8
    10.
    DSMAUX_DTRGVerb
    0.00
    10.

    FORMAT "%2.0"
    
    MATRIX_DIM 4 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_xClsFaultTrg_CA
    "Fault class parameter: Trigger type for fault counter"
    VAL_BLK
    0x80801332
    ValA_Wu8
    10.
    DSMAUX_DTRGVerb
    0.00
    10.

    FORMAT "%2.0"
    
    MATRIX_DIM 4 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_xClsFltAWL_CA
    "Customer specific fault class parameter"
    VAL_BLK
    0x808070B4
    ValA_Wu8
    8.
    DFES_LampFltAWL
    0.00
    8.

    FORMAT "%2.0"
    
    MATRIX_DIM 4 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_xClsFltMIL_CA
    "Fault class parameter: MIL control"
    VAL_BLK
    0x80801336
    ValA_Wu8
    3.
    DFES_LampFltMIL
    0.00
    3.

    FORMAT "%2.0"
    
    MATRIX_DIM 4 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_xClsFltRSL_CA
    "Customer specific fault class parameter"
    VAL_BLK
    0x808070B8
    ValA_Wu8
    8.
    DFES_LampFltRSL
    0.00
    8.

    FORMAT "%2.0"
    
    MATRIX_DIM 4 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_xClsFltSVS_CA
    "Fault class parameter: SVS lamp control"
    VAL_BLK
    0x8080133A
    ValA_Wu8
    8.
    DFES_LampFltSVS
    0.00
    8.

    FORMAT "%2.0"
    
    MATRIX_DIM 4 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_xClsHealTrg_CA
    "Fault class parameter: Trigger type for healing counter"
    VAL_BLK
    0x8080133E
    ValA_Wu8
    10.
    DSMAUX_DTRGVerb
    0.00
    10.

    FORMAT "%2.0"
    
    MATRIX_DIM 4 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_xClsPndDltTrg_CA
    "Fault class parameter: Trigger type for pending delete counter"
    VAL_BLK
    0x80801342
    ValA_Wu8
    10.
    DSMAUX_DTRGVerb
    0.00
    10.

    FORMAT "%2.0"
    
    MATRIX_DIM 4 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_xClsPrio_CA
    "Fault class parameter: Static priority and tester visibility"
    VAL_BLK
    0x80801346
    ValA_Wu8
    228.000000000
    DFES_TstVisAndPrio
    3.000000000
    231.000000000

    FORMAT "%13.9"
    
    MATRIX_DIM 4 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_xClsSvcDltTrg_CA
    "Fault class parameter: Trigger type for delete counter"
    VAL_BLK
    0x8080134A
    ValA_Wu8
    10.
    DSMAUX_DTRGVerb
    0.00
    10.

    FORMAT "%2.0"
    
    MATRIX_DIM 4 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_xClsSVSFaultTrg_CA
    "Fault class parameter: Trigger type for SVS lamp fault counter"
    VAL_BLK
    0x8080134E
    ValA_Wu8
    10.
    DSMAUX_DTRGVerb
    0.00
    10.

    FORMAT "%2.0"
    
    MATRIX_DIM 4 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_xClsSVSHealTrg_CA
    "Fault class parameter: Trigger type for SVS lamp healing counter"
    VAL_BLK
    0x80801352
    ValA_Wu8
    10.
    DSMAUX_DTRGVerb
    0.00
    10.

    FORMAT "%2.0"
    
    MATRIX_DIM 4 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_xEnaHealPend_C
    ""
    VALUE
    0x80801356
    Val_Wu8
    1.00000000000
    DFES_Enable
    0.00
    1.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_xEnaHistoryPend_C
    ""
    VALUE
    0x80801357
    Val_Wu8
    1.00000000000
    DFES_Enable
    0.00
    1.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_xEnaTiDelWithFlt_C
    ""
    VALUE
    0x80801358
    Val_Wu8
    1.00000000000
    DFES_Enable
    0.00
    1.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_xSelDsplStgyMIL_C
    ""
    VALUE
    0x80801359
    Val_Wu8
    2.00000000000
    DFES_DsplStgy
    0.00
    2.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_xSelDTCTyp_C
    ""
    VALUE
    0x8080135A
    Val_Wu8
    255.000000000
    DFES_DTCTyp_Verb
    0.00
    255.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFP_UBR
    "Internal fault path number: ambient conditions"
    VALUE
    0x808073CC
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DiaActr_ElecHBrdgDiag_DbgSigId_C
    "Select H-Bridge signal to be debugged."
    VALUE
    0x8080726E
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DiaActr_ElecHBrdgDiag_DbgSigType_C
    "Select the signal type of signal to be debugged."
    VALUE
    0x80807270
    Val_Wu8
    1.00000000000
    DiaActr_ElecHBrdgDiag_DbgSigType_COMPU_VERB
    0.00
    1.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DiaActr_ElecHBrdgDiag_OlEnaSwtOff_C
    "Enable powerstage switchoff during permanent error and preliminary heal of open load error. [Relevant only if open load is configured in active \ normal drive mode]."
    VALUE
    0x80807271
    Val_Wu8
    1.00000000000
    DiaActr_ElecHBrdgDiag_OlEnaSwtOff_COMPU_VERB
    0.00
    1.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DiaActr_ElecPsDiag_DbgSigId_C
    "Signal Id to be debugged"
    VALUE
    0x80807274
    Val_Wu32
    4294967295.00
    OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DiaActr_ElecPsDiag_DbgSigTyp_C
    "Type of the output signal (PWMOut, DigOut, Pmd) to be debugged."
    VALUE
    0x80807278
    Val_Wu8
    3.00000000000
    DiaActr_ElecPsDiag_DbgSigTyp_COMPU_VERB
    0.00
    3.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DiaActr_ElecPsDiag_SigOutDurgOpenLd_C
    "Take into account Open-Load-Error for Shut-Off request."
    VALUE
    0x80807279
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_TimeInRowDebFault_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_TimeInRowDebFault"
    VAL_BLK
    0x8080135C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_EventInRowDebFault_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_EventInRowDebFault"
    VAL_BLK
    0x80801360
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_DevLibBattUHi_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_DevLibBattUHi"
    VAL_BLK
    0x80801364
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_DevLibBattULo_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_DevLibBattULo"
    VAL_BLK
    0x80801368
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_TimeUpDownDebFault_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_TimeUpDownDebFault"
    VAL_BLK
    0x8080136C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA13OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA13OR"
    VAL_BLK
    0x80801370
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA13SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA13SCB"
    VAL_BLK
    0x80801374
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA13SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA13SCG"
    VAL_BLK
    0x80801378
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA14OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA14OR"
    VAL_BLK
    0x8080137C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA14SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA14SCB"
    VAL_BLK
    0x80801380
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA14SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA14SCG"
    VAL_BLK
    0x80801384
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA21OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA21OR"
    VAL_BLK
    0x80801388
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA21SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA21SCB"
    VAL_BLK
    0x8080138C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA21SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA21SCG"
    VAL_BLK
    0x80801390
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA22OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA22OR"
    VAL_BLK
    0x80801394
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA22SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA22SCB"
    VAL_BLK
    0x80801398
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA22SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA22SCG"
    VAL_BLK
    0x8080139C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA23OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA23OR"
    VAL_BLK
    0x808013A0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA23SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA23SCB"
    VAL_BLK
    0x808013A4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA23SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA23SCG"
    VAL_BLK
    0x808013A8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA24OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA24OR"
    VAL_BLK
    0x808013AC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA24SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA24SCB"
    VAL_BLK
    0x808013B0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA24SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA24SCG"
    VAL_BLK
    0x808013B4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA25OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA25OR"
    VAL_BLK
    0x808013B8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA25SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA25SCB"
    VAL_BLK
    0x808013BC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA25SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA25SCG"
    VAL_BLK
    0x808013C0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA26OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA26OR"
    VAL_BLK
    0x808013C4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA26SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA26SCB"
    VAL_BLK
    0x808013C8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA26SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA26SCG"
    VAL_BLK
    0x808013CC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA27OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA27OR"
    VAL_BLK
    0x808013D0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA27SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA27SCB"
    VAL_BLK
    0x808013D4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA27SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA27SCG"
    VAL_BLK
    0x808013D8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA28OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA28OR"
    VAL_BLK
    0x808013DC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA28SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA28SCB"
    VAL_BLK
    0x808013E0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA28SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA28SCG"
    VAL_BLK
    0x808013E4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA29OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA29OR"
    VAL_BLK
    0x808013E8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA29SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA29SCB"
    VAL_BLK
    0x808013EC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA29SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA29SCG"
    VAL_BLK
    0x808013F0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA36AicSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA36AicSCB"
    VAL_BLK
    0x808013F4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA36AicSCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA36AicSCG"
    VAL_BLK
    0x808013F8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA36OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA36OR"
    VAL_BLK
    0x808013FC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA36SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA36SCB"
    VAL_BLK
    0x80801400
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA36SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA36SCG"
    VAL_BLK
    0x80801404
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA36ShuntSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA36ShuntSCB"
    VAL_BLK
    0x80801408
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA37AicSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA37AicSCB"
    VAL_BLK
    0x8080140C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA37AicSCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA37AicSCG"
    VAL_BLK
    0x80801410
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA37OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA37OR"
    VAL_BLK
    0x80801414
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA37SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA37SCB"
    VAL_BLK
    0x80801418
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA37SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA37SCG"
    VAL_BLK
    0x8080141C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA37ShuntSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA37ShuntSCB"
    VAL_BLK
    0x80801420
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA38AicSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA38AicSCB"
    VAL_BLK
    0x80801424
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA38AicSCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA38AicSCG"
    VAL_BLK
    0x80801428
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA38OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA38OR"
    VAL_BLK
    0x8080142C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA38SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA38SCB"
    VAL_BLK
    0x80801430
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA38SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA38SCG"
    VAL_BLK
    0x80801434
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA38ShuntSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA38ShuntSCB"
    VAL_BLK
    0x80801438
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA39AicSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA39AicSCB"
    VAL_BLK
    0x8080143C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA39AicSCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA39AicSCG"
    VAL_BLK
    0x80801440
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA39OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA39OR"
    VAL_BLK
    0x80801444
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA39SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA39SCB"
    VAL_BLK
    0x80801448
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA39SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA39SCG"
    VAL_BLK
    0x8080144C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA39ShuntSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA39ShuntSCB"
    VAL_BLK
    0x80801450
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA40OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA40OR"
    VAL_BLK
    0x80801454
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA40SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA40SCB"
    VAL_BLK
    0x80801458
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA40SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA40SCG"
    VAL_BLK
    0x8080145C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA41OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA41OR"
    VAL_BLK
    0x80801460
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA41SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA41SCB"
    VAL_BLK
    0x80801464
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA41SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA41SCG"
    VAL_BLK
    0x80801468
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA42OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA42OR"
    VAL_BLK
    0x8080146C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA42SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA42SCB"
    VAL_BLK
    0x80801470
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA42SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA42SCG"
    VAL_BLK
    0x80801474
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA43AicSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA43AicSCB"
    VAL_BLK
    0x80801478
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA43AicSCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA43AicSCG"
    VAL_BLK
    0x8080147C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA43OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA43OR"
    VAL_BLK
    0x80801480
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA43SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA43SCB"
    VAL_BLK
    0x80801484
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA43SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA43SCG"
    VAL_BLK
    0x80801488
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA43ShuntSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA43ShuntSCB"
    VAL_BLK
    0x8080148C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA44OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA44OL"
    VAL_BLK
    0x80801490
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA44SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA44SCB"
    VAL_BLK
    0x80801494
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA44SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA44SCG"
    VAL_BLK
    0x80801498
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA57OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA57OR"
    VAL_BLK
    0x8080149C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA57SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA57SCB"
    VAL_BLK
    0x808014A0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA57SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA57SCG"
    VAL_BLK
    0x808014A4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA59OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA59OL"
    VAL_BLK
    0x808014A8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA59SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA59SCB"
    VAL_BLK
    0x808014AC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA59SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA59SCG"
    VAL_BLK
    0x808014B0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK10OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK10OR"
    VAL_BLK
    0x808014B4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK10SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK10SCB"
    VAL_BLK
    0x808014B8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK10SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK10SCG"
    VAL_BLK
    0x808014BC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK11OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK11OR"
    VAL_BLK
    0x808014C0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK11SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK11SCB"
    VAL_BLK
    0x808014C4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK11SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK11SCG"
    VAL_BLK
    0x808014C8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK30AicSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK30AicSCB"
    VAL_BLK
    0x808014CC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK30AicSCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK30AicSCG"
    VAL_BLK
    0x808014D0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK30OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK30OR"
    VAL_BLK
    0x808014D4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK30SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK30SCB"
    VAL_BLK
    0x808014D8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK30SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK30SCG"
    VAL_BLK
    0x808014DC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK30ShuntSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK30ShuntSCB"
    VAL_BLK
    0x808014E0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK31OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK31OR"
    VAL_BLK
    0x808014E4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK31SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK31SCB"
    VAL_BLK
    0x808014E8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK31SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK31SCG"
    VAL_BLK
    0x808014EC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK32OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK32OR"
    VAL_BLK
    0x808014F0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK32SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK32SCB"
    VAL_BLK
    0x808014F4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK32SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK32SCG"
    VAL_BLK
    0x808014F8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK33OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK33OR"
    VAL_BLK
    0x808014FC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK33SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK33SCB"
    VAL_BLK
    0x80801500
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK33SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK33SCG"
    VAL_BLK
    0x80801504
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK34OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK34OR"
    VAL_BLK
    0x80801508
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK34SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK34SCB"
    VAL_BLK
    0x8080150C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK34SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK34SCG"
    VAL_BLK
    0x80801510
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK35OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK35OR"
    VAL_BLK
    0x80801514
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK35SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK35SCB"
    VAL_BLK
    0x80801518
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK35SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK35SCG"
    VAL_BLK
    0x8080151C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK36OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK36OR"
    VAL_BLK
    0x80801520
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK36SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK36SCB"
    VAL_BLK
    0x80801524
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK36SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK36SCG"
    VAL_BLK
    0x80801528
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK37AicSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK37AicSCB"
    VAL_BLK
    0x8080152C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK37AicSCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK37AicSCG"
    VAL_BLK
    0x80801530
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK37OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK37OR"
    VAL_BLK
    0x80801534
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK37SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK37SCB"
    VAL_BLK
    0x80801538
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK37SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK37SCG"
    VAL_BLK
    0x8080153C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK37ShuntSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK37ShuntSCB"
    VAL_BLK
    0x80801540
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK38AicSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK38AicSCB"
    VAL_BLK
    0x80801544
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK38AicSCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK38AicSCG"
    VAL_BLK
    0x80801548
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK38OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK38OR"
    VAL_BLK
    0x8080154C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK38SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK38SCB"
    VAL_BLK
    0x80801550
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK38SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK38SCG"
    VAL_BLK
    0x80801554
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK38ShuntSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK38ShuntSCB"
    VAL_BLK
    0x80801558
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK39AicSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK39AicSCB"
    VAL_BLK
    0x8080155C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK39AicSCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK39AicSCG"
    VAL_BLK
    0x80801560
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK39OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK39OR"
    VAL_BLK
    0x80801564
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK39SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK39SCB"
    VAL_BLK
    0x80801568
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK39SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK39SCG"
    VAL_BLK
    0x8080156C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK39ShuntSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK39ShuntSCB"
    VAL_BLK
    0x80801570
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK40AicSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK40AicSCB"
    VAL_BLK
    0x80801574
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK40AicSCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK40AicSCG"
    VAL_BLK
    0x80801578
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK40OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK40OR"
    VAL_BLK
    0x8080157C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK40SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK40SCB"
    VAL_BLK
    0x80801580
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK40SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK40SCG"
    VAL_BLK
    0x80801584
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK40ShuntSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK40ShuntSCB"
    VAL_BLK
    0x80801588
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK41AicSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK41AicSCB"
    VAL_BLK
    0x8080158C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK41AicSCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK41AicSCG"
    VAL_BLK
    0x80801590
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK41OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK41OR"
    VAL_BLK
    0x80801594
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK41SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK41SCB"
    VAL_BLK
    0x80801598
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK41SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK41SCG"
    VAL_BLK
    0x8080159C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK41ShuntSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK41ShuntSCB"
    VAL_BLK
    0x808015A0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK42AicSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK42AicSCB"
    VAL_BLK
    0x808015A4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK42AicSCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK42AicSCG"
    VAL_BLK
    0x808015A8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK42OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK42OR"
    VAL_BLK
    0x808015AC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK42SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK42SCB"
    VAL_BLK
    0x808015B0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK42SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK42SCG"
    VAL_BLK
    0x808015B4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK42ShuntSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK42ShuntSCB"
    VAL_BLK
    0x808015B8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK43OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK43OR"
    VAL_BLK
    0x808015BC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK43SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK43SCB"
    VAL_BLK
    0x808015C0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK43SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK43SCG"
    VAL_BLK
    0x808015C4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK44AicSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK44AicSCB"
    VAL_BLK
    0x808015C8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK44AicSCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK44AicSCG"
    VAL_BLK
    0x808015CC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK44OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK44OR"
    VAL_BLK
    0x808015D0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK44SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK44SCB"
    VAL_BLK
    0x808015D4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK44SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK44SCG"
    VAL_BLK
    0x808015D8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK44ShuntSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK44ShuntSCB"
    VAL_BLK
    0x808015DC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK45AicSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK45AicSCB"
    VAL_BLK
    0x808015E0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK45AicSCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK45AicSCG"
    VAL_BLK
    0x808015E4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK45OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK45OR"
    VAL_BLK
    0x808015E8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK45SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK45SCB"
    VAL_BLK
    0x808015EC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK45SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK45SCG"
    VAL_BLK
    0x808015F0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK45ShuntSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK45ShuntSCB"
    VAL_BLK
    0x808015F4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK52OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK52OR"
    VAL_BLK
    0x808015F8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK52SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK52SCB"
    VAL_BLK
    0x808015FC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK52SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK52SCG"
    VAL_BLK
    0x80801600
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK53OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK53OR"
    VAL_BLK
    0x80801604
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK53SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK53SCB"
    VAL_BLK
    0x80801608
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK53SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK53SCG"
    VAL_BLK
    0x8080160C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK54AicSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK54AicSCB"
    VAL_BLK
    0x80801610
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK54AicSCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK54AicSCG"
    VAL_BLK
    0x80801614
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK54OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK54OR"
    VAL_BLK
    0x80801618
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK54SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK54SCB"
    VAL_BLK
    0x8080161C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK54SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK54SCG"
    VAL_BLK
    0x80801620
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK54ShuntSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK54ShuntSCB"
    VAL_BLK
    0x80801624
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK55AicSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK55AicSCB"
    VAL_BLK
    0x80801628
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK55AicSCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK55AicSCG"
    VAL_BLK
    0x8080162C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK55OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK55OR"
    VAL_BLK
    0x80801630
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK55SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK55SCB"
    VAL_BLK
    0x80801634
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK55SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK55SCG"
    VAL_BLK
    0x80801638
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK55ShuntSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK55ShuntSCB"
    VAL_BLK
    0x8080163C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK56OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK56OR"
    VAL_BLK
    0x80801640
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK56SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK56SCB"
    VAL_BLK
    0x80801644
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK56SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK56SCG"
    VAL_BLK
    0x80801648
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK57OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK57OR"
    VAL_BLK
    0x8080164C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK57SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK57SCB"
    VAL_BLK
    0x80801650
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK57SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK57SCG"
    VAL_BLK
    0x80801654
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK58OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK58OR"
    VAL_BLK
    0x80801658
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK58SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK58SCB"
    VAL_BLK
    0x8080165C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK58SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK58SCG"
    VAL_BLK
    0x80801660
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK59OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK59OR"
    VAL_BLK
    0x80801664
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK59SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK59SCB"
    VAL_BLK
    0x80801668
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK59SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK59SCG"
    VAL_BLK
    0x8080166C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK60OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK60OR"
    VAL_BLK
    0x80801670
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK60SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK60SCB"
    VAL_BLK
    0x80801674
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK60SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK60SCG"
    VAL_BLK
    0x80801678
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK61AicSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK61AicSCB"
    VAL_BLK
    0x8080167C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK61AicSCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK61AicSCG"
    VAL_BLK
    0x80801680
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK61OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK61OR"
    VAL_BLK
    0x80801684
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK61SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK61SCB"
    VAL_BLK
    0x80801688
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK61SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK61SCG"
    VAL_BLK
    0x8080168C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK61ShuntSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK61ShuntSCB"
    VAL_BLK
    0x80801690
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK62OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK62OR"
    VAL_BLK
    0x80801694
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK62SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK62SCB"
    VAL_BLK
    0x80801698
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK62SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK62SCG"
    VAL_BLK
    0x8080169C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK63AicSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK63AicSCB"
    VAL_BLK
    0x808016A0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK63AicSCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK63AicSCG"
    VAL_BLK
    0x808016A4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK63OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK63OR"
    VAL_BLK
    0x808016A8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK63SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK63SCB"
    VAL_BLK
    0x808016AC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK63SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK63SCG"
    VAL_BLK
    0x808016B0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK63ShuntSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK63ShuntSCB"
    VAL_BLK
    0x808016B4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK64AicSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK64AicSCB"
    VAL_BLK
    0x808016B8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK64AicSCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK64AicSCG"
    VAL_BLK
    0x808016BC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK64OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK64OR"
    VAL_BLK
    0x808016C0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK64SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK64SCB"
    VAL_BLK
    0x808016C4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK64SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK64SCG"
    VAL_BLK
    0x808016C8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK64ShuntSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK64ShuntSCB"
    VAL_BLK
    0x808016CC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK65AicSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK65AicSCB"
    VAL_BLK
    0x808016D0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK65AicSCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK65AicSCG"
    VAL_BLK
    0x808016D4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK65OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK65OR"
    VAL_BLK
    0x808016D8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK65SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK65SCB"
    VAL_BLK
    0x808016DC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK65SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK65SCG"
    VAL_BLK
    0x808016E0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK65ShuntSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK65ShuntSCB"
    VAL_BLK
    0x808016E4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK74OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK74OR"
    VAL_BLK
    0x808016E8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK74SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK74SCB"
    VAL_BLK
    0x808016EC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK74SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK74SCG"
    VAL_BLK
    0x808016F0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK75OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK75OR"
    VAL_BLK
    0x808016F4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK75SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK75SCB"
    VAL_BLK
    0x808016F8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK75SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK75SCG"
    VAL_BLK
    0x808016FC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK76OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK76OR"
    VAL_BLK
    0x80801700
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK76SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK76SCB"
    VAL_BLK
    0x80801704
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK76SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK76SCG"
    VAL_BLK
    0x80801708
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK77OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK77OR"
    VAL_BLK
    0x8080170C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK77SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK77SCB"
    VAL_BLK
    0x80801710
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK77SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK77SCG"
    VAL_BLK
    0x80801714
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK78OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK78OR"
    VAL_BLK
    0x80801718
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK78SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK78SCB"
    VAL_BLK
    0x8080171C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK78SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK78SCG"
    VAL_BLK
    0x80801720
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_DvUBAT_FWs_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_DvUBAT_FWs"
    VAL_BLK
    0x80801724
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_OVErr_VPR6_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_OVErr_VPR6"
    VAL_BLK
    0x80801728
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_OVWarn_VPR6_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_OVWarn_VPR6"
    VAL_BLK
    0x8080172C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3"
    VAL_BLK
    0x80801730
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2"
    VAL_BLK
    0x80801734
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_OV_UBAT_MON_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_OV_UBAT_MON"
    VAL_BLK
    0x80801738
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_OV_UBRM24_FLEXIN_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_OV_UBRM24_FLEXIN"
    VAL_BLK
    0x8080173C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_OV_UBRM24_LOADS_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_OV_UBRM24_LOADS"
    VAL_BLK
    0x80801740
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_OV_UBRM24_MON_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_OV_UBRM24_MON"
    VAL_BLK
    0x80801744
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_OV_VDD5_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_OV_VDD5"
    VAL_BLK
    0x80801748
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_OV_VDD5_IN_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_OV_VDD5_IN"
    VAL_BLK
    0x8080174C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_OV_VPR6_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_OV_VPR6"
    VAL_BLK
    0x80801750
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_OV_VSS3_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_OV_VSS3"
    VAL_BLK
    0x80801754
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_OV_VSS4_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_OV_VSS4"
    VAL_BLK
    0x80801758
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_Temp1_HTErr_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_Temp1_HTErr"
    VAL_BLK
    0x8080175C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_Temp1_HTWarn_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_Temp1_HTWarn"
    VAL_BLK
    0x80801760
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_Temp2_HTErr_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_Temp2_HTErr"
    VAL_BLK
    0x80801764
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_Temp2_HTWarn_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_Temp2_HTWarn"
    VAL_BLK
    0x80801768
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3"
    VAL_BLK
    0x8080176C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2"
    VAL_BLK
    0x80801770
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_UV_VDD5_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_UV_VDD5"
    VAL_BLK
    0x80801774
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_UV_VDD5_IN_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_UV_VDD5_IN"
    VAL_BLK
    0x80801778
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_UV_VPR6_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_UV_VPR6"
    VAL_BLK
    0x8080177C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_UV_VSS3_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_UV_VSS3"
    VAL_BLK
    0x80801780
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_UV_VSS4_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_UV_VSS4"
    VAL_BLK
    0x80801784
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA01OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA01OL"
    VAL_BLK
    0x80801788
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA01OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA01OT"
    VAL_BLK
    0x8080178C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA01SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA01SCB"
    VAL_BLK
    0x80801790
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA01SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA01SCG"
    VAL_BLK
    0x80801794
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA02OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA02OL"
    VAL_BLK
    0x80801798
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA02OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA02OR"
    VAL_BLK
    0x8080179C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA02OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA02OT"
    VAL_BLK
    0x808017A0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA02SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA02SCB"
    VAL_BLK
    0x808017A4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA02SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA02SCG"
    VAL_BLK
    0x808017A8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA03OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA03OL"
    VAL_BLK
    0x808017AC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA03OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA03OT"
    VAL_BLK
    0x808017B0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA03SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA03SCB"
    VAL_BLK
    0x808017B4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA03SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA03SCG"
    VAL_BLK
    0x808017B8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA04OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA04OL"
    VAL_BLK
    0x808017BC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA04OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA04OT"
    VAL_BLK
    0x808017C0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA04SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA04SCB"
    VAL_BLK
    0x808017C4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA04SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA04SCG"
    VAL_BLK
    0x808017C8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA05OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA05OL"
    VAL_BLK
    0x808017CC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA05OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA05OR"
    VAL_BLK
    0x808017D0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA05OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA05OT"
    VAL_BLK
    0x808017D4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA05SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA05SCB"
    VAL_BLK
    0x808017D8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA05SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA05SCG"
    VAL_BLK
    0x808017DC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA06OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA06OL"
    VAL_BLK
    0x808017E0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA06OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA06OR"
    VAL_BLK
    0x808017E4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA06OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA06OT"
    VAL_BLK
    0x808017E8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA06SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA06SCB"
    VAL_BLK
    0x808017EC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA06SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA06SCG"
    VAL_BLK
    0x808017F0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA07OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA07OL"
    VAL_BLK
    0x808017F4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA07OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA07OT"
    VAL_BLK
    0x808017F8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA07SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA07SCB"
    VAL_BLK
    0x808017FC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA07SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA07SCG"
    VAL_BLK
    0x80801800
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA08OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA08OL"
    VAL_BLK
    0x80801804
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA08OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA08OT"
    VAL_BLK
    0x80801808
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA08SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA08SCB"
    VAL_BLK
    0x8080180C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA08SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA08SCG"
    VAL_BLK
    0x80801810
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA09OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA09OL"
    VAL_BLK
    0x80801814
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA09OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA09OR"
    VAL_BLK
    0x80801818
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA09OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA09OT"
    VAL_BLK
    0x8080181C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA09SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA09SCB"
    VAL_BLK
    0x80801820
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA09SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA09SCG"
    VAL_BLK
    0x80801824
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA10OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA10OL"
    VAL_BLK
    0x80801828
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA10OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA10OT"
    VAL_BLK
    0x8080182C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA10SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA10SCB"
    VAL_BLK
    0x80801830
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA10SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA10SCG"
    VAL_BLK
    0x80801834
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA11OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA11OL"
    VAL_BLK
    0x80801838
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA11OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA11OT"
    VAL_BLK
    0x8080183C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA11SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA11SCB"
    VAL_BLK
    0x80801840
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA11SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA11SCG"
    VAL_BLK
    0x80801844
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA12OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA12OR"
    VAL_BLK
    0x80801848
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA12SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA12SCB"
    VAL_BLK
    0x8080184C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA12SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA12SCG"
    VAL_BLK
    0x80801850
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA16OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA16OL"
    VAL_BLK
    0x80801854
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA16OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA16OT"
    VAL_BLK
    0x80801858
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA16SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA16SCB"
    VAL_BLK
    0x8080185C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA16SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA16SCG"
    VAL_BLK
    0x80801860
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA17OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA17OL"
    VAL_BLK
    0x80801864
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA17OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA17OR"
    VAL_BLK
    0x80801868
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA17OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA17OT"
    VAL_BLK
    0x8080186C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA17SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA17SCB"
    VAL_BLK
    0x80801870
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA17SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA17SCG"
    VAL_BLK
    0x80801874
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA18OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA18OL"
    VAL_BLK
    0x80801878
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA18OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA18OT"
    VAL_BLK
    0x8080187C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA18SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA18SCB"
    VAL_BLK
    0x80801880
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA18SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA18SCG"
    VAL_BLK
    0x80801884
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA19OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA19OL"
    VAL_BLK
    0x80801888
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA19OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA19OR"
    VAL_BLK
    0x8080188C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA19OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA19OT"
    VAL_BLK
    0x80801890
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA19SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA19SCB"
    VAL_BLK
    0x80801894
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA19SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA19SCG"
    VAL_BLK
    0x80801898
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA20OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA20OL"
    VAL_BLK
    0x8080189C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA20OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA20OR"
    VAL_BLK
    0x808018A0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA20OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA20OT"
    VAL_BLK
    0x808018A4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA20SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA20SCB"
    VAL_BLK
    0x808018A8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA20SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA20SCG"
    VAL_BLK
    0x808018AC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA31OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA31OL"
    VAL_BLK
    0x808018B0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA31OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA31OR"
    VAL_BLK
    0x808018B4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA31OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA31OT"
    VAL_BLK
    0x808018B8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA31SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA31SCB"
    VAL_BLK
    0x808018BC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA31SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA31SCG"
    VAL_BLK
    0x808018C0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA32OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA32OL"
    VAL_BLK
    0x808018C4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA32OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA32OR"
    VAL_BLK
    0x808018C8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA32OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA32OT"
    VAL_BLK
    0x808018CC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA32SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA32SCB"
    VAL_BLK
    0x808018D0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA32SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA32SCG"
    VAL_BLK
    0x808018D4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA33OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA33OL"
    VAL_BLK
    0x808018D8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA33OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA33OR"
    VAL_BLK
    0x808018DC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA33OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA33OT"
    VAL_BLK
    0x808018E0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA33SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA33SCB"
    VAL_BLK
    0x808018E4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA33SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA33SCG"
    VAL_BLK
    0x808018E8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA34OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA34OL"
    VAL_BLK
    0x808018EC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA34OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA34OR"
    VAL_BLK
    0x808018F0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA34OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA34OT"
    VAL_BLK
    0x808018F4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA34SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA34SCB"
    VAL_BLK
    0x808018F8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA34SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA34SCG"
    VAL_BLK
    0x808018FC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA35OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA35OL"
    VAL_BLK
    0x80801900
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA35OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA35OR"
    VAL_BLK
    0x80801904
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA35OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA35OT"
    VAL_BLK
    0x80801908
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA35SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA35SCB"
    VAL_BLK
    0x8080190C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA35SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA35SCG"
    VAL_BLK
    0x80801910
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA46OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA46OL"
    VAL_BLK
    0x80801914
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA46OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA46OR"
    VAL_BLK
    0x80801918
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA46OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA46OT"
    VAL_BLK
    0x8080191C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA46SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA46SCB"
    VAL_BLK
    0x80801920
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA46SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA46SCG"
    VAL_BLK
    0x80801924
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA47OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA47OL"
    VAL_BLK
    0x80801928
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA47OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA47OR"
    VAL_BLK
    0x8080192C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA47OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA47OT"
    VAL_BLK
    0x80801930
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA47SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA47SCB"
    VAL_BLK
    0x80801934
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA47SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA47SCG"
    VAL_BLK
    0x80801938
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA48OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA48OL"
    VAL_BLK
    0x8080193C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA48OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA48OR"
    VAL_BLK
    0x80801940
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA48OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA48OT"
    VAL_BLK
    0x80801944
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA48SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA48SCB"
    VAL_BLK
    0x80801948
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA48SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA48SCG"
    VAL_BLK
    0x8080194C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA49OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA49OL"
    VAL_BLK
    0x80801950
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA49OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA49OT"
    VAL_BLK
    0x80801954
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA49SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA49SCB"
    VAL_BLK
    0x80801958
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA49SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA49SCG"
    VAL_BLK
    0x8080195C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA50OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA50OL"
    VAL_BLK
    0x80801960
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA50OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA50OT"
    VAL_BLK
    0x80801964
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA50SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA50SCB"
    VAL_BLK
    0x80801968
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA50SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA50SCG"
    VAL_BLK
    0x8080196C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA51OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA51OL"
    VAL_BLK
    0x80801970
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA51OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA51OR"
    VAL_BLK
    0x80801974
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA51OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA51OT"
    VAL_BLK
    0x80801978
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA51SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA51SCB"
    VAL_BLK
    0x8080197C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA51SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA51SCG"
    VAL_BLK
    0x80801980
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA52OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA52OL"
    VAL_BLK
    0x80801984
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA52OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA52OR"
    VAL_BLK
    0x80801988
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA52OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA52OT"
    VAL_BLK
    0x8080198C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA52SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA52SCB"
    VAL_BLK
    0x80801990
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA52SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA52SCG"
    VAL_BLK
    0x80801994
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA53OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA53OL"
    VAL_BLK
    0x80801998
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA53OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA53OR"
    VAL_BLK
    0x8080199C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA53OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA53OT"
    VAL_BLK
    0x808019A0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA53SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA53SCB"
    VAL_BLK
    0x808019A4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA53SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA53SCG"
    VAL_BLK
    0x808019A8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA54OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA54OL"
    VAL_BLK
    0x808019AC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA54OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA54OR"
    VAL_BLK
    0x808019B0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA54OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA54OT"
    VAL_BLK
    0x808019B4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA54SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA54SCB"
    VAL_BLK
    0x808019B8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA54SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA54SCG"
    VAL_BLK
    0x808019BC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA55OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA55OL"
    VAL_BLK
    0x808019C0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA55OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA55OT"
    VAL_BLK
    0x808019C4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA55SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA55SCB"
    VAL_BLK
    0x808019C8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA55SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA55SCG"
    VAL_BLK
    0x808019CC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA56OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA56OL"
    VAL_BLK
    0x808019D0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA56OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA56OT"
    VAL_BLK
    0x808019D4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA56SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA56SCB"
    VAL_BLK
    0x808019D8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA56SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA56SCG"
    VAL_BLK
    0x808019DC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA58OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA58OL"
    VAL_BLK
    0x808019E0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA58OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA58OT"
    VAL_BLK
    0x808019E4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA58SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA58SCB"
    VAL_BLK
    0x808019E8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA58SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA58SCG"
    VAL_BLK
    0x808019EC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK07OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK07OL"
    VAL_BLK
    0x808019F0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK07OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK07OR"
    VAL_BLK
    0x808019F4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK07OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK07OT"
    VAL_BLK
    0x808019F8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK07SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK07SCB"
    VAL_BLK
    0x808019FC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK07SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK07SCG"
    VAL_BLK
    0x80801A00
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK08OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK08OL"
    VAL_BLK
    0x80801A04
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK08OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK08OR"
    VAL_BLK
    0x80801A08
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK08OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK08OT"
    VAL_BLK
    0x80801A0C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK08SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK08SCB"
    VAL_BLK
    0x80801A10
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK08SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK08SCG"
    VAL_BLK
    0x80801A14
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK09OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK09OL"
    VAL_BLK
    0x80801A18
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK09OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK09OR"
    VAL_BLK
    0x80801A1C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK09OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK09OT"
    VAL_BLK
    0x80801A20
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK09SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK09SCB"
    VAL_BLK
    0x80801A24
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK09SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK09SCG"
    VAL_BLK
    0x80801A28
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK12OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK12OL"
    VAL_BLK
    0x80801A2C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK12OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK12OT"
    VAL_BLK
    0x80801A30
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK12SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK12SCB"
    VAL_BLK
    0x80801A34
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK12SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK12SCG"
    VAL_BLK
    0x80801A38
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK13OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK13OL"
    VAL_BLK
    0x80801A3C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK13OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK13OT"
    VAL_BLK
    0x80801A40
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK13SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK13SCB"
    VAL_BLK
    0x80801A44
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK13SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK13SCG"
    VAL_BLK
    0x80801A48
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK14OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK14OL"
    VAL_BLK
    0x80801A4C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK14OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK14OR"
    VAL_BLK
    0x80801A50
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK14OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK14OT"
    VAL_BLK
    0x80801A54
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK14SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK14SCB"
    VAL_BLK
    0x80801A58
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK14SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK14SCG"
    VAL_BLK
    0x80801A5C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

