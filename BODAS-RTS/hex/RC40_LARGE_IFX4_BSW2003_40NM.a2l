    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA27SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA27SCG"
    VALUE
    0x80800B34
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA28OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA28OR"
    VALUE
    0x80800B35
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA28SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA28SCB"
    VALUE
    0x80800B36
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA28SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA28SCG"
    VALUE
    0x80800B37
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA29OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA29OR"
    VALUE
    0x80800B38
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA29SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA29SCB"
    VALUE
    0x80800B39
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA29SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA29SCG"
    VALUE
    0x80800B3A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA36AicSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA36AicSCB"
    VALUE
    0x80800B3B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA36AicSCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA36AicSCG"
    VALUE
    0x80800B3C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA36OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA36OR"
    VALUE
    0x80800B3D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA36SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA36SCB"
    VALUE
    0x80800B3E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA36SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA36SCG"
    VALUE
    0x80800B3F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA36ShuntSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA36ShuntSCB"
    VALUE
    0x80800B40
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA37AicSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA37AicSCB"
    VALUE
    0x80800B41
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA37AicSCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA37AicSCG"
    VALUE
    0x80800B42
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA37OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA37OR"
    VALUE
    0x80800B43
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA37SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA37SCB"
    VALUE
    0x80800B44
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA37SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA37SCG"
    VALUE
    0x80800B45
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA37ShuntSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA37ShuntSCB"
    VALUE
    0x80800B46
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA38AicSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA38AicSCB"
    VALUE
    0x80800B47
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA38AicSCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA38AicSCG"
    VALUE
    0x80800B48
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA38OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA38OR"
    VALUE
    0x80800B49
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA38SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA38SCB"
    VALUE
    0x80800B4A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA38SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA38SCG"
    VALUE
    0x80800B4B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA38ShuntSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA38ShuntSCB"
    VALUE
    0x80800B4C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA39AicSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA39AicSCB"
    VALUE
    0x80800B4D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA39AicSCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA39AicSCG"
    VALUE
    0x80800B4E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA39OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA39OR"
    VALUE
    0x80800B4F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA39SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA39SCB"
    VALUE
    0x80800B50
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA39SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA39SCG"
    VALUE
    0x80800B51
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA39ShuntSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA39ShuntSCB"
    VALUE
    0x80800B52
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA40OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA40OR"
    VALUE
    0x80800B53
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA40SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA40SCB"
    VALUE
    0x80800B54
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA40SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA40SCG"
    VALUE
    0x80800B55
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA41OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA41OR"
    VALUE
    0x80800B56
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA41SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA41SCB"
    VALUE
    0x80800B57
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA41SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA41SCG"
    VALUE
    0x80800B58
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA42OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA42OR"
    VALUE
    0x80800B59
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA42SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA42SCB"
    VALUE
    0x80800B5A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA42SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA42SCG"
    VALUE
    0x80800B5B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA43AicSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA43AicSCB"
    VALUE
    0x80800B5C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA43AicSCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA43AicSCG"
    VALUE
    0x80800B5D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA43OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA43OR"
    VALUE
    0x80800B5E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA43SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA43SCB"
    VALUE
    0x80800B5F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA43SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA43SCG"
    VALUE
    0x80800B60
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA43ShuntSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA43ShuntSCB"
    VALUE
    0x80800B61
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA44OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA44OL"
    VALUE
    0x80800B62
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA44SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA44SCB"
    VALUE
    0x80800B63
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA44SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA44SCG"
    VALUE
    0x80800B64
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA57OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA57OR"
    VALUE
    0x80800B65
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA57SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA57SCB"
    VALUE
    0x80800B66
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA57SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA57SCG"
    VALUE
    0x80800B67
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA59OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA59OL"
    VALUE
    0x80800B68
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA59SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA59SCB"
    VALUE
    0x80800B69
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA59SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA59SCG"
    VALUE
    0x80800B6A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK10OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK10OR"
    VALUE
    0x80800B6B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK10SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK10SCB"
    VALUE
    0x80800B6C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK10SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK10SCG"
    VALUE
    0x80800B6D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK11OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK11OR"
    VALUE
    0x80800B6E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK11SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK11SCB"
    VALUE
    0x80800B6F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK11SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK11SCG"
    VALUE
    0x80800B70
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK30AicSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK30AicSCB"
    VALUE
    0x80800B71
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK30AicSCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK30AicSCG"
    VALUE
    0x80800B72
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK30OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK30OR"
    VALUE
    0x80800B73
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK30SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK30SCB"
    VALUE
    0x80800B74
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK30SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK30SCG"
    VALUE
    0x80800B75
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK30ShuntSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK30ShuntSCB"
    VALUE
    0x80800B76
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK31OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK31OR"
    VALUE
    0x80800B77
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK31SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK31SCB"
    VALUE
    0x80800B78
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK31SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK31SCG"
    VALUE
    0x80800B79
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK32OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK32OR"
    VALUE
    0x80800B7A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK32SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK32SCB"
    VALUE
    0x80800B7B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK32SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK32SCG"
    VALUE
    0x80800B7C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK33OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK33OR"
    VALUE
    0x80800B7D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK33SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK33SCB"
    VALUE
    0x80800B7E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK33SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK33SCG"
    VALUE
    0x80800B7F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK34OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK34OR"
    VALUE
    0x80800B80
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK34SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK34SCB"
    VALUE
    0x80800B81
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK34SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK34SCG"
    VALUE
    0x80800B82
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK35OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK35OR"
    VALUE
    0x80800B83
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK35SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK35SCB"
    VALUE
    0x80800B84
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK35SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK35SCG"
    VALUE
    0x80800B85
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK36OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK36OR"
    VALUE
    0x80800B86
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK36SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK36SCB"
    VALUE
    0x80800B87
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK36SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK36SCG"
    VALUE
    0x80800B88
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK37AicSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK37AicSCB"
    VALUE
    0x80800B89
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK37AicSCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK37AicSCG"
    VALUE
    0x80800B8A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK37OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK37OR"
    VALUE
    0x80800B8B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK37SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK37SCB"
    VALUE
    0x80800B8C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK37SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK37SCG"
    VALUE
    0x80800B8D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK37ShuntSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK37ShuntSCB"
    VALUE
    0x80800B8E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK38AicSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK38AicSCB"
    VALUE
    0x80800B8F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK38AicSCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK38AicSCG"
    VALUE
    0x80800B90
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK38OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK38OR"
    VALUE
    0x80800B91
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK38SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK38SCB"
    VALUE
    0x80800B92
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK38SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK38SCG"
    VALUE
    0x80800B93
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK38ShuntSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK38ShuntSCB"
    VALUE
    0x80800B94
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK39AicSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK39AicSCB"
    VALUE
    0x80800B95
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK39AicSCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK39AicSCG"
    VALUE
    0x80800B96
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK39OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK39OR"
    VALUE
    0x80800B97
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK39SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK39SCB"
    VALUE
    0x80800B98
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK39SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK39SCG"
    VALUE
    0x80800B99
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK39ShuntSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK39ShuntSCB"
    VALUE
    0x80800B9A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK40AicSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK40AicSCB"
    VALUE
    0x80800B9B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK40AicSCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK40AicSCG"
    VALUE
    0x80800B9C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK40OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK40OR"
    VALUE
    0x80800B9D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK40SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK40SCB"
    VALUE
    0x80800B9E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK40SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK40SCG"
    VALUE
    0x80800B9F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK40ShuntSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK40ShuntSCB"
    VALUE
    0x80800BA0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK41AicSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK41AicSCB"
    VALUE
    0x80800BA1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK41AicSCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK41AicSCG"
    VALUE
    0x80800BA2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK41OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK41OR"
    VALUE
    0x80800BA3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK41SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK41SCB"
    VALUE
    0x80800BA4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK41SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK41SCG"
    VALUE
    0x80800BA5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK41ShuntSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK41ShuntSCB"
    VALUE
    0x80800BA6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK42AicSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK42AicSCB"
    VALUE
    0x80800BA7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK42AicSCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK42AicSCG"
    VALUE
    0x80800BA8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK42OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK42OR"
    VALUE
    0x80800BA9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK42SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK42SCB"
    VALUE
    0x80800BAA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK42SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK42SCG"
    VALUE
    0x80800BAB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK42ShuntSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK42ShuntSCB"
    VALUE
    0x80800BAC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK43OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK43OR"
    VALUE
    0x80800BAD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK43SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK43SCB"
    VALUE
    0x80800BAE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK43SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK43SCG"
    VALUE
    0x80800BAF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK44AicSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK44AicSCB"
    VALUE
    0x80800BB0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK44AicSCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK44AicSCG"
    VALUE
    0x80800BB1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK44OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK44OR"
    VALUE
    0x80800BB2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK44SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK44SCB"
    VALUE
    0x80800BB3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK44SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK44SCG"
    VALUE
    0x80800BB4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK44ShuntSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK44ShuntSCB"
    VALUE
    0x80800BB5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK45AicSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK45AicSCB"
    VALUE
    0x80800BB6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK45AicSCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK45AicSCG"
    VALUE
    0x80800BB7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK45OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK45OR"
    VALUE
    0x80800BB8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK45SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK45SCB"
    VALUE
    0x80800BB9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK45SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK45SCG"
    VALUE
    0x80800BBA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK45ShuntSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK45ShuntSCB"
    VALUE
    0x80800BBB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK52OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK52OR"
    VALUE
    0x80800BBC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK52SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK52SCB"
    VALUE
    0x80800BBD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK52SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK52SCG"
    VALUE
    0x80800BBE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK53OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK53OR"
    VALUE
    0x80800BBF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK53SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK53SCB"
    VALUE
    0x80800BC0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK53SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK53SCG"
    VALUE
    0x80800BC1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK54AicSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK54AicSCB"
    VALUE
    0x80800BC2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK54AicSCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK54AicSCG"
    VALUE
    0x80800BC3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK54OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK54OR"
    VALUE
    0x80800BC4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK54SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK54SCB"
    VALUE
    0x80800BC5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK54SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK54SCG"
    VALUE
    0x80800BC6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK54ShuntSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK54ShuntSCB"
    VALUE
    0x80800BC7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK55AicSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK55AicSCB"
    VALUE
    0x80800BC8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK55AicSCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK55AicSCG"
    VALUE
    0x80800BC9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK55OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK55OR"
    VALUE
    0x80800BCA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK55SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK55SCB"
    VALUE
    0x80800BCB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK55SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK55SCG"
    VALUE
    0x80800BCC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK55ShuntSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK55ShuntSCB"
    VALUE
    0x80800BCD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK56OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK56OR"
    VALUE
    0x80800BCE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK56SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK56SCB"
    VALUE
    0x80800BCF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK56SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK56SCG"
    VALUE
    0x80800BD0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK57OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK57OR"
    VALUE
    0x80800BD1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK57SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK57SCB"
    VALUE
    0x80800BD2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK57SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK57SCG"
    VALUE
    0x80800BD3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK58OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK58OR"
    VALUE
    0x80800BD4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK58SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK58SCB"
    VALUE
    0x80800BD5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK58SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK58SCG"
    VALUE
    0x80800BD6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK59OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK59OR"
    VALUE
    0x80800BD7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK59SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK59SCB"
    VALUE
    0x80800BD8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK59SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK59SCG"
    VALUE
    0x80800BD9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK60OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK60OR"
    VALUE
    0x80800BDA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK60SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK60SCB"
    VALUE
    0x80800BDB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK60SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK60SCG"
    VALUE
    0x80800BDC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK61AicSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK61AicSCB"
    VALUE
    0x80800BDD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK61AicSCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK61AicSCG"
    VALUE
    0x80800BDE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK61OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK61OR"
    VALUE
    0x80800BDF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK61SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK61SCB"
    VALUE
    0x80800BE0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK61SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK61SCG"
    VALUE
    0x80800BE1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK61ShuntSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK61ShuntSCB"
    VALUE
    0x80800BE2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK62OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK62OR"
    VALUE
    0x80800BE3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK62SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK62SCB"
    VALUE
    0x80800BE4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK62SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK62SCG"
    VALUE
    0x80800BE5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK63AicSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK63AicSCB"
    VALUE
    0x80800BE6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK63AicSCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK63AicSCG"
    VALUE
    0x80800BE7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK63OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK63OR"
    VALUE
    0x80800BE8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK63SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK63SCB"
    VALUE
    0x80800BE9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK63SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK63SCG"
    VALUE
    0x80800BEA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK63ShuntSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK63ShuntSCB"
    VALUE
    0x80800BEB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK64AicSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK64AicSCB"
    VALUE
    0x80800BEC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK64AicSCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK64AicSCG"
    VALUE
    0x80800BED
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK64OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK64OR"
    VALUE
    0x80800BEE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK64SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK64SCB"
    VALUE
    0x80800BEF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK64SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK64SCG"
    VALUE
    0x80800BF0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK64ShuntSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK64ShuntSCB"
    VALUE
    0x80800BF1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK65AicSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK65AicSCB"
    VALUE
    0x80800BF2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK65AicSCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK65AicSCG"
    VALUE
    0x80800BF3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK65OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK65OR"
    VALUE
    0x80800BF4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK65SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK65SCB"
    VALUE
    0x80800BF5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK65SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK65SCG"
    VALUE
    0x80800BF6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK65ShuntSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK65ShuntSCB"
    VALUE
    0x80800BF7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK74OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK74OR"
    VALUE
    0x80800BF8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK74SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK74SCB"
    VALUE
    0x80800BF9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK74SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK74SCG"
    VALUE
    0x80800BFA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK75OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK75OR"
    VALUE
    0x80800BFB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK75SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK75SCB"
    VALUE
    0x80800BFC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK75SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK75SCG"
    VALUE
    0x80800BFD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK76OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK76OR"
    VALUE
    0x80800BFE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK76SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK76SCB"
    VALUE
    0x80800BFF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK76SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK76SCG"
    VALUE
    0x80800C00
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK77OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK77OR"
    VALUE
    0x80800C01
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK77SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK77SCB"
    VALUE
    0x80800C02
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK77SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK77SCG"
    VALUE
    0x80800C03
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK78OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK78OR"
    VALUE
    0x80800C04
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK78SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK78SCB"
    VALUE
    0x80800C05
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK78SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK78SCG"
    VALUE
    0x80800C06
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_DvUBAT_FWs_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_DvUBAT_FWs"
    VALUE
    0x80800C07
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_OVErr_VPR6_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_OVErr_VPR6"
    VALUE
    0x80800C08
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_OVWarn_VPR6_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_OVWarn_VPR6"
    VALUE
    0x80800C09
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3"
    VALUE
    0x80800C0A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2"
    VALUE
    0x80800C0B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_OV_UBAT_MON_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_OV_UBAT_MON"
    VALUE
    0x80800C0C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_OV_UBRM24_FLEXIN_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_OV_UBRM24_FLEXIN"
    VALUE
    0x80800C0D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_OV_UBRM24_LOADS_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_OV_UBRM24_LOADS"
    VALUE
    0x80800C0E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_OV_UBRM24_MON_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_OV_UBRM24_MON"
    VALUE
    0x80800C0F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_OV_VDD5_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_OV_VDD5"
    VALUE
    0x80800C10
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_OV_VDD5_IN_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_OV_VDD5_IN"
    VALUE
    0x80800C11
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_OV_VPR6_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_OV_VPR6"
    VALUE
    0x80800C12
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_OV_VSS3_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_OV_VSS3"
    VALUE
    0x80800C13
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_OV_VSS4_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_OV_VSS4"
    VALUE
    0x80800C14
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_Temp1_HTErr_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_Temp1_HTErr"
    VALUE
    0x80800C15
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_Temp1_HTWarn_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_Temp1_HTWarn"
    VALUE
    0x80800C16
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_Temp2_HTErr_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_Temp2_HTErr"
    VALUE
    0x80800C17
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_Temp2_HTWarn_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_Temp2_HTWarn"
    VALUE
    0x80800C18
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3"
    VALUE
    0x80800C19
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2"
    VALUE
    0x80800C1A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_UV_VDD5_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_UV_VDD5"
    VALUE
    0x80800C1B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_UV_VDD5_IN_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_UV_VDD5_IN"
    VALUE
    0x80800C1C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_UV_VPR6_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_UV_VPR6"
    VALUE
    0x80800C1D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_UV_VSS3_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_UV_VSS3"
    VALUE
    0x80800C1E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_UV_VSS4_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_UV_VSS4"
    VALUE
    0x80800C1F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA01OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA01OL"
    VALUE
    0x80800C20
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA01OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA01OT"
    VALUE
    0x80800C21
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA01SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA01SCB"
    VALUE
    0x80800C22
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA01SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA01SCG"
    VALUE
    0x80800C23
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA02OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA02OL"
    VALUE
    0x80800C24
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA02OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA02OR"
    VALUE
    0x80800C25
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA02OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA02OT"
    VALUE
    0x80800C26
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA02SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA02SCB"
    VALUE
    0x80800C27
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA02SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA02SCG"
    VALUE
    0x80800C28
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA03OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA03OL"
    VALUE
    0x80800C29
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA03OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA03OT"
    VALUE
    0x80800C2A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA03SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA03SCB"
    VALUE
    0x80800C2B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA03SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA03SCG"
    VALUE
    0x80800C2C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA04OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA04OL"
    VALUE
    0x80800C2D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA04OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA04OT"
    VALUE
    0x80800C2E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA04SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA04SCB"
    VALUE
    0x80800C2F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA04SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA04SCG"
    VALUE
    0x80800C30
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA05OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA05OL"
    VALUE
    0x80800C31
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA05OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA05OR"
    VALUE
    0x80800C32
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA05OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA05OT"
    VALUE
    0x80800C33
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA05SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA05SCB"
    VALUE
    0x80800C34
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA05SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA05SCG"
    VALUE
    0x80800C35
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA06OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA06OL"
    VALUE
    0x80800C36
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA06OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA06OR"
    VALUE
    0x80800C37
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA06OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA06OT"
    VALUE
    0x80800C38
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA06SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA06SCB"
    VALUE
    0x80800C39
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA06SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA06SCG"
    VALUE
    0x80800C3A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA07OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA07OL"
    VALUE
    0x80800C3B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA07OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA07OT"
    VALUE
    0x80800C3C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA07SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA07SCB"
    VALUE
    0x80800C3D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA07SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA07SCG"
    VALUE
    0x80800C3E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA08OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA08OL"
    VALUE
    0x80800C3F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA08OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA08OT"
    VALUE
    0x80800C40
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA08SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA08SCB"
    VALUE
    0x80800C41
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA08SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA08SCG"
    VALUE
    0x80800C42
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA09OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA09OL"
    VALUE
    0x80800C43
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA09OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA09OR"
    VALUE
    0x80800C44
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA09OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA09OT"
    VALUE
    0x80800C45
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA09SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA09SCB"
    VALUE
    0x80800C46
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA09SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA09SCG"
    VALUE
    0x80800C47
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA10OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA10OL"
    VALUE
    0x80800C48
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA10OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA10OT"
    VALUE
    0x80800C49
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA10SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA10SCB"
    VALUE
    0x80800C4A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA10SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA10SCG"
    VALUE
    0x80800C4B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA11OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA11OL"
    VALUE
    0x80800C4C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA11OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA11OT"
    VALUE
    0x80800C4D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA11SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA11SCB"
    VALUE
    0x80800C4E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA11SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA11SCG"
    VALUE
    0x80800C4F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA12OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA12OR"
    VALUE
    0x80800C50
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA12SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA12SCB"
    VALUE
    0x80800C51
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA12SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA12SCG"
    VALUE
    0x80800C52
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA16OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA16OL"
    VALUE
    0x80800C53
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA16OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA16OT"
    VALUE
    0x80800C54
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA16SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA16SCB"
    VALUE
    0x80800C55
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA16SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA16SCG"
    VALUE
    0x80800C56
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA17OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA17OL"
    VALUE
    0x80800C57
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA17OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA17OR"
    VALUE
    0x80800C58
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA17OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA17OT"
    VALUE
    0x80800C59
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA17SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA17SCB"
    VALUE
    0x80800C5A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA17SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA17SCG"
    VALUE
    0x80800C5B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA18OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA18OL"
    VALUE
    0x80800C5C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA18OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA18OT"
    VALUE
    0x80800C5D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA18SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA18SCB"
    VALUE
    0x80800C5E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA18SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA18SCG"
    VALUE
    0x80800C5F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA19OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA19OL"
    VALUE
    0x80800C60
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA19OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA19OR"
    VALUE
    0x80800C61
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA19OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA19OT"
    VALUE
    0x80800C62
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA19SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA19SCB"
    VALUE
    0x80800C63
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA19SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA19SCG"
    VALUE
    0x80800C64
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA20OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA20OL"
    VALUE
    0x80800C65
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA20OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA20OR"
    VALUE
    0x80800C66
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA20OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA20OT"
    VALUE
    0x80800C67
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA20SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA20SCB"
    VALUE
    0x80800C68
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA20SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA20SCG"
    VALUE
    0x80800C69
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA31OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA31OL"
    VALUE
    0x80800C6A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA31OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA31OR"
    VALUE
    0x80800C6B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA31OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA31OT"
    VALUE
    0x80800C6C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA31SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA31SCB"
    VALUE
    0x80800C6D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA31SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA31SCG"
    VALUE
    0x80800C6E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA32OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA32OL"
    VALUE
    0x80800C6F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA32OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA32OR"
    VALUE
    0x80800C70
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA32OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA32OT"
    VALUE
    0x80800C71
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA32SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA32SCB"
    VALUE
    0x80800C72
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA32SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA32SCG"
    VALUE
    0x80800C73
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA33OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA33OL"
    VALUE
    0x80800C74
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA33OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA33OR"
    VALUE
    0x80800C75
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA33OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA33OT"
    VALUE
    0x80800C76
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA33SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA33SCB"
    VALUE
    0x80800C77
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA33SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA33SCG"
    VALUE
    0x80800C78
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA34OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA34OL"
    VALUE
    0x80800C79
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA34OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA34OR"
    VALUE
    0x80800C7A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA34OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA34OT"
    VALUE
    0x80800C7B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA34SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA34SCB"
    VALUE
    0x80800C7C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA34SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA34SCG"
    VALUE
    0x80800C7D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA35OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA35OL"
    VALUE
    0x80800C7E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA35OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA35OR"
    VALUE
    0x80800C7F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA35OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA35OT"
    VALUE
    0x80800C80
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA35SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA35SCB"
    VALUE
    0x80800C81
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA35SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA35SCG"
    VALUE
    0x80800C82
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA46OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA46OL"
    VALUE
    0x80800C83
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA46OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA46OR"
    VALUE
    0x80800C84
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA46OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA46OT"
    VALUE
    0x80800C85
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA46SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA46SCB"
    VALUE
    0x80800C86
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA46SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA46SCG"
    VALUE
    0x80800C87
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA47OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA47OL"
    VALUE
    0x80800C88
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA47OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA47OR"
    VALUE
    0x80800C89
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA47OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA47OT"
    VALUE
    0x80800C8A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA47SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA47SCB"
    VALUE
    0x80800C8B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA47SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA47SCG"
    VALUE
    0x80800C8C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA48OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA48OL"
    VALUE
    0x80800C8D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA48OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA48OR"
    VALUE
    0x80800C8E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA48OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA48OT"
    VALUE
    0x80800C8F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA48SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA48SCB"
    VALUE
    0x80800C90
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA48SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA48SCG"
    VALUE
    0x80800C91
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA49OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA49OL"
    VALUE
    0x80800C92
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA49OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA49OT"
    VALUE
    0x80800C93
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA49SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA49SCB"
    VALUE
    0x80800C94
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA49SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA49SCG"
    VALUE
    0x80800C95
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA50OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA50OL"
    VALUE
    0x80800C96
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA50OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA50OT"
    VALUE
    0x80800C97
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA50SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA50SCB"
    VALUE
    0x80800C98
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA50SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA50SCG"
    VALUE
    0x80800C99
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA51OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA51OL"
    VALUE
    0x80800C9A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA51OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA51OR"
    VALUE
    0x80800C9B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA51OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA51OT"
    VALUE
    0x80800C9C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA51SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA51SCB"
    VALUE
    0x80800C9D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA51SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA51SCG"
    VALUE
    0x80800C9E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA52OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA52OL"
    VALUE
    0x80800C9F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA52OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA52OR"
    VALUE
    0x80800CA0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA52OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA52OT"
    VALUE
    0x80800CA1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA52SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA52SCB"
    VALUE
    0x80800CA2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA52SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA52SCG"
    VALUE
    0x80800CA3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA53OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA53OL"
    VALUE
    0x80800CA4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA53OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA53OR"
    VALUE
    0x80800CA5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA53OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA53OT"
    VALUE
    0x80800CA6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA53SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA53SCB"
    VALUE
    0x80800CA7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA53SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA53SCG"
    VALUE
    0x80800CA8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA54OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA54OL"
    VALUE
    0x80800CA9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA54OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA54OR"
    VALUE
    0x80800CAA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA54OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA54OT"
    VALUE
    0x80800CAB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA54SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA54SCB"
    VALUE
    0x80800CAC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA54SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA54SCG"
    VALUE
    0x80800CAD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA55OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA55OL"
    VALUE
    0x80800CAE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA55OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA55OT"
    VALUE
    0x80800CAF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA55SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA55SCB"
    VALUE
    0x80800CB0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA55SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA55SCG"
    VALUE
    0x80800CB1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA56OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA56OL"
    VALUE
    0x80800CB2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA56OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA56OT"
    VALUE
    0x80800CB3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA56SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA56SCB"
    VALUE
    0x80800CB4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA56SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA56SCG"
    VALUE
    0x80800CB5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA58OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA58OL"
    VALUE
    0x80800CB6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA58OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA58OT"
    VALUE
    0x80800CB7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA58SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA58SCB"
    VALUE
    0x80800CB8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA58SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA58SCG"
    VALUE
    0x80800CB9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK07OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK07OL"
    VALUE
    0x80800CBA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK07OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK07OR"
    VALUE
    0x80800CBB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK07OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK07OT"
    VALUE
    0x80800CBC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK07SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK07SCB"
    VALUE
    0x80800CBD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK07SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK07SCG"
    VALUE
    0x80800CBE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK08OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK08OL"
    VALUE
    0x80800CBF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK08OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK08OR"
    VALUE
    0x80800CC0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK08OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK08OT"
    VALUE
    0x80800CC1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK08SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK08SCB"
    VALUE
    0x80800CC2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK08SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK08SCG"
    VALUE
    0x80800CC3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK09OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK09OL"
    VALUE
    0x80800CC4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK09OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK09OR"
    VALUE
    0x80800CC5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK09OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK09OT"
    VALUE
    0x80800CC6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK09SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK09SCB"
    VALUE
    0x80800CC7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK09SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK09SCG"
    VALUE
    0x80800CC8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK12OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK12OL"
    VALUE
    0x80800CC9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK12OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK12OT"
    VALUE
    0x80800CCA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK12SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK12SCB"
    VALUE
    0x80800CCB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK12SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK12SCG"
    VALUE
    0x80800CCC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK13OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK13OL"
    VALUE
    0x80800CCD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK13OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK13OT"
    VALUE
    0x80800CCE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK13SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK13SCB"
    VALUE
    0x80800CCF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK13SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK13SCG"
    VALUE
    0x80800CD0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK14OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK14OL"
    VALUE
    0x80800CD1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK14OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK14OR"
    VALUE
    0x80800CD2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK14OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK14OT"
    VALUE
    0x80800CD3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK14SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK14SCB"
    VALUE
    0x80800CD4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK14SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK14SCG"
    VALUE
    0x80800CD5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK15OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK15OL"
    VALUE
    0x80800CD6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK15OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK15OR"
    VALUE
    0x80800CD7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK15OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK15OT"
    VALUE
    0x80800CD8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK15SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK15SCB"
    VALUE
    0x80800CD9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK15SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK15SCG"
    VALUE
    0x80800CDA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK16OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK16OL"
    VALUE
    0x80800CDB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK16OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK16OR"
    VALUE
    0x80800CDC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK16OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK16OT"
    VALUE
    0x80800CDD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK16SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK16SCB"
    VALUE
    0x80800CDE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK16SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK16SCG"
    VALUE
    0x80800CDF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK17OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK17OL"
    VALUE
    0x80800CE0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK17OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK17OR"
    VALUE
    0x80800CE1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK17OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK17OT"
    VALUE
    0x80800CE2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK17SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK17SCB"
    VALUE
    0x80800CE3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK17SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK17SCG"
    VALUE
    0x80800CE4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK25OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK25OR"
    VALUE
    0x80800CE5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK25SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK25SCB"
    VALUE
    0x80800CE6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK25SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK25SCG"
    VALUE
    0x80800CE7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK29OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK29OL"
    VALUE
    0x80800CE8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK29OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK29OR"
    VALUE
    0x80800CE9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK29OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK29OT"
    VALUE
    0x80800CEA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK29SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK29SCB"
    VALUE
    0x80800CEB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK29SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK29SCG"
    VALUE
    0x80800CEC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK51OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK51OL"
    VALUE
    0x80800CED
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK51OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK51OT"
    VALUE
    0x80800CEE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK51SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK51SCB"
    VALUE
    0x80800CEF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK51SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK51SCG"
    VALUE
    0x80800CF0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK62OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK62OR"
    VALUE
    0x80800CF1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK62SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK62SCB"
    VALUE
    0x80800CF2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK62SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK62SCG"
    VALUE
    0x80800CF3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK73OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK73OL"
    VALUE
    0x80800CF4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK73OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK73OR"
    VALUE
    0x80800CF5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK73OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK73OT"
    VALUE
    0x80800CF6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK73SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK73SCB"
    VALUE
    0x80800CF7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK73SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK73SCG"
    VALUE
    0x80800CF8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK80OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK80OL"
    VALUE
    0x80800CF9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK80OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK80OT"
    VALUE
    0x80800CFA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK80SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK80SCB"
    VALUE
    0x80800CFB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK80SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK80SCG"
    VALUE
    0x80800CFC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK81OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK81OL"
    VALUE
    0x80800CFD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK81OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK81OT"
    VALUE
    0x80800CFE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK81SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK81SCB"
    VALUE
    0x80800CFF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK81SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK81SCG"
    VALUE
    0x80800D00
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK82OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK82OL"
    VALUE
    0x80800D01
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK82OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK82OT"
    VALUE
    0x80800D02
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK82SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK82SCB"
    VALUE
    0x80800D03
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK82SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK82SCG"
    VALUE
    0x80800D04
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK83OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK83OL"
    VALUE
    0x80800D05
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK83OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK83OT"
    VALUE
    0x80800D06
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK83SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK83SCB"
    VALUE
    0x80800D07
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK83SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK83SCG"
    VALUE
    0x80800D08
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK84OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK84OL"
    VALUE
    0x80800D09
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK84OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK84OT"
    VALUE
    0x80800D0A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK84SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK84SCB"
    VALUE
    0x80800D0B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK84SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK84SCG"
    VALUE
    0x80800D0C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK85OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK85OL"
    VALUE
    0x80800D0D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK85OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK85OT"
    VALUE
    0x80800D0E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK85SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK85SCB"
    VALUE
    0x80800D0F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK85SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK85SCG"
    VALUE
    0x80800D10
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK86OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK86OL"
    VALUE
    0x80800D11
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK86OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK86OT"
    VALUE
    0x80800D12
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK86SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK86SCB"
    VALUE
    0x80800D13
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK86SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK86SCG"
    VALUE
    0x80800D14
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK87OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK87OL"
    VALUE
    0x80800D15
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK87OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK87OT"
    VALUE
    0x80800D16
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK87SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK87SCB"
    VALUE
    0x80800D17
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK87SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK87SCG"
    VALUE
    0x80800D18
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_EventUpDownDebFault_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_EventUpDownDebFault"
    VALUE
    0x80800D19
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_DSMDummy_C
    "Behaviour control mask / Behaviour control masks of check DFC_DSMDummy"
    VALUE
    0x80800D1A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canGetDataNoBuf_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canGetDataNoBuf"
    VALUE
    0x80800D1B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canGetDataParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canGetDataParam"
    VALUE
    0x80800D1C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canGetDataboxNoInit_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canGetDataboxNoInit"
    VALUE
    0x80800D1D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canGetDataboxParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canGetDataboxParam"
    VALUE
    0x80800D1E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canGetRxBufStatusParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canGetRxBufStatusParam"
    VALUE
    0x80800D1F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canGetStatusParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canGetStatusParam"
    VALUE
    0x80800D20
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canGetTxBufStatusParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canGetTxBufStatusParam"
    VALUE
    0x80800D21
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canInitParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canInitParam"
    VALUE
    0x80800D22
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canInitRxDataboxOverlap_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canInitRxDataboxOverlap"
    VALUE
    0x80800D23
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canInitRxDataboxParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canInitRxDataboxParam"
    VALUE
    0x80800D24
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canInitTxDataboxParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canInitTxDataboxParam"
    VALUE
    0x80800D25
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canIpduGroupControl_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canIpduGroupControl"
    VALUE
    0x80800D26
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canIsDataboxFreeNoInit_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canIsDataboxFreeNoInit"
    VALUE
    0x80800D27
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canIsDataboxFreeParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canIsDataboxFreeParam"
    VALUE
    0x80800D28
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canIsTxEmptyParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canIsTxEmptyParam"
    VALUE
    0x80800D29
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canRegBusOffCallbInvState_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canRegBusOffCallbInvState"
    VALUE
    0x80800D2A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canRegBusOffCallbParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canRegBusOffCallbParam"
    VALUE
    0x80800D2B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canRegRxBufInvState_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canRegRxBufInvState"
    VALUE
    0x80800D2C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canRegRxBufOverlap_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canRegRxBufOverlap"
    VALUE
    0x80800D2D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canRegRxBufParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canRegRxBufParam"
    VALUE
    0x80800D2E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canRegRxCallbInvState_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canRegRxCallbInvState"
    VALUE
    0x80800D2F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canRegRxCallbParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canRegRxCallbParam"
    VALUE
    0x80800D30
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canRegRxDataboxInvNumb_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canRegRxDataboxInvNumb"
    VALUE
    0x80800D31
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canRegRxDataboxInvState_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canRegRxDataboxInvState"
    VALUE
    0x80800D32
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canRegRxDataboxOverlap_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canRegRxDataboxOverlap"
    VALUE
    0x80800D33
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canRegRxDataboxParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canRegRxDataboxParam"
    VALUE
    0x80800D34
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canRegTxBufInvState_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canRegTxBufInvState"
    VALUE
    0x80800D35
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canRegTxBufOverlap_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canRegTxBufOverlap"
    VALUE
    0x80800D36
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canRegTxBufParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canRegTxBufParam"
    VALUE
    0x80800D37
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canRegTxDataboxInvNumb_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canRegTxDataboxInvNumb"
    VALUE
    0x80800D38
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canRegTxDataboxInvState_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canRegTxDataboxInvState"
    VALUE
    0x80800D39
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canRegTxDataboxOverlap_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canRegTxDataboxOverlap"
    VALUE
    0x80800D3A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canRegTxDataboxParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canRegTxDataboxParam"
    VALUE
    0x80800D3B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canResetTxBufParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canResetTxBufParam"
    VALUE
    0x80800D3C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canSendDataBufOvfl_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canSendDataBufOvfl"
    VALUE
    0x80800D3D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canSendDataParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canSendDataParam"
    VALUE
    0x80800D3E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canSendDataboxNoInit_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canSendDataboxNoInit"
    VALUE
    0x80800D3F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canSendDataboxParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canSendDataboxParam"
    VALUE
    0x80800D40
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canSetTxCycleParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canSetTxCycleParam"
    VALUE
    0x80800D41
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canStartParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canStartParam"
    VALUE
    0x80800D42
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canStopParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canStopParam"
    VALUE
    0x80800D43
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_can_ClearIpduGroup_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_can_ClearIpduGroup"
    VALUE
    0x80800D44
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_can_ReceiveSignal_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_can_ReceiveSignal"
    VALUE
    0x80800D45
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_can_SendSignal_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_can_SendSignal"
    VALUE
    0x80800D46
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_can_SetIpduGroup_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_can_SetIpduGroup"
    VALUE
    0x80800D47
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_dsmDTCJ1939_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_dsmDTCJ1939"
    VALUE
    0x80800D48
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_dsmDelDTCJ1939_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_dsmDelDTCJ1939"
    VALUE
    0x80800D49
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_dsmDelErrors_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_dsmDelErrors"
    VALUE
    0x80800D4A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_dsmGetDFES_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_dsmGetDFES"
    VALUE
    0x80800D4B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_dsmGetDTCJ1939_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_dsmGetDTCJ1939"
    VALUE
    0x80800D4C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_dsmGetErrors_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_dsmGetErrors"
    VALUE
    0x80800D4D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_dsmGetNumErrors_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_dsmGetNumErrors"
    VALUE
    0x80800D4E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_dsmInitQueueOverflow_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_dsmInitQueueOverflow"
    VALUE
    0x80800D4F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_dsmNumDTCJ1939_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_dsmNumDTCJ1939"
    VALUE
    0x80800D50
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_dsmTesterror_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_dsmTesterror"
    VALUE
    0x80800D51
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_dsmUpdateDebError_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_dsmUpdateDebError"
    VALUE
    0x80800D52
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_dsmUpdateError_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_dsmUpdateError"
    VALUE
    0x80800D53
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_dsmgetDFCStatus_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_dsmgetDFCStatus"
    VALUE
    0x80800D54
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_dsmtestErrorDFC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_dsmtestErrorDFC"
    VALUE
    0x80800D55
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inAi_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inAi"
    VALUE
    0x80800D56
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inAic_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inAic"
    VALUE
    0x80800D57
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inAicCfg_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inAicCfg"
    VALUE
    0x80800D58
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inAicGetStatus_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inAicGetStatus"
    VALUE
    0x80800D59
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inAid_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inAid"
    VALUE
    0x80800D5A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inAidCfg_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inAidCfg"
    VALUE
    0x80800D5B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inAiv_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inAiv"
    VALUE
    0x80800D5C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inAivCfg_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inAivCfg"
    VALUE
    0x80800D5D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inAivGetStatus_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inAivGetStatus"
    VALUE
    0x80800D5E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inDi_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inDi"
    VALUE
    0x80800D5F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inFi_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inFi"
    VALUE
    0x80800D60
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inFiCfg_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inFiCfg"
    VALUE
    0x80800D61
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inFiGetStatus_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inFiGetStatus"
    VALUE
    0x80800D62
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inFi_Buffered_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inFi_Buffered"
    VALUE
    0x80800D63
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inPhase_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inPhase"
    VALUE
    0x80800D64
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inPhaseGetStatus_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inPhaseGetStatus"
    VALUE
    0x80800D65
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inPhaseResetCounter_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inPhaseResetCounter"
    VALUE
    0x80800D66
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inRi_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inRi"
    VALUE
    0x80800D67
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inRiCfg_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inRiCfg"
    VALUE
    0x80800D68
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inRiCfgTemp_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inRiCfgTemp"
    VALUE
    0x80800D69
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inRiGetStatus_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inRiGetStatus"
    VALUE
    0x80800D6A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inRiGetTemp_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inRiGetTemp"
    VALUE
    0x80800D6B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inSentCopyFDFifo_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inSentCopyFDFifo"
    VALUE
    0x80800D6C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inSentDisable_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inSentDisable"
    VALUE
    0x80800D6D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inSentEnable_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inSentEnable"
    VALUE
    0x80800D6E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inSentGetErrorStatus_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inSentGetErrorStatus"
    VALUE
    0x80800D6F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inSentGetFD_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inSentGetFD"
    VALUE
    0x80800D70
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inSentGetSD_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inSentGetSD"
    VALUE
    0x80800D71
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inSentGetSDDatabox_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inSentGetSDDatabox"
    VALUE
    0x80800D72
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inSentGetStatus_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inSentGetStatus"
    VALUE
    0x80800D73
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inSentInitSDDatabox_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inSentInitSDDatabox"
    VALUE
    0x80800D74
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inSentRegisterCopyFDFifo_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inSentRegisterCopyFDFifo"
    VALUE
    0x80800D75
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inSentRegisterFDFifo_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inSentRegisterFDFifo"
    VALUE
    0x80800D76
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inSentRegisterSDDataboxes_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inSentRegisterSDDataboxes"
    VALUE
    0x80800D77
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_isobusCanRxBufferOverflow_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_isobusCanRxBufferOverflow"
    VALUE
    0x80800D78
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_isobusGetCaAddrParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_isobusGetCaAddrParam"
    VALUE
    0x80800D79
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_isobusGetDiagnosticParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_isobusGetDiagnosticParam"
    VALUE
    0x80800D7A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_isobusGetRxDataboxStatusParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_isobusGetRxDataboxStatusParam"
    VALUE
    0x80800D7B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_isobusGetStatusParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_isobusGetStatusParam"
    VALUE
    0x80800D7C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_isobusInitCommCaMissing_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_isobusInitCommCaMissing"
    VALUE
    0x80800D7D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_isobusInitCommParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_isobusInitCommParam"
    VALUE
    0x80800D7E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_isobusInitCommState_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_isobusInitCommState"
    VALUE
    0x80800D7F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_isobusInitDiagnosticParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_isobusInitDiagnosticParam"
    VALUE
    0x80800D80
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_isobusInitFailureListParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_isobusInitFailureListParam"
    VALUE
    0x80800D81
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_isobusInitRxDataboxParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_isobusInitRxDataboxParam"
    VALUE
    0x80800D82
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_isobusInitTxDataboxParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_isobusInitTxDataboxParam"
    VALUE
    0x80800D83
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_isobusRegRxDataboxOverlap_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_isobusRegRxDataboxOverlap"
    VALUE
    0x80800D84
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_isobusRegRxDataboxParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_isobusRegRxDataboxParam"
    VALUE
    0x80800D85
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_isobusRegRxDataboxState_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_isobusRegRxDataboxState"
    VALUE
    0x80800D86
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_isobusRegTxDataboxOverlap_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_isobusRegTxDataboxOverlap"
    VALUE
    0x80800D87
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_isobusRegTxDataboxParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_isobusRegTxDataboxParam"
    VALUE
    0x80800D88
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_isobusRegTxDataboxState_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_isobusRegTxDataboxState"
    VALUE
    0x80800D89
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_isobusRegisterErrClrCallbackParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_isobusRegisterErrClrCallbackParam"
    VALUE
    0x80800D8A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_isobusRegisterInstancesOverlap_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_isobusRegisterInstancesOverlap"
    VALUE
    0x80800D8B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_isobusRegisterInstancesParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_isobusRegisterInstancesParam"
    VALUE
    0x80800D8C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_isobusRegisterInstancesState_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_isobusRegisterInstancesState"
    VALUE
    0x80800D8D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_isobusSendDataboxParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_isobusSendDataboxParam"
    VALUE
    0x80800D8E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_isobusSendRequestPGNParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_isobusSendRequestPGNParam"
    VALUE
    0x80800D8F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_isobusSetCaAddrCaUsed_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_isobusSetCaAddrCaUsed"
    VALUE
    0x80800D90
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_isobusSetCaAddrComm_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_isobusSetCaAddrComm"
    VALUE
    0x80800D91
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_isobusSetCaAddrInvCan_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_isobusSetCaAddrInvCan"
    VALUE
    0x80800D92
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_isobusSetCaAddrParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_isobusSetCaAddrParam"
    VALUE
    0x80800D93
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_isobusSetCaInfoParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_isobusSetCaInfoParam"
    VALUE
    0x80800D94
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_isobusSetCaNameParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_isobusSetCaNameParam"
    VALUE
    0x80800D95
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_isobusSftyCanTxErr_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_isobusSftyCanTxErr"
    VALUE
    0x80800D96
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_lin_ReceiveSignal_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_lin_ReceiveSignal"
    VALUE
    0x80800D97
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_lin_SendSignal_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_lin_SendSignal"
    VALUE
    0x80800D98
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_lin_getStatus_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_lin_getStatus"
    VALUE
    0x80800D99
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_lin_gotoSleep_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_lin_gotoSleep"
    VALUE
    0x80800D9A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_lin_scheduleRequest_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_lin_scheduleRequest"
    VALUE
    0x80800D9B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_lin_wakeUp_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_lin_wakeUp"
    VALUE
    0x80800D9C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_memFlsCfgShr_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_memFlsCfgShr"
    VALUE
    0x80800D9D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_memGetStatus_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_memGetStatus"
    VALUE
    0x80800D9E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_memMarkBlock_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_memMarkBlock"
    VALUE
    0x80800D9F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_memReadApi1Error_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_memReadApi1Error"
    VALUE
    0x80800DA0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_memReadApi2Error_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_memReadApi2Error"
    VALUE
    0x80800DA1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_memReadBlock_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_memReadBlock"
    VALUE
    0x80800DA2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_memReadCalibInputError_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_memReadCalibInputError"
    VALUE
    0x80800DA3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_memReadCalibOuputError_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_memReadCalibOuputError"
    VALUE
    0x80800DA4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_memReadSystemError_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_memReadSystemError"
    VALUE
    0x80800DA5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_memWriteBlock_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_memWriteBlock"
    VALUE
    0x80800DA6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_moOV_FirstConstADC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_moOV_FirstConstADC"
    VALUE
    0x80800DA7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_moOV_SecondConstADC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_moOV_SecondConstADC"
    VALUE
    0x80800DA8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_moUV_FirstConstADC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_moUV_FirstConstADC"
    VALUE
    0x80800DA9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_moUV_SecondConstADC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_moUV_SecondConstADC"
    VALUE
    0x80800DAA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_INH_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_INH"
    VALUE
    0x80800DAB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_INHLatch_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_INHLatch"
    VALUE
    0x80800DAC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_adcPDD_fail_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_adcPDD_fail"
    VALUE
    0x80800DAD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_memoryProtection_err_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_memoryProtection_err"
    VALUE
    0x80800DAE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA02OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA02OC"
    VALUE
    0x80800DAF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA02Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA02Unintended"
    VALUE
    0x80800DB0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA03OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA03OC"
    VALUE
    0x80800DB1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA03Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA03Unintended"
    VALUE
    0x80800DB2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA04OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA04OC"
    VALUE
    0x80800DB3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA04Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA04Unintended"
    VALUE
    0x80800DB4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA05OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA05OC"
    VALUE
    0x80800DB5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA05Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA05Unintended"
    VALUE
    0x80800DB6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA07OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA07OC"
    VALUE
    0x80800DB7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA07Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA07Unintended"
    VALUE
    0x80800DB8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA08OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA08OC"
    VALUE
    0x80800DB9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA08Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA08Unintended"
    VALUE
    0x80800DBA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA09OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA09OC"
    VALUE
    0x80800DBB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA09Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA09Unintended"
    VALUE
    0x80800DBC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA10OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA10OC"
    VALUE
    0x80800DBD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA10Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA10Unintended"
    VALUE
    0x80800DBE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA17OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA17OC"
    VALUE
    0x80800DBF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA17Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA17Unintended"
    VALUE
    0x80800DC0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA18OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA18OC"
    VALUE
    0x80800DC1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA18Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA18Unintended"
    VALUE
    0x80800DC2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA19OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA19OC"
    VALUE
    0x80800DC3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA19Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA19Unintended"
    VALUE
    0x80800DC4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA20OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA20OC"
    VALUE
    0x80800DC5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA20Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA20Unintended"
    VALUE
    0x80800DC6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA31OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA31OC"
    VALUE
    0x80800DC7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA31Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA31Unintended"
    VALUE
    0x80800DC8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA32OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA32OC"
    VALUE
    0x80800DC9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA32Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA32Unintended"
    VALUE
    0x80800DCA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA33OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA33OC"
    VALUE
    0x80800DCB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA33Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA33Unintended"
    VALUE
    0x80800DCC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA34OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA34OC"
    VALUE
    0x80800DCD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA34Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA34Unintended"
    VALUE
    0x80800DCE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA35OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA35OC"
    VALUE
    0x80800DCF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA35Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA35Unintended"
    VALUE
    0x80800DD0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA46OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA46OC"
    VALUE
    0x80800DD1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA46Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA46Unintended"
    VALUE
    0x80800DD2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA47OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA47OC"
    VALUE
    0x80800DD3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA47Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA47Unintended"
    VALUE
    0x80800DD4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA48OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA48OC"
    VALUE
    0x80800DD5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA48Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA48Unintended"
    VALUE
    0x80800DD6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA51OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA51OC"
    VALUE
    0x80800DD7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA51Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA51Unintended"
    VALUE
    0x80800DD8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA52OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA52OC"
    VALUE
    0x80800DD9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA52Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA52Unintended"
    VALUE
    0x80800DDA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA53OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA53OC"
    VALUE
    0x80800DDB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA53Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA53Unintended"
    VALUE
    0x80800DDC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA54OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA54OC"
    VALUE
    0x80800DDD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA54Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA54Unintended"
    VALUE
    0x80800DDE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outAov_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outAov"
    VALUE
    0x80800DDF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outAovCfg_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outAovCfg"
    VALUE
    0x80800DE0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outAovCfgPI_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outAovCfgPI"
    VALUE
    0x80800DE1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outAovGetStatus_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outAovGetStatus"
    VALUE
    0x80800DE2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outAovGetVoltage_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outAovGetVoltage"
    VALUE
    0x80800DE3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outAovResetError_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outAovResetError"
    VALUE
    0x80800DE4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outDo_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outDo"
    VALUE
    0x80800DE5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outDoCfgPwrLs_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outDoCfgPwrLs"
    VALUE
    0x80800DE6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outDoDisable_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outDoDisable"
    VALUE
    0x80800DE7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outDoGetCurrent_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outDoGetCurrent"
    VALUE
    0x80800DE8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outDoGetStatus_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outDoGetStatus"
    VALUE
    0x80800DE9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outDoResetError_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outDoResetError"
    VALUE
    0x80800DEA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK07OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK07OC"
    VALUE
    0x80800DEB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK07Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK07Unintended"
    VALUE
    0x80800DEC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK08OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK08OC"
    VALUE
    0x80800DED
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK08Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK08Unintended"
    VALUE
    0x80800DEE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK09OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK09OC"
    VALUE
    0x80800DEF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK09Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK09Unintended"
    VALUE
    0x80800DF0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK12OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK12OC"
    VALUE
    0x80800DF1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK12Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK12Unintended"
    VALUE
    0x80800DF2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK13OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK13OC"
    VALUE
    0x80800DF3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK13Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK13Unintended"
    VALUE
    0x80800DF4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK14OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK14OC"
    VALUE
    0x80800DF5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK14Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK14Unintended"
    VALUE
    0x80800DF6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK15OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK15OC"
    VALUE
    0x80800DF7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK15Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK15Unintended"
    VALUE
    0x80800DF8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK16OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK16OC"
    VALUE
    0x80800DF9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK16Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK16Unintended"
    VALUE
    0x80800DFA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK17OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK17OC"
    VALUE
    0x80800DFB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK17Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK17Unintended"
    VALUE
    0x80800DFC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK29OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK29OC"
    VALUE
    0x80800DFD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK29Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK29Unintended"
    VALUE
    0x80800DFE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK51OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK51OC"
    VALUE
    0x80800DFF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK51Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK51Unintended"
    VALUE
    0x80800E00
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK73OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK73OC"
    VALUE
    0x80800E01
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK73Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK73Unintended"
    VALUE
    0x80800E02
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outPo_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outPo"
    VALUE
    0x80800E03
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outPoCfg_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outPoCfg"
    VALUE
    0x80800E04
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outPoCfgPeriod_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outPoCfgPeriod"
    VALUE
    0x80800E05
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outPoCfgPwrLs_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outPoCfgPwrLs"
    VALUE
    0x80800E06
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outPoDisable_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outPoDisable"
    VALUE
    0x80800E07
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outPoGetCurrent_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outPoGetCurrent"
    VALUE
    0x80800E08
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outPoGetStatus_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outPoGetStatus"
    VALUE
    0x80800E09
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outPoResetError_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outPoResetError"
    VALUE
    0x80800E0A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outPoc_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outPoc"
    VALUE
    0x80800E0B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outPocCfg_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outPocCfg"
    VALUE
    0x80800E0C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outPocCfgDither_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outPocCfgDither"
    VALUE
    0x80800E0D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outPocCfgPI_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outPocCfgPI"
    VALUE
    0x80800E0E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outPod_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outPod"
    VALUE
    0x80800E0F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outPodCfg_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outPodCfg"
    VALUE
    0x80800E10
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outPodCfgPeriod_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outPodCfgPeriod"
    VALUE
    0x80800E11
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_rsmFfiApiCallErr_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_rsmFfiApiCallErr"
    VALUE
    0x80800E12
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safout_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safout"
    VALUE
    0x80800E13
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutCfg_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutCfg"
    VALUE
    0x80800E14
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl1_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl1"
    VALUE
    0x80800E15
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl10_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl10"
    VALUE
    0x80800E16
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl10Dev_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl10Dev"
    VALUE
    0x80800E17
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl10OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl10OR"
    VALUE
    0x80800E18
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl11_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl11"
    VALUE
    0x80800E19
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl11Dev_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl11Dev"
    VALUE
    0x80800E1A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl11OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl11OR"
    VALUE
    0x80800E1B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl12_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl12"
    VALUE
    0x80800E1C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl12Dev_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl12Dev"
    VALUE
    0x80800E1D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl12OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl12OR"
    VALUE
    0x80800E1E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl13_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl13"
    VALUE
    0x80800E1F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl13Dev_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl13Dev"
    VALUE
    0x80800E20
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl13OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl13OR"
    VALUE
    0x80800E21
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl14_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl14"
    VALUE
    0x80800E22
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl14Dev_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl14Dev"
    VALUE
    0x80800E23
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl14OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl14OR"
    VALUE
    0x80800E24
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl15_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl15"
    VALUE
    0x80800E25
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl15Dev_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl15Dev"
    VALUE
    0x80800E26
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl15OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl15OR"
    VALUE
    0x80800E27
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl16_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl16"
    VALUE
    0x80800E28
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl16Dev_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl16Dev"
    VALUE
    0x80800E29
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl16OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl16OR"
    VALUE
    0x80800E2A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl17_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl17"
    VALUE
    0x80800E2B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl17Dev_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl17Dev"
    VALUE
    0x80800E2C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl17OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl17OR"
    VALUE
    0x80800E2D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl18_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl18"
    VALUE
    0x80800E2E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl18Dev_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl18Dev"
    VALUE
    0x80800E2F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl18OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl18OR"
    VALUE
    0x80800E30
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl1Dev_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl1Dev"
    VALUE
    0x80800E31
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl1OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl1OR"
    VALUE
    0x80800E32
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl2_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl2"
    VALUE
    0x80800E33
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl2Dev_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl2Dev"
    VALUE
    0x80800E34
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl2OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl2OR"
    VALUE
    0x80800E35
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl3_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl3"
    VALUE
    0x80800E36
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl3Dev_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl3Dev"
    VALUE
    0x80800E37
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl3OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl3OR"
    VALUE
    0x80800E38
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl4_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl4"
    VALUE
    0x80800E39
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl4Dev_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl4Dev"
    VALUE
    0x80800E3A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl4OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl4OR"
    VALUE
    0x80800E3B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl5_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl5"
    VALUE
    0x80800E3C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl5Dev_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl5Dev"
    VALUE
    0x80800E3D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl5OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl5OR"
    VALUE
    0x80800E3E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl6_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl6"
    VALUE
    0x80800E3F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl6Dev_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl6Dev"
    VALUE
    0x80800E40
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl6OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl6OR"
    VALUE
    0x80800E41
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl7_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl7"
    VALUE
    0x80800E42
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl7Dev_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl7Dev"
    VALUE
    0x80800E43
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl7OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl7OR"
    VALUE
    0x80800E44
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl8_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl8"
    VALUE
    0x80800E45
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl8Dev_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl8Dev"
    VALUE
    0x80800E46
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl8OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl8OR"
    VALUE
    0x80800E47
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl9_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl9"
    VALUE
    0x80800E48
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl9Dev_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl9Dev"
    VALUE
    0x80800E49
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl9OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl9OR"
    VALUE
    0x80800E4A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutDevError_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutDevError"
    VALUE
    0x80800E4B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutGetStatus_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutGetStatus"
    VALUE
    0x80800E4C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutIgnoreError_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutIgnoreError"
    VALUE
    0x80800E4D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutResetError_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutResetError"
    VALUE
    0x80800E4E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutUnlock_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutUnlock"
    VALUE
    0x80800E4F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safout_cfgDiag_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safout_cfgDiag"
    VALUE
    0x80800E50
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_secAccessDenied_RC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_secAccessDenied_RC"
    VALUE
    0x80800E51
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_secAccessDenied_WDBI_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_secAccessDenied_WDBI"
    VALUE
    0x80800E52
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_secEvalRespKey_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_secEvalRespKey"
    VALUE
    0x80800E53
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_secFlashingFailure_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_secFlashingFailure"
    VALUE
    0x80800E54
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_secGetLevel_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_secGetLevel"
    VALUE
    0x80800E55
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_secGetRnd_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_secGetRnd"
    VALUE
    0x80800E56
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_secGetSeed_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_secGetSeed"
    VALUE
    0x80800E57
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_secInvalidPassword_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_secInvalidPassword"
    VALUE
    0x80800E58
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_secIsRequestAllowed_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_secIsRequestAllowed"
    VALUE
    0x80800E59
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_secResetLevel_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_secResetLevel"
    VALUE
    0x80800E5A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_secSaveSecret_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_secSaveSecret"
    VALUE
    0x80800E5B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_secSetLevel_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_secSetLevel"
    VALUE
    0x80800E5C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_sysAit_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_sysAit"
    VALUE
    0x80800E5D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_sysAiv_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_sysAiv"
    VALUE
    0x80800E5E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_sysDi_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_sysDi"
    VALUE
    0x80800E5F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_sysDo_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_sysDo"
    VALUE
    0x80800E60
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_sysGetVss_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_sysGetVss"
    VALUE
    0x80800E61
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_sysInit_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_sysInit"
    VALUE
    0x80800E62
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_sysOperHrIntegrityErr_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_sysOperHrIntegrityErr"
    VALUE
    0x80800E63
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_sysOperHrsSaturated_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_sysOperHrsSaturated"
    VALUE
    0x80800E64
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_sysSetVss_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_sysSetVss"
    VALUE
    0x80800E65
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_sys_coreload_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_sys_coreload"
    VALUE
    0x80800E66
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_sys_taskload_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_sys_taskload"
    VALUE
    0x80800E67
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_OV_VSS1_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_OV_VSS1"
    VALUE
    0x80800E68
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_OV_VSS2_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_OV_VSS2"
    VALUE
    0x80800E69
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_UV_VSS1_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_UV_VSS1"
    VALUE
    0x80800E6A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_UV_VSS2_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_UV_VSS2"
    VALUE
    0x80800E6B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_CANSM_E_BUS_OFF_NETWORK_0_C
    "Behaviour control mask / Behaviour control masks of check DFC_CANSM_E_BUS_OFF_NETWORK_0"
    VALUE
    0x80800E6C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_CANSM_E_BUS_OFF_NETWORK_1_C
    "Behaviour control mask / Behaviour control masks of check DFC_CANSM_E_BUS_OFF_NETWORK_1"
    VALUE
    0x80800E6D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_CANSM_E_BUS_OFF_NETWORK_2_C
    "Behaviour control mask / Behaviour control masks of check DFC_CANSM_E_BUS_OFF_NETWORK_2"
    VALUE
    0x80800E6E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_CANSM_E_BUS_OFF_NETWORK_3_C
    "Behaviour control mask / Behaviour control masks of check DFC_CANSM_E_BUS_OFF_NETWORK_3"
    VALUE
    0x80800E6F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_CANTRCV_E_NO_TRCV_CONTROL_0_C
    "Behaviour control mask / Behaviour control masks of check DFC_CANTRCV_E_NO_TRCV_CONTROL_0"
    VALUE
    0x80800E70
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_CAN_E_TIMEOUT_C
    "Behaviour control mask / Behaviour control masks of check DFC_CAN_E_TIMEOUT"
    VALUE
    0x80800E71
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_COMM_E_NET_START_IND_CHANNEL_0_C
    "Behaviour control mask / Behaviour control masks of check DFC_COMM_E_NET_START_IND_CHANNEL_0"
    VALUE
    0x80800E72
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_COMM_E_NET_START_IND_CHANNEL_1_C
    "Behaviour control mask / Behaviour control masks of check DFC_COMM_E_NET_START_IND_CHANNEL_1"
    VALUE
    0x80800E73
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_COMM_E_NET_START_IND_CHANNEL_2_C
    "Behaviour control mask / Behaviour control masks of check DFC_COMM_E_NET_START_IND_CHANNEL_2"
    VALUE
    0x80800E74
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_COMM_E_NET_START_IND_CHANNEL_3_C
    "Behaviour control mask / Behaviour control masks of check DFC_COMM_E_NET_START_IND_CHANNEL_3"
    VALUE
    0x80800E75
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_COMM_E_NET_START_IND_CHANNEL_4_C
    "Behaviour control mask / Behaviour control masks of check DFC_COMM_E_NET_START_IND_CHANNEL_4"
    VALUE
    0x80800E76
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_COMM_E_NET_START_IND_CHANNEL_5_C
    "Behaviour control mask / Behaviour control masks of check DFC_COMM_E_NET_START_IND_CHANNEL_5"
    VALUE
    0x80800E77
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_LIN_E_TIMEOUT_C
    "Behaviour control mask / Behaviour control masks of check DFC_LIN_E_TIMEOUT"
    VALUE
    0x80800E78
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rba_MultiStackTrace_Threshold_C
    "Behaviour control mask / Behaviour control masks of check DFC_rba_MultiStackTrace_Threshold"
    VALUE
    0x80800E79
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_ETH_E_ACCESS_0_C
    "Behaviour control mask / Behaviour control masks of check DFC_ETH_E_ACCESS_0"
    VALUE
    0x80800E7A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_RBA_IOEXTLIB_KEEPALIVE_DRV_C
    "Behaviour control mask / Behaviour control masks of check DFC_RBA_IOEXTLIB_KEEPALIVE_DRV"
    VALUE
    0x80800E7B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_RBA_IOEXTLIB_KEEPALIVE_INI_C
    "Behaviour control mask / Behaviour control masks of check DFC_RBA_IOEXTLIB_KEEPALIVE_INI"
    VALUE
    0x80800E7C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rba_MRly_Diag_Stk_Event_C
    "Behaviour control mask / Behaviour control masks of check DFC_rba_MRly_Diag_Stk_Event"
    VALUE
    0x80800E7D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rba_MemDiagExtd_MemReadSngErr_C
    "Behaviour control mask / Behaviour control masks of check DFC_rba_MemDiagExtd_MemReadSngErr"
    VALUE
    0x80800E7E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rba_MemDiag_MemReadErr_C
    "Behaviour control mask / Behaviour control masks of check DFC_rba_MemDiag_MemReadErr"
    VALUE
    0x80800E7F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rba_MemDiag_MemWrErr_C
    "Behaviour control mask / Behaviour control masks of check DFC_rba_MemDiag_MemWrErr"
    VALUE
    0x80800E80
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rba_SyC_IrrSwOffTrigEngRun_Event_C
    "Behaviour control mask / Behaviour control masks of check DFC_rba_SyC_IrrSwOffTrigEngRun_Event"
    VALUE
    0x80800E81
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rba_T15_Diag_ComInVld_Event_C
    "Behaviour control mask / Behaviour control masks of check DFC_rba_T15_Diag_ComInVld_Event"
    VALUE
    0x80800E82
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rba_T15_Diag_ComOff_HwOn_Event_C
    "Behaviour control mask / Behaviour control masks of check DFC_rba_T15_Diag_ComOff_HwOn_Event"
    VALUE
    0x80800E83
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rba_T15_Diag_ComOn_HwOff_Event_C
    "Behaviour control mask / Behaviour control masks of check DFC_rba_T15_Diag_ComOn_HwOff_Event"
    VALUE
    0x80800E84
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM0_0_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM0_0"
    VALUE
    0x80800E85
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM0_1_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM0_1"
    VALUE
    0x80800E86
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM0_10_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM0_10"
    VALUE
    0x80800E87
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM0_11_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM0_11"
    VALUE
    0x80800E88
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM0_13_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM0_13"
    VALUE
    0x80800E89
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM0_14_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM0_14"
    VALUE
    0x80800E8A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM0_2_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM0_2"
    VALUE
    0x80800E8B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM0_22_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM0_22"
    VALUE
    0x80800E8C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM0_23_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM0_23"
    VALUE
    0x80800E8D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM0_4_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM0_4"
    VALUE
    0x80800E8E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM0_5_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM0_5"
    VALUE
    0x80800E8F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM0_7_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM0_7"
    VALUE
    0x80800E90
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM0_8_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM0_8"
    VALUE
    0x80800E91
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM10_16_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM10_16"
    VALUE
    0x80800E92
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM10_17_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM10_17"
    VALUE
    0x80800E93
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM10_21_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM10_21"
    VALUE
    0x80800E94
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM11_0_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM11_0"
    VALUE
    0x80800E95
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM11_1_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM11_1"
    VALUE
    0x80800E96
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM11_2_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM11_2"
    VALUE
    0x80800E97
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM11_3_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM11_3"
    VALUE
    0x80800E98
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM11_4_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM11_4"
    VALUE
    0x80800E99
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM11_5_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM11_5"
    VALUE
    0x80800E9A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM11_8_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM11_8"
    VALUE
    0x80800E9B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM11_9_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM11_9"
    VALUE
    0x80800E9C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM1_0_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM1_0"
    VALUE
    0x80800E9D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM1_1_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM1_1"
    VALUE
    0x80800E9E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM1_10_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM1_10"
    VALUE
    0x80800E9F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM1_11_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM1_11"
    VALUE
    0x80800EA0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM1_13_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM1_13"
    VALUE
    0x80800EA1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM1_14_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM1_14"
    VALUE
    0x80800EA2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM1_2_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM1_2"
    VALUE
    0x80800EA3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM1_22_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM1_22"
    VALUE
    0x80800EA4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM1_23_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM1_23"
    VALUE
    0x80800EA5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM1_4_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM1_4"
    VALUE
    0x80800EA6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM1_5_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM1_5"
    VALUE
    0x80800EA7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM1_7_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM1_7"
    VALUE
    0x80800EA8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM1_8_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM1_8"
    VALUE
    0x80800EA9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM21_0_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM21_0"
    VALUE
    0x80800EAA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM21_16_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM21_16"
    VALUE
    0x80800EAB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM21_3_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM21_3"
    VALUE
    0x80800EAC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM2_1_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM2_1"
    VALUE
    0x80800EAD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM2_10_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM2_10"
    VALUE
    0x80800EAE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM2_11_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM2_11"
    VALUE
    0x80800EAF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM2_13_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM2_13"
    VALUE
    0x80800EB0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM2_14_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM2_14"
    VALUE
    0x80800EB1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM2_2_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM2_2"
    VALUE
    0x80800EB2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM2_22_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM2_22"
    VALUE
    0x80800EB3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM2_23_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM2_23"
    VALUE
    0x80800EB4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM2_4_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM2_4"
    VALUE
    0x80800EB5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM2_5_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM2_5"
    VALUE
    0x80800EB6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM2_7_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM2_7"
    VALUE
    0x80800EB7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM2_8_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM2_8"
    VALUE
    0x80800EB8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM3_1_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM3_1"
    VALUE
    0x80800EB9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM3_10_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM3_10"
    VALUE
    0x80800EBA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM3_11_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM3_11"
    VALUE
    0x80800EBB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM3_13_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM3_13"
    VALUE
    0x80800EBC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM3_14_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM3_14"
    VALUE
    0x80800EBD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM3_2_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM3_2"
    VALUE
    0x80800EBE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM3_22_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM3_22"
    VALUE
    0x80800EBF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM3_23_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM3_23"
    VALUE
    0x80800EC0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM3_4_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM3_4"
    VALUE
    0x80800EC1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM3_5_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM3_5"
    VALUE
    0x80800EC2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM3_7_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM3_7"
    VALUE
    0x80800EC3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM3_8_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM3_8"
    VALUE
    0x80800EC4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM6_0_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM6_0"
    VALUE
    0x80800EC5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM6_11_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM6_11"
    VALUE
    0x80800EC6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM6_12_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM6_12"
    VALUE
    0x80800EC7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM6_14_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM6_14"
    VALUE
    0x80800EC8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM6_15_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM6_15"
    VALUE
    0x80800EC9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM6_17_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM6_17"
    VALUE
    0x80800ECA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM6_18_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM6_18"
    VALUE
    0x80800ECB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM6_2_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM6_2"
    VALUE
    0x80800ECC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM6_20_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM6_20"
    VALUE
    0x80800ECD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM6_21_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM6_21"
    VALUE
    0x80800ECE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM6_25_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM6_25"
    VALUE
    0x80800ECF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM6_4_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM6_4"
    VALUE
    0x80800ED0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM6_5_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM6_5"
    VALUE
    0x80800ED1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM6_7_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM6_7"
    VALUE
    0x80800ED2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM6_8_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM6_8"
    VALUE
    0x80800ED3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM7_1_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM7_1"
    VALUE
    0x80800ED4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM7_12_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM7_12"
    VALUE
    0x80800ED5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM7_13_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM7_13"
    VALUE
    0x80800ED6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM7_14_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM7_14"
    VALUE
    0x80800ED7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM7_15_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM7_15"
    VALUE
    0x80800ED8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM7_16_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM7_16"
    VALUE
    0x80800ED9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM7_17_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM7_17"
    VALUE
    0x80800EDA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM7_2_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM7_2"
    VALUE
    0x80800EDB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM7_20_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM7_20"
    VALUE
    0x80800EDC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM7_25_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM7_25"
    VALUE
    0x80800EDD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM7_26_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM7_26"
    VALUE
    0x80800EDE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM7_28_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM7_28"
    VALUE
    0x80800EDF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM7_29_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM7_29"
    VALUE
    0x80800EE0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM7_30_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM7_30"
    VALUE
    0x80800EE1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM7_31_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM7_31"
    VALUE
    0x80800EE2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM8_0_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM8_0"
    VALUE
    0x80800EE3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM8_1_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM8_1"
    VALUE
    0x80800EE4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM8_10_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM8_10"
    VALUE
    0x80800EE5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM8_11_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM8_11"
    VALUE
    0x80800EE6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM8_12_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM8_12"
    VALUE
    0x80800EE7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM8_13_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM8_13"
    VALUE
    0x80800EE8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM8_16_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM8_16"
    VALUE
    0x80800EE9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM8_18_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM8_18"
    VALUE
    0x80800EEA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM8_2_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM8_2"
    VALUE
    0x80800EEB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM8_3_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM8_3"
    VALUE
    0x80800EEC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM8_30_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM8_30"
    VALUE
    0x80800EED
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM8_31_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM8_31"
    VALUE
    0x80800EEE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM8_4_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM8_4"
    VALUE
    0x80800EEF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM9_0_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM9_0"
    VALUE
    0x80800EF0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM9_1_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM9_1"
    VALUE
    0x80800EF1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM9_15_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM9_15"
    VALUE
    0x80800EF2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM9_3_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM9_3"
    VALUE
    0x80800EF3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MoCSOPICO_C
    "Behaviour control mask / Behaviour control masks of check DFC_MoCSOPICO"
    VALUE
    0x80800EF4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MoFVarPostBldSel_C
    "Behaviour control mask / Behaviour control masks of check DFC_MoFVarPostBldSel"
    VALUE
    0x80800EF5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MoSysCtrlReIni_C
    "Behaviour control mask / Behaviour control masks of check DFC_MoSysCtrlReIni"
    VALUE
    0x80800EF6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MoXEMMHwLTMCUFW_C
    "Behaviour control mask / Behaviour control masks of check DFC_MoXEMMHwLTMCUFW"
    VALUE
    0x80800EF7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MoXEMMHwLTMonBIST_C
    "Behaviour control mask / Behaviour control masks of check DFC_MoXEMMHwLTMonBIST"
    VALUE
    0x80800EF8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MoXEMMHwLTRegMonTest_C
    "Behaviour control mask / Behaviour control masks of check DFC_MoXEMMHwLTRegMonTest"
    VALUE
    0x80800EF9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MoXEMMHwLTStbySMUAlvTest_C
    "Behaviour control mask / Behaviour control masks of check DFC_MoXEMMHwLTStbySMUAlvTest"
    VALUE
    0x80800EFA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MoXEMMHwLTTempSens_C
    "Behaviour control mask / Behaviour control masks of check DFC_MoXEMMHwLTTempSens"
    VALUE
    0x80800EFB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MoXEMMHwLTUCBCfg_C
    "Behaviour control mask / Behaviour control masks of check DFC_MoXEMMHwLTUCBCfg"
    VALUE
    0x80800EFC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_OCWDAABEActv_C
    "Behaviour control mask / Behaviour control masks of check DFC_OCWDAABEActv"
    VALUE
    0x80800EFD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_OCWDACom_C
    "Behaviour control mask / Behaviour control masks of check DFC_OCWDACom"
    VALUE
    0x80800EFE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_OCWDAErrPin_C
    "Behaviour control mask / Behaviour control masks of check DFC_OCWDAErrPin"
    VALUE
    0x80800EFF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_SWReset_0_C
    "Behaviour control mask / Behaviour control masks of check DFC_SWReset_0"
    VALUE
    0x80800F00
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_SWReset_1_C
    "Behaviour control mask / Behaviour control masks of check DFC_SWReset_1"
    VALUE
    0x80800F01
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_SWReset_2_C
    "Behaviour control mask / Behaviour control masks of check DFC_SWReset_2"
    VALUE
    0x80800F02
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDebFault1_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDebFault1"
    VALUE
    0x80800F03
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_Unused_C
    "disable mask / "
    VALUE
    0x8080277C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    READ_ONLY

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_TimeInRowDebFault_C
    "disable mask / Disable masks of check DFC_bds_TimeInRowDebFault"
    VALUE
    0x8080277D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_EventInRowDebFault_C
    "disable mask / Disable masks of check DFC_bds_EventInRowDebFault"
    VALUE
    0x8080277E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_DevLibBattUHi_C
    "disable mask / Disable masks of check DFC_DevLibBattUHi"
    VALUE
    0x8080277F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_DevLibBattULo_C
    "disable mask / Disable masks of check DFC_DevLibBattULo"
    VALUE
    0x80802780
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_TimeUpDownDebFault_C
    "disable mask / Disable masks of check DFC_bds_TimeUpDownDebFault"
    VALUE
    0x80802781
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA13OR_C
    "disable mask / Disable masks of check DFC_rbr_inA13OR"
    VALUE
    0x80802782
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA13SCB_C
    "disable mask / Disable masks of check DFC_rbr_inA13SCB"
    VALUE
    0x80802783
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA13SCG_C
    "disable mask / Disable masks of check DFC_rbr_inA13SCG"
    VALUE
    0x80802784
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA14OR_C
    "disable mask / Disable masks of check DFC_rbr_inA14OR"
    VALUE
    0x80802785
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA14SCB_C
    "disable mask / Disable masks of check DFC_rbr_inA14SCB"
    VALUE
    0x80802786
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA14SCG_C
    "disable mask / Disable masks of check DFC_rbr_inA14SCG"
    VALUE
    0x80802787
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA21OR_C
    "disable mask / Disable masks of check DFC_rbr_inA21OR"
    VALUE
    0x80802788
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA21SCB_C
    "disable mask / Disable masks of check DFC_rbr_inA21SCB"
    VALUE
    0x80802789
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA21SCG_C
    "disable mask / Disable masks of check DFC_rbr_inA21SCG"
    VALUE
    0x8080278A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA22OR_C
    "disable mask / Disable masks of check DFC_rbr_inA22OR"
    VALUE
    0x8080278B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA22SCB_C
    "disable mask / Disable masks of check DFC_rbr_inA22SCB"
    VALUE
    0x8080278C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA22SCG_C
    "disable mask / Disable masks of check DFC_rbr_inA22SCG"
    VALUE
    0x8080278D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA23OR_C
    "disable mask / Disable masks of check DFC_rbr_inA23OR"
    VALUE
    0x8080278E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA23SCB_C
    "disable mask / Disable masks of check DFC_rbr_inA23SCB"
    VALUE
    0x8080278F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA23SCG_C
    "disable mask / Disable masks of check DFC_rbr_inA23SCG"
    VALUE
    0x80802790
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA24OR_C
    "disable mask / Disable masks of check DFC_rbr_inA24OR"
    VALUE
    0x80802791
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA24SCB_C
    "disable mask / Disable masks of check DFC_rbr_inA24SCB"
    VALUE
    0x80802792
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA24SCG_C
    "disable mask / Disable masks of check DFC_rbr_inA24SCG"
    VALUE
    0x80802793
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA25OR_C
    "disable mask / Disable masks of check DFC_rbr_inA25OR"
    VALUE
    0x80802794
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA25SCB_C
    "disable mask / Disable masks of check DFC_rbr_inA25SCB"
    VALUE
    0x80802795
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA25SCG_C
    "disable mask / Disable masks of check DFC_rbr_inA25SCG"
    VALUE
    0x80802796
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA26OR_C
    "disable mask / Disable masks of check DFC_rbr_inA26OR"
    VALUE
    0x80802797
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA26SCB_C
    "disable mask / Disable masks of check DFC_rbr_inA26SCB"
    VALUE
    0x80802798
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA26SCG_C
    "disable mask / Disable masks of check DFC_rbr_inA26SCG"
    VALUE
    0x80802799
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA27OR_C
    "disable mask / Disable masks of check DFC_rbr_inA27OR"
    VALUE
    0x8080279A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA27SCB_C
    "disable mask / Disable masks of check DFC_rbr_inA27SCB"
    VALUE
    0x8080279B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA27SCG_C
    "disable mask / Disable masks of check DFC_rbr_inA27SCG"
    VALUE
    0x8080279C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA28OR_C
    "disable mask / Disable masks of check DFC_rbr_inA28OR"
    VALUE
    0x8080279D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA28SCB_C
    "disable mask / Disable masks of check DFC_rbr_inA28SCB"
    VALUE
    0x8080279E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA28SCG_C
    "disable mask / Disable masks of check DFC_rbr_inA28SCG"
    VALUE
    0x8080279F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA29OR_C
    "disable mask / Disable masks of check DFC_rbr_inA29OR"
    VALUE
    0x808027A0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA29SCB_C
    "disable mask / Disable masks of check DFC_rbr_inA29SCB"
    VALUE
    0x808027A1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA29SCG_C
    "disable mask / Disable masks of check DFC_rbr_inA29SCG"
    VALUE
    0x808027A2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA36AicSCB_C
    "disable mask / Disable masks of check DFC_rbr_inA36AicSCB"
    VALUE
    0x808027A3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA36AicSCG_C
    "disable mask / Disable masks of check DFC_rbr_inA36AicSCG"
    VALUE
    0x808027A4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA36OR_C
    "disable mask / Disable masks of check DFC_rbr_inA36OR"
    VALUE
    0x808027A5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA36SCB_C
    "disable mask / Disable masks of check DFC_rbr_inA36SCB"
    VALUE
    0x808027A6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA36SCG_C
    "disable mask / Disable masks of check DFC_rbr_inA36SCG"
    VALUE
    0x808027A7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA36ShuntSCB_C
    "disable mask / Disable masks of check DFC_rbr_inA36ShuntSCB"
    VALUE
    0x808027A8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA37AicSCB_C
    "disable mask / Disable masks of check DFC_rbr_inA37AicSCB"
    VALUE
    0x808027A9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA37AicSCG_C
    "disable mask / Disable masks of check DFC_rbr_inA37AicSCG"
    VALUE
    0x808027AA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA37OR_C
    "disable mask / Disable masks of check DFC_rbr_inA37OR"
    VALUE
    0x808027AB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA37SCB_C
    "disable mask / Disable masks of check DFC_rbr_inA37SCB"
    VALUE
    0x808027AC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA37SCG_C
    "disable mask / Disable masks of check DFC_rbr_inA37SCG"
    VALUE
    0x808027AD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA37ShuntSCB_C
    "disable mask / Disable masks of check DFC_rbr_inA37ShuntSCB"
    VALUE
    0x808027AE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA38AicSCB_C
    "disable mask / Disable masks of check DFC_rbr_inA38AicSCB"
    VALUE
    0x808027AF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA38AicSCG_C
    "disable mask / Disable masks of check DFC_rbr_inA38AicSCG"
    VALUE
    0x808027B0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA38OR_C
    "disable mask / Disable masks of check DFC_rbr_inA38OR"
    VALUE
    0x808027B1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA38SCB_C
    "disable mask / Disable masks of check DFC_rbr_inA38SCB"
    VALUE
    0x808027B2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA38SCG_C
    "disable mask / Disable masks of check DFC_rbr_inA38SCG"
    VALUE
    0x808027B3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA38ShuntSCB_C
    "disable mask / Disable masks of check DFC_rbr_inA38ShuntSCB"
    VALUE
    0x808027B4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA39AicSCB_C
    "disable mask / Disable masks of check DFC_rbr_inA39AicSCB"
    VALUE
    0x808027B5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA39AicSCG_C
    "disable mask / Disable masks of check DFC_rbr_inA39AicSCG"
    VALUE
    0x808027B6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA39OR_C
    "disable mask / Disable masks of check DFC_rbr_inA39OR"
    VALUE
    0x808027B7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA39SCB_C
    "disable mask / Disable masks of check DFC_rbr_inA39SCB"
    VALUE
    0x808027B8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA39SCG_C
    "disable mask / Disable masks of check DFC_rbr_inA39SCG"
    VALUE
    0x808027B9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA39ShuntSCB_C
    "disable mask / Disable masks of check DFC_rbr_inA39ShuntSCB"
    VALUE
    0x808027BA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA40OR_C
    "disable mask / Disable masks of check DFC_rbr_inA40OR"
    VALUE
    0x808027BB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA40SCB_C
    "disable mask / Disable masks of check DFC_rbr_inA40SCB"
    VALUE
    0x808027BC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA40SCG_C
    "disable mask / Disable masks of check DFC_rbr_inA40SCG"
    VALUE
    0x808027BD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA41OR_C
    "disable mask / Disable masks of check DFC_rbr_inA41OR"
    VALUE
    0x808027BE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA41SCB_C
    "disable mask / Disable masks of check DFC_rbr_inA41SCB"
    VALUE
    0x808027BF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA41SCG_C
    "disable mask / Disable masks of check DFC_rbr_inA41SCG"
    VALUE
    0x808027C0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA42OR_C
    "disable mask / Disable masks of check DFC_rbr_inA42OR"
    VALUE
    0x808027C1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA42SCB_C
    "disable mask / Disable masks of check DFC_rbr_inA42SCB"
    VALUE
    0x808027C2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA42SCG_C
    "disable mask / Disable masks of check DFC_rbr_inA42SCG"
    VALUE
    0x808027C3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA43AicSCB_C
    "disable mask / Disable masks of check DFC_rbr_inA43AicSCB"
    VALUE
    0x808027C4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA43AicSCG_C
    "disable mask / Disable masks of check DFC_rbr_inA43AicSCG"
    VALUE
    0x808027C5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA43OR_C
    "disable mask / Disable masks of check DFC_rbr_inA43OR"
    VALUE
    0x808027C6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA43SCB_C
    "disable mask / Disable masks of check DFC_rbr_inA43SCB"
    VALUE
    0x808027C7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA43SCG_C
    "disable mask / Disable masks of check DFC_rbr_inA43SCG"
    VALUE
    0x808027C8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA43ShuntSCB_C
    "disable mask / Disable masks of check DFC_rbr_inA43ShuntSCB"
    VALUE
    0x808027C9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA44OL_C
    "disable mask / Disable masks of check DFC_rbr_inA44OL"
    VALUE
    0x808027CA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA44SCB_C
    "disable mask / Disable masks of check DFC_rbr_inA44SCB"
    VALUE
    0x808027CB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA44SCG_C
    "disable mask / Disable masks of check DFC_rbr_inA44SCG"
    VALUE
    0x808027CC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA57OR_C
    "disable mask / Disable masks of check DFC_rbr_inA57OR"
    VALUE
    0x808027CD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA57SCB_C
    "disable mask / Disable masks of check DFC_rbr_inA57SCB"
    VALUE
    0x808027CE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA57SCG_C
    "disable mask / Disable masks of check DFC_rbr_inA57SCG"
    VALUE
    0x808027CF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA59OL_C
    "disable mask / Disable masks of check DFC_rbr_inA59OL"
    VALUE
    0x808027D0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA59SCB_C
    "disable mask / Disable masks of check DFC_rbr_inA59SCB"
    VALUE
    0x808027D1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA59SCG_C
    "disable mask / Disable masks of check DFC_rbr_inA59SCG"
    VALUE
    0x808027D2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK10OR_C
    "disable mask / Disable masks of check DFC_rbr_inK10OR"
    VALUE
    0x808027D3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK10SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK10SCB"
    VALUE
    0x808027D4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK10SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK10SCG"
    VALUE
    0x808027D5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK11OR_C
    "disable mask / Disable masks of check DFC_rbr_inK11OR"
    VALUE
    0x808027D6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK11SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK11SCB"
    VALUE
    0x808027D7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK11SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK11SCG"
    VALUE
    0x808027D8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK30AicSCB_C
    "disable mask / Disable masks of check DFC_rbr_inK30AicSCB"
    VALUE
    0x808027D9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK30AicSCG_C
    "disable mask / Disable masks of check DFC_rbr_inK30AicSCG"
    VALUE
    0x808027DA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK30OR_C
    "disable mask / Disable masks of check DFC_rbr_inK30OR"
    VALUE
    0x808027DB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK30SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK30SCB"
    VALUE
    0x808027DC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK30SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK30SCG"
    VALUE
    0x808027DD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK30ShuntSCB_C
    "disable mask / Disable masks of check DFC_rbr_inK30ShuntSCB"
    VALUE
    0x808027DE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK31OR_C
    "disable mask / Disable masks of check DFC_rbr_inK31OR"
    VALUE
    0x808027DF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK31SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK31SCB"
    VALUE
    0x808027E0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK31SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK31SCG"
    VALUE
    0x808027E1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK32OR_C
    "disable mask / Disable masks of check DFC_rbr_inK32OR"
    VALUE
    0x808027E2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK32SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK32SCB"
    VALUE
    0x808027E3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK32SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK32SCG"
    VALUE
    0x808027E4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK33OR_C
    "disable mask / Disable masks of check DFC_rbr_inK33OR"
    VALUE
    0x808027E5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK33SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK33SCB"
    VALUE
    0x808027E6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK33SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK33SCG"
    VALUE
    0x808027E7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK34OR_C
    "disable mask / Disable masks of check DFC_rbr_inK34OR"
    VALUE
    0x808027E8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK34SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK34SCB"
    VALUE
    0x808027E9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK34SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK34SCG"
    VALUE
    0x808027EA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK35OR_C
    "disable mask / Disable masks of check DFC_rbr_inK35OR"
    VALUE
    0x808027EB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK35SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK35SCB"
    VALUE
    0x808027EC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK35SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK35SCG"
    VALUE
    0x808027ED
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK36OR_C
    "disable mask / Disable masks of check DFC_rbr_inK36OR"
    VALUE
    0x808027EE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK36SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK36SCB"
    VALUE
    0x808027EF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK36SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK36SCG"
    VALUE
    0x808027F0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK37AicSCB_C
    "disable mask / Disable masks of check DFC_rbr_inK37AicSCB"
    VALUE
    0x808027F1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK37AicSCG_C
    "disable mask / Disable masks of check DFC_rbr_inK37AicSCG"
    VALUE
    0x808027F2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK37OR_C
    "disable mask / Disable masks of check DFC_rbr_inK37OR"
    VALUE
    0x808027F3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK37SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK37SCB"
    VALUE
    0x808027F4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK37SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK37SCG"
    VALUE
    0x808027F5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK37ShuntSCB_C
    "disable mask / Disable masks of check DFC_rbr_inK37ShuntSCB"
    VALUE
    0x808027F6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK38AicSCB_C
    "disable mask / Disable masks of check DFC_rbr_inK38AicSCB"
    VALUE
    0x808027F7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK38AicSCG_C
    "disable mask / Disable masks of check DFC_rbr_inK38AicSCG"
    VALUE
    0x808027F8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK38OR_C
    "disable mask / Disable masks of check DFC_rbr_inK38OR"
    VALUE
    0x808027F9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK38SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK38SCB"
    VALUE
    0x808027FA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK38SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK38SCG"
    VALUE
    0x808027FB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK38ShuntSCB_C
    "disable mask / Disable masks of check DFC_rbr_inK38ShuntSCB"
    VALUE
    0x808027FC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK39AicSCB_C
    "disable mask / Disable masks of check DFC_rbr_inK39AicSCB"
    VALUE
    0x808027FD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK39AicSCG_C
    "disable mask / Disable masks of check DFC_rbr_inK39AicSCG"
    VALUE
    0x808027FE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK39OR_C
    "disable mask / Disable masks of check DFC_rbr_inK39OR"
    VALUE
    0x808027FF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK39SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK39SCB"
    VALUE
    0x80802800
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK39SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK39SCG"
    VALUE
    0x80802801
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK39ShuntSCB_C
    "disable mask / Disable masks of check DFC_rbr_inK39ShuntSCB"
    VALUE
    0x80802802
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK40AicSCB_C
    "disable mask / Disable masks of check DFC_rbr_inK40AicSCB"
    VALUE
    0x80802803
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK40AicSCG_C
    "disable mask / Disable masks of check DFC_rbr_inK40AicSCG"
    VALUE
    0x80802804
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK40OR_C
    "disable mask / Disable masks of check DFC_rbr_inK40OR"
    VALUE
    0x80802805
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK40SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK40SCB"
    VALUE
    0x80802806
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK40SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK40SCG"
    VALUE
    0x80802807
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK40ShuntSCB_C
    "disable mask / Disable masks of check DFC_rbr_inK40ShuntSCB"
    VALUE
    0x80802808
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK41AicSCB_C
    "disable mask / Disable masks of check DFC_rbr_inK41AicSCB"
    VALUE
    0x80802809
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK41AicSCG_C
    "disable mask / Disable masks of check DFC_rbr_inK41AicSCG"
    VALUE
    0x8080280A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK41OR_C
    "disable mask / Disable masks of check DFC_rbr_inK41OR"
    VALUE
    0x8080280B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK41SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK41SCB"
    VALUE
    0x8080280C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK41SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK41SCG"
    VALUE
    0x8080280D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK41ShuntSCB_C
    "disable mask / Disable masks of check DFC_rbr_inK41ShuntSCB"
    VALUE
    0x8080280E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK42AicSCB_C
    "disable mask / Disable masks of check DFC_rbr_inK42AicSCB"
    VALUE
    0x8080280F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK42AicSCG_C
    "disable mask / Disable masks of check DFC_rbr_inK42AicSCG"
    VALUE
    0x80802810
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK42OR_C
    "disable mask / Disable masks of check DFC_rbr_inK42OR"
    VALUE
    0x80802811
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK42SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK42SCB"
    VALUE
    0x80802812
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK42SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK42SCG"
    VALUE
    0x80802813
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK42ShuntSCB_C
    "disable mask / Disable masks of check DFC_rbr_inK42ShuntSCB"
    VALUE
    0x80802814
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK43OR_C
    "disable mask / Disable masks of check DFC_rbr_inK43OR"
    VALUE
    0x80802815
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK43SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK43SCB"
    VALUE
    0x80802816
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK43SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK43SCG"
    VALUE
    0x80802817
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK44AicSCB_C
    "disable mask / Disable masks of check DFC_rbr_inK44AicSCB"
    VALUE
    0x80802818
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK44AicSCG_C
    "disable mask / Disable masks of check DFC_rbr_inK44AicSCG"
    VALUE
    0x80802819
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK44OR_C
    "disable mask / Disable masks of check DFC_rbr_inK44OR"
    VALUE
    0x8080281A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK44SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK44SCB"
    VALUE
    0x8080281B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK44SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK44SCG"
    VALUE
    0x8080281C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK44ShuntSCB_C
    "disable mask / Disable masks of check DFC_rbr_inK44ShuntSCB"
    VALUE
    0x8080281D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK45AicSCB_C
    "disable mask / Disable masks of check DFC_rbr_inK45AicSCB"
    VALUE
    0x8080281E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK45AicSCG_C
    "disable mask / Disable masks of check DFC_rbr_inK45AicSCG"
    VALUE
    0x8080281F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK45OR_C
    "disable mask / Disable masks of check DFC_rbr_inK45OR"
    VALUE
    0x80802820
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK45SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK45SCB"
    VALUE
    0x80802821
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK45SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK45SCG"
    VALUE
    0x80802822
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK45ShuntSCB_C
    "disable mask / Disable masks of check DFC_rbr_inK45ShuntSCB"
    VALUE
    0x80802823
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK52OR_C
    "disable mask / Disable masks of check DFC_rbr_inK52OR"
    VALUE
    0x80802824
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK52SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK52SCB"
    VALUE
    0x80802825
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK52SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK52SCG"
    VALUE
    0x80802826
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK53OR_C
    "disable mask / Disable masks of check DFC_rbr_inK53OR"
    VALUE
    0x80802827
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK53SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK53SCB"
    VALUE
    0x80802828
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK53SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK53SCG"
    VALUE
    0x80802829
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK54AicSCB_C
    "disable mask / Disable masks of check DFC_rbr_inK54AicSCB"
    VALUE
    0x8080282A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK54AicSCG_C
    "disable mask / Disable masks of check DFC_rbr_inK54AicSCG"
    VALUE
    0x8080282B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK54OR_C
    "disable mask / Disable masks of check DFC_rbr_inK54OR"
    VALUE
    0x8080282C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK54SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK54SCB"
    VALUE
    0x8080282D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK54SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK54SCG"
    VALUE
    0x8080282E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK54ShuntSCB_C
    "disable mask / Disable masks of check DFC_rbr_inK54ShuntSCB"
    VALUE
    0x8080282F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK55AicSCB_C
    "disable mask / Disable masks of check DFC_rbr_inK55AicSCB"
    VALUE
    0x80802830
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK55AicSCG_C
    "disable mask / Disable masks of check DFC_rbr_inK55AicSCG"
    VALUE
    0x80802831
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK55OR_C
    "disable mask / Disable masks of check DFC_rbr_inK55OR"
    VALUE
    0x80802832
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK55SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK55SCB"
    VALUE
    0x80802833
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK55SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK55SCG"
    VALUE
    0x80802834
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK55ShuntSCB_C
    "disable mask / Disable masks of check DFC_rbr_inK55ShuntSCB"
    VALUE
    0x80802835
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK56OR_C
    "disable mask / Disable masks of check DFC_rbr_inK56OR"
    VALUE
    0x80802836
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK56SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK56SCB"
    VALUE
    0x80802837
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK56SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK56SCG"
    VALUE
    0x80802838
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK57OR_C
    "disable mask / Disable masks of check DFC_rbr_inK57OR"
    VALUE
    0x80802839
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK57SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK57SCB"
    VALUE
    0x8080283A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK57SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK57SCG"
    VALUE
    0x8080283B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK58OR_C
    "disable mask / Disable masks of check DFC_rbr_inK58OR"
    VALUE
    0x8080283C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK58SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK58SCB"
    VALUE
    0x8080283D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK58SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK58SCG"
    VALUE
    0x8080283E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK59OR_C
    "disable mask / Disable masks of check DFC_rbr_inK59OR"
    VALUE
    0x8080283F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK59SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK59SCB"
    VALUE
    0x80802840
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK59SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK59SCG"
    VALUE
    0x80802841
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK60OR_C
    "disable mask / Disable masks of check DFC_rbr_inK60OR"
    VALUE
    0x80802842
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK60SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK60SCB"
    VALUE
    0x80802843
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK60SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK60SCG"
    VALUE
    0x80802844
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK61AicSCB_C
    "disable mask / Disable masks of check DFC_rbr_inK61AicSCB"
    VALUE
    0x80802845
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK61AicSCG_C
    "disable mask / Disable masks of check DFC_rbr_inK61AicSCG"
    VALUE
    0x80802846
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK61OR_C
    "disable mask / Disable masks of check DFC_rbr_inK61OR"
    VALUE
    0x80802847
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK61SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK61SCB"
    VALUE
    0x80802848
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK61SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK61SCG"
    VALUE
    0x80802849
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK61ShuntSCB_C
    "disable mask / Disable masks of check DFC_rbr_inK61ShuntSCB"
    VALUE
    0x8080284A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK62OR_C
    "disable mask / Disable masks of check DFC_rbr_inK62OR"
    VALUE
    0x8080284B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK62SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK62SCB"
    VALUE
    0x8080284C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK62SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK62SCG"
    VALUE
    0x8080284D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK63AicSCB_C
    "disable mask / Disable masks of check DFC_rbr_inK63AicSCB"
    VALUE
    0x8080284E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK63AicSCG_C
    "disable mask / Disable masks of check DFC_rbr_inK63AicSCG"
    VALUE
    0x8080284F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK63OR_C
    "disable mask / Disable masks of check DFC_rbr_inK63OR"
    VALUE
    0x80802850
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK63SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK63SCB"
    VALUE
    0x80802851
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK63SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK63SCG"
    VALUE
    0x80802852
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK63ShuntSCB_C
    "disable mask / Disable masks of check DFC_rbr_inK63ShuntSCB"
    VALUE
    0x80802853
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK64AicSCB_C
    "disable mask / Disable masks of check DFC_rbr_inK64AicSCB"
    VALUE
    0x80802854
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK64AicSCG_C
    "disable mask / Disable masks of check DFC_rbr_inK64AicSCG"
    VALUE
    0x80802855
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK64OR_C
    "disable mask / Disable masks of check DFC_rbr_inK64OR"
    VALUE
    0x80802856
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK64SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK64SCB"
    VALUE
    0x80802857
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK64SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK64SCG"
    VALUE
    0x80802858
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK64ShuntSCB_C
    "disable mask / Disable masks of check DFC_rbr_inK64ShuntSCB"
    VALUE
    0x80802859
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK65AicSCB_C
    "disable mask / Disable masks of check DFC_rbr_inK65AicSCB"
    VALUE
    0x8080285A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK65AicSCG_C
    "disable mask / Disable masks of check DFC_rbr_inK65AicSCG"
    VALUE
    0x8080285B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK65OR_C
    "disable mask / Disable masks of check DFC_rbr_inK65OR"
    VALUE
    0x8080285C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK65SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK65SCB"
    VALUE
    0x8080285D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK65SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK65SCG"
    VALUE
    0x8080285E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK65ShuntSCB_C
    "disable mask / Disable masks of check DFC_rbr_inK65ShuntSCB"
    VALUE
    0x8080285F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK74OR_C
    "disable mask / Disable masks of check DFC_rbr_inK74OR"
    VALUE
    0x80802860
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK74SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK74SCB"
    VALUE
    0x80802861
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK74SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK74SCG"
    VALUE
    0x80802862
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK75OR_C
    "disable mask / Disable masks of check DFC_rbr_inK75OR"
    VALUE
    0x80802863
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK75SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK75SCB"
    VALUE
    0x80802864
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK75SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK75SCG"
    VALUE
    0x80802865
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK76OR_C
    "disable mask / Disable masks of check DFC_rbr_inK76OR"
    VALUE
    0x80802866
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK76SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK76SCB"
    VALUE
    0x80802867
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK76SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK76SCG"
    VALUE
    0x80802868
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK77OR_C
    "disable mask / Disable masks of check DFC_rbr_inK77OR"
    VALUE
    0x80802869
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK77SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK77SCB"
    VALUE
    0x8080286A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK77SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK77SCG"
    VALUE
    0x8080286B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK78OR_C
    "disable mask / Disable masks of check DFC_rbr_inK78OR"
    VALUE
    0x8080286C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK78SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK78SCB"
    VALUE
    0x8080286D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK78SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK78SCG"
    VALUE
    0x8080286E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_DvUBAT_FWs_C
    "disable mask / Disable masks of check DFC_rbr_mo_DvUBAT_FWs"
    VALUE
    0x8080286F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_OVErr_VPR6_C
    "disable mask / Disable masks of check DFC_rbr_mo_OVErr_VPR6"
    VALUE
    0x80802870
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_OVWarn_VPR6_C
    "disable mask / Disable masks of check DFC_rbr_mo_OVWarn_VPR6"
    VALUE
    0x80802871
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3_C
    "disable mask / Disable masks of check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3"
    VALUE
    0x80802872
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2_C
    "disable mask / Disable masks of check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2"
    VALUE
    0x80802873
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_OV_UBAT_MON_C
    "disable mask / Disable masks of check DFC_rbr_mo_OV_UBAT_MON"
    VALUE
    0x80802874
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_OV_UBRM24_FLEXIN_C
    "disable mask / Disable masks of check DFC_rbr_mo_OV_UBRM24_FLEXIN"
    VALUE
    0x80802875
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_OV_UBRM24_LOADS_C
    "disable mask / Disable masks of check DFC_rbr_mo_OV_UBRM24_LOADS"
    VALUE
    0x80802876
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_OV_UBRM24_MON_C
    "disable mask / Disable masks of check DFC_rbr_mo_OV_UBRM24_MON"
    VALUE
    0x80802877
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_OV_VDD5_C
    "disable mask / Disable masks of check DFC_rbr_mo_OV_VDD5"
    VALUE
    0x80802878
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_OV_VDD5_IN_C
    "disable mask / Disable masks of check DFC_rbr_mo_OV_VDD5_IN"
    VALUE
    0x80802879
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_OV_VPR6_C
    "disable mask / Disable masks of check DFC_rbr_mo_OV_VPR6"
    VALUE
    0x8080287A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_OV_VSS3_C
    "disable mask / Disable masks of check DFC_rbr_mo_OV_VSS3"
    VALUE
    0x8080287B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_OV_VSS4_C
    "disable mask / Disable masks of check DFC_rbr_mo_OV_VSS4"
    VALUE
    0x8080287C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_Temp1_HTErr_C
    "disable mask / Disable masks of check DFC_rbr_mo_Temp1_HTErr"
    VALUE
    0x8080287D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_Temp1_HTWarn_C
    "disable mask / Disable masks of check DFC_rbr_mo_Temp1_HTWarn"
    VALUE
    0x8080287E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_Temp2_HTErr_C
    "disable mask / Disable masks of check DFC_rbr_mo_Temp2_HTErr"
    VALUE
    0x8080287F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_Temp2_HTWarn_C
    "disable mask / Disable masks of check DFC_rbr_mo_Temp2_HTWarn"
    VALUE
    0x80802880
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3_C
    "disable mask / Disable masks of check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3"
    VALUE
    0x80802881
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2_C
    "disable mask / Disable masks of check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2"
    VALUE
    0x80802882
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_UV_VDD5_C
    "disable mask / Disable masks of check DFC_rbr_mo_UV_VDD5"
    VALUE
    0x80802883
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_UV_VDD5_IN_C
    "disable mask / Disable masks of check DFC_rbr_mo_UV_VDD5_IN"
    VALUE
    0x80802884
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_UV_VPR6_C
    "disable mask / Disable masks of check DFC_rbr_mo_UV_VPR6"
    VALUE
    0x80802885
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_UV_VSS3_C
    "disable mask / Disable masks of check DFC_rbr_mo_UV_VSS3"
    VALUE
    0x80802886
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_UV_VSS4_C
    "disable mask / Disable masks of check DFC_rbr_mo_UV_VSS4"
    VALUE
    0x80802887
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA01OL_C
    "disable mask / Disable masks of check DFC_rbr_outA01OL"
    VALUE
    0x80802888
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA01OT_C
    "disable mask / Disable masks of check DFC_rbr_outA01OT"
    VALUE
    0x80802889
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA01SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA01SCB"
    VALUE
    0x8080288A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA01SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA01SCG"
    VALUE
    0x8080288B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA02OL_C
    "disable mask / Disable masks of check DFC_rbr_outA02OL"
    VALUE
    0x8080288C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA02OR_C
    "disable mask / Disable masks of check DFC_rbr_outA02OR"
    VALUE
    0x8080288D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA02OT_C
    "disable mask / Disable masks of check DFC_rbr_outA02OT"
    VALUE
    0x8080288E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA02SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA02SCB"
    VALUE
    0x8080288F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA02SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA02SCG"
    VALUE
    0x80802890
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA03OL_C
    "disable mask / Disable masks of check DFC_rbr_outA03OL"
    VALUE
    0x80802891
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA03OT_C
    "disable mask / Disable masks of check DFC_rbr_outA03OT"
    VALUE
    0x80802892
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA03SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA03SCB"
    VALUE
    0x80802893
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA03SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA03SCG"
    VALUE
    0x80802894
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA04OL_C
    "disable mask / Disable masks of check DFC_rbr_outA04OL"
    VALUE
    0x80802895
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA04OT_C
    "disable mask / Disable masks of check DFC_rbr_outA04OT"
    VALUE
    0x80802896
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA04SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA04SCB"
    VALUE
    0x80802897
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA04SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA04SCG"
    VALUE
    0x80802898
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA05OL_C
    "disable mask / Disable masks of check DFC_rbr_outA05OL"
    VALUE
    0x80802899
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA05OR_C
    "disable mask / Disable masks of check DFC_rbr_outA05OR"
    VALUE
    0x8080289A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA05OT_C
    "disable mask / Disable masks of check DFC_rbr_outA05OT"
    VALUE
    0x8080289B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA05SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA05SCB"
    VALUE
    0x8080289C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA05SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA05SCG"
    VALUE
    0x8080289D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA06OL_C
    "disable mask / Disable masks of check DFC_rbr_outA06OL"
    VALUE
    0x8080289E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA06OR_C
    "disable mask / Disable masks of check DFC_rbr_outA06OR"
    VALUE
    0x8080289F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA06OT_C
    "disable mask / Disable masks of check DFC_rbr_outA06OT"
    VALUE
    0x808028A0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA06SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA06SCB"
    VALUE
    0x808028A1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA06SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA06SCG"
    VALUE
    0x808028A2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA07OL_C
    "disable mask / Disable masks of check DFC_rbr_outA07OL"
    VALUE
    0x808028A3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA07OT_C
    "disable mask / Disable masks of check DFC_rbr_outA07OT"
    VALUE
    0x808028A4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA07SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA07SCB"
    VALUE
    0x808028A5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA07SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA07SCG"
    VALUE
    0x808028A6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA08OL_C
    "disable mask / Disable masks of check DFC_rbr_outA08OL"
    VALUE
    0x808028A7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA08OT_C
    "disable mask / Disable masks of check DFC_rbr_outA08OT"
    VALUE
    0x808028A8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA08SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA08SCB"
    VALUE
    0x808028A9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA08SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA08SCG"
    VALUE
    0x808028AA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA09OL_C
    "disable mask / Disable masks of check DFC_rbr_outA09OL"
    VALUE
    0x808028AB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA09OR_C
    "disable mask / Disable masks of check DFC_rbr_outA09OR"
    VALUE
    0x808028AC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA09OT_C
    "disable mask / Disable masks of check DFC_rbr_outA09OT"
    VALUE
    0x808028AD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA09SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA09SCB"
    VALUE
    0x808028AE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA09SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA09SCG"
    VALUE
    0x808028AF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA10OL_C
    "disable mask / Disable masks of check DFC_rbr_outA10OL"
    VALUE
    0x808028B0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA10OT_C
    "disable mask / Disable masks of check DFC_rbr_outA10OT"
    VALUE
    0x808028B1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA10SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA10SCB"
    VALUE
    0x808028B2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA10SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA10SCG"
    VALUE
    0x808028B3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA11OL_C
    "disable mask / Disable masks of check DFC_rbr_outA11OL"
    VALUE
    0x808028B4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA11OT_C
    "disable mask / Disable masks of check DFC_rbr_outA11OT"
    VALUE
    0x808028B5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA11SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA11SCB"
    VALUE
    0x808028B6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA11SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA11SCG"
    VALUE
    0x808028B7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA12OR_C
    "disable mask / Disable masks of check DFC_rbr_outA12OR"
    VALUE
    0x808028B8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA12SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA12SCB"
    VALUE
    0x808028B9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA12SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA12SCG"
    VALUE
    0x808028BA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA16OL_C
    "disable mask / Disable masks of check DFC_rbr_outA16OL"
    VALUE
    0x808028BB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA16OT_C
    "disable mask / Disable masks of check DFC_rbr_outA16OT"
    VALUE
    0x808028BC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA16SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA16SCB"
    VALUE
    0x808028BD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA16SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA16SCG"
    VALUE
    0x808028BE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA17OL_C
    "disable mask / Disable masks of check DFC_rbr_outA17OL"
    VALUE
    0x808028BF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA17OR_C
    "disable mask / Disable masks of check DFC_rbr_outA17OR"
    VALUE
    0x808028C0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA17OT_C
    "disable mask / Disable masks of check DFC_rbr_outA17OT"
    VALUE
    0x808028C1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA17SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA17SCB"
    VALUE
    0x808028C2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA17SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA17SCG"
    VALUE
    0x808028C3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA18OL_C
    "disable mask / Disable masks of check DFC_rbr_outA18OL"
    VALUE
    0x808028C4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA18OT_C
    "disable mask / Disable masks of check DFC_rbr_outA18OT"
    VALUE
    0x808028C5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA18SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA18SCB"
    VALUE
    0x808028C6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA18SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA18SCG"
    VALUE
    0x808028C7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA19OL_C
    "disable mask / Disable masks of check DFC_rbr_outA19OL"
    VALUE
    0x808028C8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA19OR_C
    "disable mask / Disable masks of check DFC_rbr_outA19OR"
    VALUE
    0x808028C9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA19OT_C
    "disable mask / Disable masks of check DFC_rbr_outA19OT"
    VALUE
    0x808028CA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA19SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA19SCB"
    VALUE
    0x808028CB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA19SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA19SCG"
    VALUE
    0x808028CC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA20OL_C
    "disable mask / Disable masks of check DFC_rbr_outA20OL"
    VALUE
    0x808028CD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA20OR_C
    "disable mask / Disable masks of check DFC_rbr_outA20OR"
    VALUE
    0x808028CE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA20OT_C
    "disable mask / Disable masks of check DFC_rbr_outA20OT"
    VALUE
    0x808028CF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA20SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA20SCB"
    VALUE
    0x808028D0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA20SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA20SCG"
    VALUE
    0x808028D1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA31OL_C
    "disable mask / Disable masks of check DFC_rbr_outA31OL"
    VALUE
    0x808028D2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA31OR_C
    "disable mask / Disable masks of check DFC_rbr_outA31OR"
    VALUE
    0x808028D3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA31OT_C
    "disable mask / Disable masks of check DFC_rbr_outA31OT"
    VALUE
    0x808028D4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA31SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA31SCB"
    VALUE
    0x808028D5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA31SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA31SCG"
    VALUE
    0x808028D6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA32OL_C
    "disable mask / Disable masks of check DFC_rbr_outA32OL"
    VALUE
    0x808028D7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA32OR_C
    "disable mask / Disable masks of check DFC_rbr_outA32OR"
    VALUE
    0x808028D8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA32OT_C
    "disable mask / Disable masks of check DFC_rbr_outA32OT"
    VALUE
    0x808028D9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA32SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA32SCB"
    VALUE
    0x808028DA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA32SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA32SCG"
    VALUE
    0x808028DB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA33OL_C
    "disable mask / Disable masks of check DFC_rbr_outA33OL"
    VALUE
    0x808028DC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA33OR_C
    "disable mask / Disable masks of check DFC_rbr_outA33OR"
    VALUE
    0x808028DD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA33OT_C
    "disable mask / Disable masks of check DFC_rbr_outA33OT"
    VALUE
    0x808028DE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA33SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA33SCB"
    VALUE
    0x808028DF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA33SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA33SCG"
    VALUE
    0x808028E0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA34OL_C
    "disable mask / Disable masks of check DFC_rbr_outA34OL"
    VALUE
    0x808028E1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA34OR_C
    "disable mask / Disable masks of check DFC_rbr_outA34OR"
    VALUE
    0x808028E2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA34OT_C
    "disable mask / Disable masks of check DFC_rbr_outA34OT"
    VALUE
    0x808028E3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA34SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA34SCB"
    VALUE
    0x808028E4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA34SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA34SCG"
    VALUE
    0x808028E5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA35OL_C
    "disable mask / Disable masks of check DFC_rbr_outA35OL"
    VALUE
    0x808028E6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA35OR_C
    "disable mask / Disable masks of check DFC_rbr_outA35OR"
    VALUE
    0x808028E7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA35OT_C
    "disable mask / Disable masks of check DFC_rbr_outA35OT"
    VALUE
    0x808028E8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA35SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA35SCB"
    VALUE
    0x808028E9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA35SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA35SCG"
    VALUE
    0x808028EA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA46OL_C
    "disable mask / Disable masks of check DFC_rbr_outA46OL"
    VALUE
    0x808028EB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA46OR_C
    "disable mask / Disable masks of check DFC_rbr_outA46OR"
    VALUE
    0x808028EC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA46OT_C
    "disable mask / Disable masks of check DFC_rbr_outA46OT"
    VALUE
    0x808028ED
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA46SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA46SCB"
    VALUE
    0x808028EE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA46SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA46SCG"
    VALUE
    0x808028EF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA47OL_C
    "disable mask / Disable masks of check DFC_rbr_outA47OL"
    VALUE
    0x808028F0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA47OR_C
    "disable mask / Disable masks of check DFC_rbr_outA47OR"
    VALUE
    0x808028F1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA47OT_C
    "disable mask / Disable masks of check DFC_rbr_outA47OT"
    VALUE
    0x808028F2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA47SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA47SCB"
    VALUE
    0x808028F3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA47SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA47SCG"
    VALUE
    0x808028F4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA48OL_C
    "disable mask / Disable masks of check DFC_rbr_outA48OL"
    VALUE
    0x808028F5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA48OR_C
    "disable mask / Disable masks of check DFC_rbr_outA48OR"
    VALUE
    0x808028F6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA48OT_C
    "disable mask / Disable masks of check DFC_rbr_outA48OT"
    VALUE
    0x808028F7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA48SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA48SCB"
    VALUE
    0x808028F8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA48SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA48SCG"
    VALUE
    0x808028F9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA49OL_C
    "disable mask / Disable masks of check DFC_rbr_outA49OL"
    VALUE
    0x808028FA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA49OT_C
    "disable mask / Disable masks of check DFC_rbr_outA49OT"
    VALUE
    0x808028FB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA49SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA49SCB"
    VALUE
    0x808028FC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA49SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA49SCG"
    VALUE
    0x808028FD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA50OL_C
    "disable mask / Disable masks of check DFC_rbr_outA50OL"
    VALUE
    0x808028FE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA50OT_C
    "disable mask / Disable masks of check DFC_rbr_outA50OT"
    VALUE
    0x808028FF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA50SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA50SCB"
    VALUE
    0x80802900
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA50SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA50SCG"
    VALUE
    0x80802901
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA51OL_C
    "disable mask / Disable masks of check DFC_rbr_outA51OL"
    VALUE
    0x80802902
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA51OR_C
    "disable mask / Disable masks of check DFC_rbr_outA51OR"
    VALUE
    0x80802903
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA51OT_C
    "disable mask / Disable masks of check DFC_rbr_outA51OT"
    VALUE
    0x80802904
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA51SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA51SCB"
    VALUE
    0x80802905
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA51SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA51SCG"
    VALUE
    0x80802906
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA52OL_C
    "disable mask / Disable masks of check DFC_rbr_outA52OL"
    VALUE
    0x80802907
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA52OR_C
    "disable mask / Disable masks of check DFC_rbr_outA52OR"
    VALUE
    0x80802908
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA52OT_C
    "disable mask / Disable masks of check DFC_rbr_outA52OT"
    VALUE
    0x80802909
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA52SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA52SCB"
    VALUE
    0x8080290A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA52SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA52SCG"
    VALUE
    0x8080290B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA53OL_C
    "disable mask / Disable masks of check DFC_rbr_outA53OL"
    VALUE
    0x8080290C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA53OR_C
    "disable mask / Disable masks of check DFC_rbr_outA53OR"
    VALUE
    0x8080290D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA53OT_C
    "disable mask / Disable masks of check DFC_rbr_outA53OT"
    VALUE
    0x8080290E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA53SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA53SCB"
    VALUE
    0x8080290F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA53SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA53SCG"
    VALUE
    0x80802910
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA54OL_C
    "disable mask / Disable masks of check DFC_rbr_outA54OL"
    VALUE
    0x80802911
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA54OR_C
    "disable mask / Disable masks of check DFC_rbr_outA54OR"
    VALUE
    0x80802912
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA54OT_C
    "disable mask / Disable masks of check DFC_rbr_outA54OT"
    VALUE
    0x80802913
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA54SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA54SCB"
    VALUE
    0x80802914
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA54SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA54SCG"
    VALUE
    0x80802915
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA55OL_C
    "disable mask / Disable masks of check DFC_rbr_outA55OL"
    VALUE
    0x80802916
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA55OT_C
    "disable mask / Disable masks of check DFC_rbr_outA55OT"
    VALUE
    0x80802917
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA55SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA55SCB"
    VALUE
    0x80802918
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA55SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA55SCG"
    VALUE
    0x80802919
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA56OL_C
    "disable mask / Disable masks of check DFC_rbr_outA56OL"
    VALUE
    0x8080291A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA56OT_C
    "disable mask / Disable masks of check DFC_rbr_outA56OT"
    VALUE
    0x8080291B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA56SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA56SCB"
    VALUE
    0x8080291C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA56SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA56SCG"
    VALUE
    0x8080291D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA58OL_C
    "disable mask / Disable masks of check DFC_rbr_outA58OL"
    VALUE
    0x8080291E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA58OT_C
    "disable mask / Disable masks of check DFC_rbr_outA58OT"
    VALUE
    0x8080291F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA58SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA58SCB"
    VALUE
    0x80802920
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA58SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA58SCG"
    VALUE
    0x80802921
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK07OL_C
    "disable mask / Disable masks of check DFC_rbr_outK07OL"
    VALUE
    0x80802922
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK07OR_C
    "disable mask / Disable masks of check DFC_rbr_outK07OR"
    VALUE
    0x80802923
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK07OT_C
    "disable mask / Disable masks of check DFC_rbr_outK07OT"
    VALUE
    0x80802924
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK07SCB_C
    "disable mask / Disable masks of check DFC_rbr_outK07SCB"
    VALUE
    0x80802925
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK07SCG_C
    "disable mask / Disable masks of check DFC_rbr_outK07SCG"
    VALUE
    0x80802926
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK08OL_C
    "disable mask / Disable masks of check DFC_rbr_outK08OL"
    VALUE
    0x80802927
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK08OR_C
    "disable mask / Disable masks of check DFC_rbr_outK08OR"
    VALUE
    0x80802928
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK08OT_C
    "disable mask / Disable masks of check DFC_rbr_outK08OT"
    VALUE
    0x80802929
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK08SCB_C
    "disable mask / Disable masks of check DFC_rbr_outK08SCB"
    VALUE
    0x8080292A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK08SCG_C
    "disable mask / Disable masks of check DFC_rbr_outK08SCG"
    VALUE
    0x8080292B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK09OL_C
    "disable mask / Disable masks of check DFC_rbr_outK09OL"
    VALUE
    0x8080292C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK09OR_C
    "disable mask / Disable masks of check DFC_rbr_outK09OR"
    VALUE
    0x8080292D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK09OT_C
    "disable mask / Disable masks of check DFC_rbr_outK09OT"
    VALUE
    0x8080292E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK09SCB_C
    "disable mask / Disable masks of check DFC_rbr_outK09SCB"
    VALUE
    0x8080292F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK09SCG_C
    "disable mask / Disable masks of check DFC_rbr_outK09SCG"
    VALUE
    0x80802930
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK12OL_C
    "disable mask / Disable masks of check DFC_rbr_outK12OL"
    VALUE
    0x80802931
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK12OT_C
    "disable mask / Disable masks of check DFC_rbr_outK12OT"
    VALUE
    0x80802932
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK12SCB_C
    "disable mask / Disable masks of check DFC_rbr_outK12SCB"
    VALUE
    0x80802933
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK12SCG_C
    "disable mask / Disable masks of check DFC_rbr_outK12SCG"
    VALUE
    0x80802934
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK13OL_C
    "disable mask / Disable masks of check DFC_rbr_outK13OL"
    VALUE
    0x80802935
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK13OT_C
    "disable mask / Disable masks of check DFC_rbr_outK13OT"
    VALUE
    0x80802936
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK13SCB_C
    "disable mask / Disable masks of check DFC_rbr_outK13SCB"
    VALUE
    0x80802937
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK13SCG_C
    "disable mask / Disable masks of check DFC_rbr_outK13SCG"
    VALUE
    0x80802938
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK14OL_C
    "disable mask / Disable masks of check DFC_rbr_outK14OL"
    VALUE
    0x80802939
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK14OR_C
    "disable mask / Disable masks of check DFC_rbr_outK14OR"
    VALUE
    0x8080293A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK14OT_C
    "disable mask / Disable masks of check DFC_rbr_outK14OT"
    VALUE
    0x8080293B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK14SCB_C
    "disable mask / Disable masks of check DFC_rbr_outK14SCB"
    VALUE
    0x8080293C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK14SCG_C
    "disable mask / Disable masks of check DFC_rbr_outK14SCG"
    VALUE
    0x8080293D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK15OL_C
    "disable mask / Disable masks of check DFC_rbr_outK15OL"
    VALUE
    0x8080293E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK15OR_C
    "disable mask / Disable masks of check DFC_rbr_outK15OR"
    VALUE
    0x8080293F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK15OT_C
    "disable mask / Disable masks of check DFC_rbr_outK15OT"
    VALUE
    0x80802940
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK15SCB_C
    "disable mask / Disable masks of check DFC_rbr_outK15SCB"
    VALUE
    0x80802941
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK15SCG_C
    "disable mask / Disable masks of check DFC_rbr_outK15SCG"
    VALUE
    0x80802942
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK16OL_C
    "disable mask / Disable masks of check DFC_rbr_outK16OL"
    VALUE
    0x80802943
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK16OR_C
    "disable mask / Disable masks of check DFC_rbr_outK16OR"
    VALUE
    0x80802944
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK16OT_C
    "disable mask / Disable masks of check DFC_rbr_outK16OT"
    VALUE
    0x80802945
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK16SCB_C
    "disable mask / Disable masks of check DFC_rbr_outK16SCB"
    VALUE
    0x80802946
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK16SCG_C
    "disable mask / Disable masks of check DFC_rbr_outK16SCG"
    VALUE
    0x80802947
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK17OL_C
    "disable mask / Disable masks of check DFC_rbr_outK17OL"
    VALUE
    0x80802948
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK17OR_C
    "disable mask / Disable masks of check DFC_rbr_outK17OR"
    VALUE
    0x80802949
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK17OT_C
    "disable mask / Disable masks of check DFC_rbr_outK17OT"
    VALUE
    0x8080294A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK17SCB_C
    "disable mask / Disable masks of check DFC_rbr_outK17SCB"
    VALUE
    0x8080294B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK17SCG_C
    "disable mask / Disable masks of check DFC_rbr_outK17SCG"
    VALUE
    0x8080294C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK25OR_C
    "disable mask / Disable masks of check DFC_rbr_outK25OR"
    VALUE
    0x8080294D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK25SCB_C
    "disable mask / Disable masks of check DFC_rbr_outK25SCB"
    VALUE
    0x8080294E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK25SCG_C
    "disable mask / Disable masks of check DFC_rbr_outK25SCG"
    VALUE
    0x8080294F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK29OL_C
    "disable mask / Disable masks of check DFC_rbr_outK29OL"
    VALUE
    0x80802950
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK29OR_C
    "disable mask / Disable masks of check DFC_rbr_outK29OR"
    VALUE
    0x80802951
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK29OT_C
    "disable mask / Disable masks of check DFC_rbr_outK29OT"
    VALUE
    0x80802952
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK29SCB_C
    "disable mask / Disable masks of check DFC_rbr_outK29SCB"
    VALUE
    0x80802953
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK29SCG_C
    "disable mask / Disable masks of check DFC_rbr_outK29SCG"
    VALUE
    0x80802954
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK51OL_C
    "disable mask / Disable masks of check DFC_rbr_outK51OL"
    VALUE
    0x80802955
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK51OT_C
    "disable mask / Disable masks of check DFC_rbr_outK51OT"
    VALUE
    0x80802956
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK51SCB_C
    "disable mask / Disable masks of check DFC_rbr_outK51SCB"
    VALUE
    0x80802957
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK51SCG_C
    "disable mask / Disable masks of check DFC_rbr_outK51SCG"
    VALUE
    0x80802958
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK62OR_C
    "disable mask / Disable masks of check DFC_rbr_outK62OR"
    VALUE
    0x80802959
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK62SCB_C
    "disable mask / Disable masks of check DFC_rbr_outK62SCB"
    VALUE
    0x8080295A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK62SCG_C
    "disable mask / Disable masks of check DFC_rbr_outK62SCG"
    VALUE
    0x8080295B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK73OL_C
    "disable mask / Disable masks of check DFC_rbr_outK73OL"
    VALUE
    0x8080295C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK73OR_C
    "disable mask / Disable masks of check DFC_rbr_outK73OR"
    VALUE
    0x8080295D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK73OT_C
    "disable mask / Disable masks of check DFC_rbr_outK73OT"
    VALUE
    0x8080295E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK73SCB_C
    "disable mask / Disable masks of check DFC_rbr_outK73SCB"
    VALUE
    0x8080295F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK73SCG_C
    "disable mask / Disable masks of check DFC_rbr_outK73SCG"
    VALUE
    0x80802960
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK80OL_C
    "disable mask / Disable masks of check DFC_rbr_outK80OL"
    VALUE
    0x80802961
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK80OT_C
    "disable mask / Disable masks of check DFC_rbr_outK80OT"
    VALUE
    0x80802962
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK80SCB_C
    "disable mask / Disable masks of check DFC_rbr_outK80SCB"
    VALUE
    0x80802963
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK80SCG_C
    "disable mask / Disable masks of check DFC_rbr_outK80SCG"
    VALUE
    0x80802964
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK81OL_C
    "disable mask / Disable masks of check DFC_rbr_outK81OL"
    VALUE
    0x80802965
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK81OT_C
    "disable mask / Disable masks of check DFC_rbr_outK81OT"
    VALUE
    0x80802966
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK81SCB_C
    "disable mask / Disable masks of check DFC_rbr_outK81SCB"
    VALUE
    0x80802967
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK81SCG_C
    "disable mask / Disable masks of check DFC_rbr_outK81SCG"
    VALUE
    0x80802968
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK82OL_C
    "disable mask / Disable masks of check DFC_rbr_outK82OL"
    VALUE
    0x80802969
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK82OT_C
    "disable mask / Disable masks of check DFC_rbr_outK82OT"
    VALUE
    0x8080296A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK82SCB_C
    "disable mask / Disable masks of check DFC_rbr_outK82SCB"
    VALUE
    0x8080296B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK82SCG_C
    "disable mask / Disable masks of check DFC_rbr_outK82SCG"
    VALUE
    0x8080296C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK83OL_C
    "disable mask / Disable masks of check DFC_rbr_outK83OL"
    VALUE
    0x8080296D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK83OT_C
    "disable mask / Disable masks of check DFC_rbr_outK83OT"
    VALUE
    0x8080296E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK83SCB_C
    "disable mask / Disable masks of check DFC_rbr_outK83SCB"
    VALUE
    0x8080296F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK83SCG_C
    "disable mask / Disable masks of check DFC_rbr_outK83SCG"
    VALUE
    0x80802970
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK84OL_C
    "disable mask / Disable masks of check DFC_rbr_outK84OL"
    VALUE
    0x80802971
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK84OT_C
    "disable mask / Disable masks of check DFC_rbr_outK84OT"
    VALUE
    0x80802972
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK84SCB_C
    "disable mask / Disable masks of check DFC_rbr_outK84SCB"
    VALUE
    0x80802973
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK84SCG_C
    "disable mask / Disable masks of check DFC_rbr_outK84SCG"
    VALUE
    0x80802974
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK85OL_C
    "disable mask / Disable masks of check DFC_rbr_outK85OL"
    VALUE
    0x80802975
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK85OT_C
    "disable mask / Disable masks of check DFC_rbr_outK85OT"
    VALUE
    0x80802976
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK85SCB_C
    "disable mask / Disable masks of check DFC_rbr_outK85SCB"
    VALUE
    0x80802977
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK85SCG_C
    "disable mask / Disable masks of check DFC_rbr_outK85SCG"
    VALUE
    0x80802978
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK86OL_C
    "disable mask / Disable masks of check DFC_rbr_outK86OL"
    VALUE
    0x80802979
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK86OT_C
    "disable mask / Disable masks of check DFC_rbr_outK86OT"
    VALUE
    0x8080297A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK86SCB_C
    "disable mask / Disable masks of check DFC_rbr_outK86SCB"
    VALUE
    0x8080297B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK86SCG_C
    "disable mask / Disable masks of check DFC_rbr_outK86SCG"
    VALUE
    0x8080297C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK87OL_C
    "disable mask / Disable masks of check DFC_rbr_outK87OL"
    VALUE
    0x8080297D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK87OT_C
    "disable mask / Disable masks of check DFC_rbr_outK87OT"
    VALUE
