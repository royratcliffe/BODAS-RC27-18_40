    "AUTOSAR: DTC severity class / Check DFC_rbr_outK29SCB"
    VALUE
    0x80806E9B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK29SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK29SCG"
    VALUE
    0x80806E9C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK51OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK51OL"
    VALUE
    0x80806E9D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK51OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK51OT"
    VALUE
    0x80806E9E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK51SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK51SCB"
    VALUE
    0x80806E9F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK51SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK51SCG"
    VALUE
    0x80806EA0
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK62OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK62OR"
    VALUE
    0x80806EA1
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK62SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK62SCB"
    VALUE
    0x80806EA2
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK62SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK62SCG"
    VALUE
    0x80806EA3
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK73OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK73OL"
    VALUE
    0x80806EA4
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK73OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK73OR"
    VALUE
    0x80806EA5
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK73OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK73OT"
    VALUE
    0x80806EA6
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK73SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK73SCB"
    VALUE
    0x80806EA7
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK73SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK73SCG"
    VALUE
    0x80806EA8
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK80OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK80OL"
    VALUE
    0x80806EA9
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK80OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK80OT"
    VALUE
    0x80806EAA
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK80SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK80SCB"
    VALUE
    0x80806EAB
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK80SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK80SCG"
    VALUE
    0x80806EAC
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK81OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK81OL"
    VALUE
    0x80806EAD
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK81OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK81OT"
    VALUE
    0x80806EAE
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK81SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK81SCB"
    VALUE
    0x80806EAF
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK81SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK81SCG"
    VALUE
    0x80806EB0
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK82OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK82OL"
    VALUE
    0x80806EB1
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK82OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK82OT"
    VALUE
    0x80806EB2
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK82SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK82SCB"
    VALUE
    0x80806EB3
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK82SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK82SCG"
    VALUE
    0x80806EB4
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK83OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK83OL"
    VALUE
    0x80806EB5
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK83OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK83OT"
    VALUE
    0x80806EB6
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK83SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK83SCB"
    VALUE
    0x80806EB7
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK83SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK83SCG"
    VALUE
    0x80806EB8
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK84OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK84OL"
    VALUE
    0x80806EB9
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK84OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK84OT"
    VALUE
    0x80806EBA
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK84SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK84SCB"
    VALUE
    0x80806EBB
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK84SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK84SCG"
    VALUE
    0x80806EBC
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK85OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK85OL"
    VALUE
    0x80806EBD
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK85OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK85OT"
    VALUE
    0x80806EBE
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK85SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK85SCB"
    VALUE
    0x80806EBF
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK85SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK85SCG"
    VALUE
    0x80806EC0
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK86OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK86OL"
    VALUE
    0x80806EC1
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK86OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK86OT"
    VALUE
    0x80806EC2
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK86SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK86SCB"
    VALUE
    0x80806EC3
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK86SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK86SCG"
    VALUE
    0x80806EC4
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK87OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK87OL"
    VALUE
    0x80806EC5
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK87OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK87OT"
    VALUE
    0x80806EC6
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK87SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK87SCB"
    VALUE
    0x80806EC7
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK87SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK87SCG"
    VALUE
    0x80806EC8
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_EventUpDownDebFault_C
    "AUTOSAR: DTC severity class / Check DFC_bds_EventUpDownDebFault"
    VALUE
    0x80806EC9
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_DSMDummy_C
    "AUTOSAR: DTC severity class / Check DFC_DSMDummy"
    VALUE
    0x80806ECA
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canGetDataNoBuf_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canGetDataNoBuf"
    VALUE
    0x80806ECB
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canGetDataParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canGetDataParam"
    VALUE
    0x80806ECC
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canGetDataboxNoInit_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canGetDataboxNoInit"
    VALUE
    0x80806ECD
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canGetDataboxParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canGetDataboxParam"
    VALUE
    0x80806ECE
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canGetRxBufStatusParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canGetRxBufStatusParam"
    VALUE
    0x80806ECF
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canGetStatusParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canGetStatusParam"
    VALUE
    0x80806ED0
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canGetTxBufStatusParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canGetTxBufStatusParam"
    VALUE
    0x80806ED1
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canInitParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canInitParam"
    VALUE
    0x80806ED2
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canInitRxDataboxOverlap_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canInitRxDataboxOverlap"
    VALUE
    0x80806ED3
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canInitRxDataboxParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canInitRxDataboxParam"
    VALUE
    0x80806ED4
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canInitTxDataboxParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canInitTxDataboxParam"
    VALUE
    0x80806ED5
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canIpduGroupControl_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canIpduGroupControl"
    VALUE
    0x80806ED6
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canIsDataboxFreeNoInit_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canIsDataboxFreeNoInit"
    VALUE
    0x80806ED7
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canIsDataboxFreeParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canIsDataboxFreeParam"
    VALUE
    0x80806ED8
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canIsTxEmptyParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canIsTxEmptyParam"
    VALUE
    0x80806ED9
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canRegBusOffCallbInvState_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canRegBusOffCallbInvState"
    VALUE
    0x80806EDA
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canRegBusOffCallbParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canRegBusOffCallbParam"
    VALUE
    0x80806EDB
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canRegRxBufInvState_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canRegRxBufInvState"
    VALUE
    0x80806EDC
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canRegRxBufOverlap_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canRegRxBufOverlap"
    VALUE
    0x80806EDD
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canRegRxBufParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canRegRxBufParam"
    VALUE
    0x80806EDE
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canRegRxCallbInvState_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canRegRxCallbInvState"
    VALUE
    0x80806EDF
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canRegRxCallbParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canRegRxCallbParam"
    VALUE
    0x80806EE0
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canRegRxDataboxInvNumb_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canRegRxDataboxInvNumb"
    VALUE
    0x80806EE1
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canRegRxDataboxInvState_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canRegRxDataboxInvState"
    VALUE
    0x80806EE2
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canRegRxDataboxOverlap_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canRegRxDataboxOverlap"
    VALUE
    0x80806EE3
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canRegRxDataboxParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canRegRxDataboxParam"
    VALUE
    0x80806EE4
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canRegTxBufInvState_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canRegTxBufInvState"
    VALUE
    0x80806EE5
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canRegTxBufOverlap_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canRegTxBufOverlap"
    VALUE
    0x80806EE6
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canRegTxBufParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canRegTxBufParam"
    VALUE
    0x80806EE7
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canRegTxDataboxInvNumb_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canRegTxDataboxInvNumb"
    VALUE
    0x80806EE8
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canRegTxDataboxInvState_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canRegTxDataboxInvState"
    VALUE
    0x80806EE9
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canRegTxDataboxOverlap_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canRegTxDataboxOverlap"
    VALUE
    0x80806EEA
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canRegTxDataboxParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canRegTxDataboxParam"
    VALUE
    0x80806EEB
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canResetTxBufParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canResetTxBufParam"
    VALUE
    0x80806EEC
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canSendDataBufOvfl_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canSendDataBufOvfl"
    VALUE
    0x80806EED
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canSendDataParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canSendDataParam"
    VALUE
    0x80806EEE
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canSendDataboxNoInit_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canSendDataboxNoInit"
    VALUE
    0x80806EEF
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canSendDataboxParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canSendDataboxParam"
    VALUE
    0x80806EF0
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canSetTxCycleParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canSetTxCycleParam"
    VALUE
    0x80806EF1
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canStartParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canStartParam"
    VALUE
    0x80806EF2
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canStopParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canStopParam"
    VALUE
    0x80806EF3
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_can_ClearIpduGroup_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_can_ClearIpduGroup"
    VALUE
    0x80806EF4
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_can_ReceiveSignal_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_can_ReceiveSignal"
    VALUE
    0x80806EF5
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_can_SendSignal_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_can_SendSignal"
    VALUE
    0x80806EF6
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_can_SetIpduGroup_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_can_SetIpduGroup"
    VALUE
    0x80806EF7
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_dsmDTCJ1939_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_dsmDTCJ1939"
    VALUE
    0x80806EF8
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_dsmDelDTCJ1939_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_dsmDelDTCJ1939"
    VALUE
    0x80806EF9
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_dsmDelErrors_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_dsmDelErrors"
    VALUE
    0x80806EFA
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_dsmGetDFES_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_dsmGetDFES"
    VALUE
    0x80806EFB
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_dsmGetDTCJ1939_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_dsmGetDTCJ1939"
    VALUE
    0x80806EFC
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_dsmGetErrors_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_dsmGetErrors"
    VALUE
    0x80806EFD
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_dsmGetNumErrors_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_dsmGetNumErrors"
    VALUE
    0x80806EFE
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_dsmInitQueueOverflow_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_dsmInitQueueOverflow"
    VALUE
    0x80806EFF
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_dsmNumDTCJ1939_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_dsmNumDTCJ1939"
    VALUE
    0x80806F00
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_dsmTesterror_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_dsmTesterror"
    VALUE
    0x80806F01
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_dsmUpdateDebError_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_dsmUpdateDebError"
    VALUE
    0x80806F02
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_dsmUpdateError_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_dsmUpdateError"
    VALUE
    0x80806F03
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_dsmgetDFCStatus_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_dsmgetDFCStatus"
    VALUE
    0x80806F04
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_dsmtestErrorDFC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_dsmtestErrorDFC"
    VALUE
    0x80806F05
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inAi_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inAi"
    VALUE
    0x80806F06
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inAic_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inAic"
    VALUE
    0x80806F07
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inAicCfg_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inAicCfg"
    VALUE
    0x80806F08
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inAicGetStatus_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inAicGetStatus"
    VALUE
    0x80806F09
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inAid_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inAid"
    VALUE
    0x80806F0A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inAidCfg_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inAidCfg"
    VALUE
    0x80806F0B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inAiv_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inAiv"
    VALUE
    0x80806F0C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inAivCfg_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inAivCfg"
    VALUE
    0x80806F0D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inAivGetStatus_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inAivGetStatus"
    VALUE
    0x80806F0E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inDi_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inDi"
    VALUE
    0x80806F0F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inFi_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inFi"
    VALUE
    0x80806F10
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inFiCfg_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inFiCfg"
    VALUE
    0x80806F11
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inFiGetStatus_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inFiGetStatus"
    VALUE
    0x80806F12
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inFi_Buffered_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inFi_Buffered"
    VALUE
    0x80806F13
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inPhase_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inPhase"
    VALUE
    0x80806F14
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inPhaseGetStatus_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inPhaseGetStatus"
    VALUE
    0x80806F15
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inPhaseResetCounter_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inPhaseResetCounter"
    VALUE
    0x80806F16
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inRi_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inRi"
    VALUE
    0x80806F17
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inRiCfg_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inRiCfg"
    VALUE
    0x80806F18
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inRiCfgTemp_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inRiCfgTemp"
    VALUE
    0x80806F19
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inRiGetStatus_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inRiGetStatus"
    VALUE
    0x80806F1A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inRiGetTemp_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inRiGetTemp"
    VALUE
    0x80806F1B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inSentCopyFDFifo_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inSentCopyFDFifo"
    VALUE
    0x80806F1C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inSentDisable_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inSentDisable"
    VALUE
    0x80806F1D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inSentEnable_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inSentEnable"
    VALUE
    0x80806F1E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inSentGetErrorStatus_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inSentGetErrorStatus"
    VALUE
    0x80806F1F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inSentGetFD_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inSentGetFD"
    VALUE
    0x80806F20
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inSentGetSD_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inSentGetSD"
    VALUE
    0x80806F21
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inSentGetSDDatabox_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inSentGetSDDatabox"
    VALUE
    0x80806F22
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inSentGetStatus_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inSentGetStatus"
    VALUE
    0x80806F23
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inSentInitSDDatabox_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inSentInitSDDatabox"
    VALUE
    0x80806F24
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inSentRegisterCopyFDFifo_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inSentRegisterCopyFDFifo"
    VALUE
    0x80806F25
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inSentRegisterFDFifo_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inSentRegisterFDFifo"
    VALUE
    0x80806F26
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inSentRegisterSDDataboxes_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inSentRegisterSDDataboxes"
    VALUE
    0x80806F27
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_isobusCanRxBufferOverflow_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_isobusCanRxBufferOverflow"
    VALUE
    0x80806F28
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_isobusGetCaAddrParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_isobusGetCaAddrParam"
    VALUE
    0x80806F29
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_isobusGetDiagnosticParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_isobusGetDiagnosticParam"
    VALUE
    0x80806F2A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_isobusGetRxDataboxStatusParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_isobusGetRxDataboxStatusParam"
    VALUE
    0x80806F2B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_isobusGetStatusParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_isobusGetStatusParam"
    VALUE
    0x80806F2C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_isobusInitCommCaMissing_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_isobusInitCommCaMissing"
    VALUE
    0x80806F2D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_isobusInitCommParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_isobusInitCommParam"
    VALUE
    0x80806F2E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_isobusInitCommState_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_isobusInitCommState"
    VALUE
    0x80806F2F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_isobusInitDiagnosticParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_isobusInitDiagnosticParam"
    VALUE
    0x80806F30
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_isobusInitFailureListParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_isobusInitFailureListParam"
    VALUE
    0x80806F31
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_isobusInitRxDataboxParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_isobusInitRxDataboxParam"
    VALUE
    0x80806F32
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_isobusInitTxDataboxParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_isobusInitTxDataboxParam"
    VALUE
    0x80806F33
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_isobusRegRxDataboxOverlap_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_isobusRegRxDataboxOverlap"
    VALUE
    0x80806F34
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_isobusRegRxDataboxParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_isobusRegRxDataboxParam"
    VALUE
    0x80806F35
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_isobusRegRxDataboxState_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_isobusRegRxDataboxState"
    VALUE
    0x80806F36
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_isobusRegTxDataboxOverlap_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_isobusRegTxDataboxOverlap"
    VALUE
    0x80806F37
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_isobusRegTxDataboxParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_isobusRegTxDataboxParam"
    VALUE
    0x80806F38
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_isobusRegTxDataboxState_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_isobusRegTxDataboxState"
    VALUE
    0x80806F39
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_isobusRegisterErrClrCallbackParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_isobusRegisterErrClrCallbackParam"
    VALUE
    0x80806F3A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_isobusRegisterInstancesOverlap_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_isobusRegisterInstancesOverlap"
    VALUE
    0x80806F3B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_isobusRegisterInstancesParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_isobusRegisterInstancesParam"
    VALUE
    0x80806F3C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_isobusRegisterInstancesState_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_isobusRegisterInstancesState"
    VALUE
    0x80806F3D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_isobusSendDataboxParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_isobusSendDataboxParam"
    VALUE
    0x80806F3E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_isobusSendRequestPGNParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_isobusSendRequestPGNParam"
    VALUE
    0x80806F3F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_isobusSetCaAddrCaUsed_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_isobusSetCaAddrCaUsed"
    VALUE
    0x80806F40
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_isobusSetCaAddrComm_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_isobusSetCaAddrComm"
    VALUE
    0x80806F41
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_isobusSetCaAddrInvCan_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_isobusSetCaAddrInvCan"
    VALUE
    0x80806F42
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_isobusSetCaAddrParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_isobusSetCaAddrParam"
    VALUE
    0x80806F43
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_isobusSetCaInfoParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_isobusSetCaInfoParam"
    VALUE
    0x80806F44
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_isobusSetCaNameParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_isobusSetCaNameParam"
    VALUE
    0x80806F45
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_isobusSftyCanTxErr_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_isobusSftyCanTxErr"
    VALUE
    0x80806F46
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_lin_ReceiveSignal_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_lin_ReceiveSignal"
    VALUE
    0x80806F47
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_lin_SendSignal_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_lin_SendSignal"
    VALUE
    0x80806F48
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_lin_getStatus_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_lin_getStatus"
    VALUE
    0x80806F49
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_lin_gotoSleep_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_lin_gotoSleep"
    VALUE
    0x80806F4A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_lin_scheduleRequest_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_lin_scheduleRequest"
    VALUE
    0x80806F4B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_lin_wakeUp_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_lin_wakeUp"
    VALUE
    0x80806F4C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_memFlsCfgShr_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_memFlsCfgShr"
    VALUE
    0x80806F4D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_memGetStatus_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_memGetStatus"
    VALUE
    0x80806F4E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_memMarkBlock_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_memMarkBlock"
    VALUE
    0x80806F4F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_memReadApi1Error_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_memReadApi1Error"
    VALUE
    0x80806F50
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_memReadApi2Error_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_memReadApi2Error"
    VALUE
    0x80806F51
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_memReadBlock_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_memReadBlock"
    VALUE
    0x80806F52
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_memReadCalibInputError_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_memReadCalibInputError"
    VALUE
    0x80806F53
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_memReadCalibOuputError_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_memReadCalibOuputError"
    VALUE
    0x80806F54
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_memReadSystemError_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_memReadSystemError"
    VALUE
    0x80806F55
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_memWriteBlock_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_memWriteBlock"
    VALUE
    0x80806F56
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_moOV_FirstConstADC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_moOV_FirstConstADC"
    VALUE
    0x80806F57
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_moOV_SecondConstADC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_moOV_SecondConstADC"
    VALUE
    0x80806F58
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_moUV_FirstConstADC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_moUV_FirstConstADC"
    VALUE
    0x80806F59
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_moUV_SecondConstADC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_moUV_SecondConstADC"
    VALUE
    0x80806F5A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_INH_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_INH"
    VALUE
    0x80806F5B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_INHLatch_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_INHLatch"
    VALUE
    0x80806F5C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_adcPDD_fail_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_adcPDD_fail"
    VALUE
    0x80806F5D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_memoryProtection_err_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_memoryProtection_err"
    VALUE
    0x80806F5E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA02OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA02OC"
    VALUE
    0x80806F5F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA02Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA02Unintended"
    VALUE
    0x80806F60
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA03OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA03OC"
    VALUE
    0x80806F61
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA03Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA03Unintended"
    VALUE
    0x80806F62
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA04OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA04OC"
    VALUE
    0x80806F63
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA04Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA04Unintended"
    VALUE
    0x80806F64
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA05OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA05OC"
    VALUE
    0x80806F65
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA05Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA05Unintended"
    VALUE
    0x80806F66
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA07OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA07OC"
    VALUE
    0x80806F67
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA07Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA07Unintended"
    VALUE
    0x80806F68
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA08OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA08OC"
    VALUE
    0x80806F69
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA08Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA08Unintended"
    VALUE
    0x80806F6A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA09OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA09OC"
    VALUE
    0x80806F6B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA09Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA09Unintended"
    VALUE
    0x80806F6C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA10OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA10OC"
    VALUE
    0x80806F6D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA10Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA10Unintended"
    VALUE
    0x80806F6E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA17OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA17OC"
    VALUE
    0x80806F6F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA17Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA17Unintended"
    VALUE
    0x80806F70
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA18OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA18OC"
    VALUE
    0x80806F71
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA18Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA18Unintended"
    VALUE
    0x80806F72
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA19OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA19OC"
    VALUE
    0x80806F73
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA19Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA19Unintended"
    VALUE
    0x80806F74
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA20OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA20OC"
    VALUE
    0x80806F75
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA20Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA20Unintended"
    VALUE
    0x80806F76
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA31OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA31OC"
    VALUE
    0x80806F77
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA31Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA31Unintended"
    VALUE
    0x80806F78
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA32OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA32OC"
    VALUE
    0x80806F79
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA32Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA32Unintended"
    VALUE
    0x80806F7A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA33OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA33OC"
    VALUE
    0x80806F7B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA33Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA33Unintended"
    VALUE
    0x80806F7C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA34OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA34OC"
    VALUE
    0x80806F7D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA34Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA34Unintended"
    VALUE
    0x80806F7E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA35OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA35OC"
    VALUE
    0x80806F7F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA35Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA35Unintended"
    VALUE
    0x80806F80
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA46OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA46OC"
    VALUE
    0x80806F81
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA46Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA46Unintended"
    VALUE
    0x80806F82
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA47OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA47OC"
    VALUE
    0x80806F83
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA47Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA47Unintended"
    VALUE
    0x80806F84
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA48OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA48OC"
    VALUE
    0x80806F85
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA48Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA48Unintended"
    VALUE
    0x80806F86
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA51OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA51OC"
    VALUE
    0x80806F87
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA51Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA51Unintended"
    VALUE
    0x80806F88
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA52OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA52OC"
    VALUE
    0x80806F89
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA52Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA52Unintended"
    VALUE
    0x80806F8A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA53OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA53OC"
    VALUE
    0x80806F8B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA53Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA53Unintended"
    VALUE
    0x80806F8C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA54OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA54OC"
    VALUE
    0x80806F8D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA54Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA54Unintended"
    VALUE
    0x80806F8E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outAov_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outAov"
    VALUE
    0x80806F8F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outAovCfg_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outAovCfg"
    VALUE
    0x80806F90
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outAovCfgPI_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outAovCfgPI"
    VALUE
    0x80806F91
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outAovGetStatus_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outAovGetStatus"
    VALUE
    0x80806F92
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outAovGetVoltage_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outAovGetVoltage"
    VALUE
    0x80806F93
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outAovResetError_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outAovResetError"
    VALUE
    0x80806F94
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outDo_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outDo"
    VALUE
    0x80806F95
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outDoCfgPwrLs_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outDoCfgPwrLs"
    VALUE
    0x80806F96
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outDoDisable_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outDoDisable"
    VALUE
    0x80806F97
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outDoGetCurrent_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outDoGetCurrent"
    VALUE
    0x80806F98
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outDoGetStatus_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outDoGetStatus"
    VALUE
    0x80806F99
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outDoResetError_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outDoResetError"
    VALUE
    0x80806F9A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK07OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK07OC"
    VALUE
    0x80806F9B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK07Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK07Unintended"
    VALUE
    0x80806F9C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK08OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK08OC"
    VALUE
    0x80806F9D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK08Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK08Unintended"
    VALUE
    0x80806F9E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK09OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK09OC"
    VALUE
    0x80806F9F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK09Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK09Unintended"
    VALUE
    0x80806FA0
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK12OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK12OC"
    VALUE
    0x80806FA1
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK12Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK12Unintended"
    VALUE
    0x80806FA2
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK13OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK13OC"
    VALUE
    0x80806FA3
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK13Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK13Unintended"
    VALUE
    0x80806FA4
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK14OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK14OC"
    VALUE
    0x80806FA5
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK14Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK14Unintended"
    VALUE
    0x80806FA6
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK15OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK15OC"
    VALUE
    0x80806FA7
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK15Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK15Unintended"
    VALUE
    0x80806FA8
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK16OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK16OC"
    VALUE
    0x80806FA9
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK16Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK16Unintended"
    VALUE
    0x80806FAA
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK17OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK17OC"
    VALUE
    0x80806FAB
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK17Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK17Unintended"
    VALUE
    0x80806FAC
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK29OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK29OC"
    VALUE
    0x80806FAD
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK29Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK29Unintended"
    VALUE
    0x80806FAE
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK51OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK51OC"
    VALUE
    0x80806FAF
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK51Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK51Unintended"
    VALUE
    0x80806FB0
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK73OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK73OC"
    VALUE
    0x80806FB1
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK73Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK73Unintended"
    VALUE
    0x80806FB2
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outPo_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outPo"
    VALUE
    0x80806FB3
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outPoCfg_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outPoCfg"
    VALUE
    0x80806FB4
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outPoCfgPeriod_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outPoCfgPeriod"
    VALUE
    0x80806FB5
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outPoCfgPwrLs_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outPoCfgPwrLs"
    VALUE
    0x80806FB6
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outPoDisable_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outPoDisable"
    VALUE
    0x80806FB7
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outPoGetCurrent_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outPoGetCurrent"
    VALUE
    0x80806FB8
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outPoGetStatus_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outPoGetStatus"
    VALUE
    0x80806FB9
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outPoResetError_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outPoResetError"
    VALUE
    0x80806FBA
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outPoc_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outPoc"
    VALUE
    0x80806FBB
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outPocCfg_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outPocCfg"
    VALUE
    0x80806FBC
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outPocCfgDither_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outPocCfgDither"
    VALUE
    0x80806FBD
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outPocCfgPI_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outPocCfgPI"
    VALUE
    0x80806FBE
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outPod_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outPod"
    VALUE
    0x80806FBF
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outPodCfg_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outPodCfg"
    VALUE
    0x80806FC0
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outPodCfgPeriod_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outPodCfgPeriod"
    VALUE
    0x80806FC1
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_rsmFfiApiCallErr_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_rsmFfiApiCallErr"
    VALUE
    0x80806FC2
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safout_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safout"
    VALUE
    0x80806FC3
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutCfg_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutCfg"
    VALUE
    0x80806FC4
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl1_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl1"
    VALUE
    0x80806FC5
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl10_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl10"
    VALUE
    0x80806FC6
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl10Dev_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl10Dev"
    VALUE
    0x80806FC7
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl10OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl10OR"
    VALUE
    0x80806FC8
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl11_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl11"
    VALUE
    0x80806FC9
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl11Dev_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl11Dev"
    VALUE
    0x80806FCA
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl11OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl11OR"
    VALUE
    0x80806FCB
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl12_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl12"
    VALUE
    0x80806FCC
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl12Dev_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl12Dev"
    VALUE
    0x80806FCD
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl12OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl12OR"
    VALUE
    0x80806FCE
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl13_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl13"
    VALUE
    0x80806FCF
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl13Dev_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl13Dev"
    VALUE
    0x80806FD0
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl13OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl13OR"
    VALUE
    0x80806FD1
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl14_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl14"
    VALUE
    0x80806FD2
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl14Dev_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl14Dev"
    VALUE
    0x80806FD3
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl14OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl14OR"
    VALUE
    0x80806FD4
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl15_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl15"
    VALUE
    0x80806FD5
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl15Dev_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl15Dev"
    VALUE
    0x80806FD6
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl15OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl15OR"
    VALUE
    0x80806FD7
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl16_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl16"
    VALUE
    0x80806FD8
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl16Dev_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl16Dev"
    VALUE
    0x80806FD9
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl16OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl16OR"
    VALUE
    0x80806FDA
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl17_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl17"
    VALUE
    0x80806FDB
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl17Dev_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl17Dev"
    VALUE
    0x80806FDC
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl17OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl17OR"
    VALUE
    0x80806FDD
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl18_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl18"
    VALUE
    0x80806FDE
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl18Dev_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl18Dev"
    VALUE
    0x80806FDF
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl18OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl18OR"
    VALUE
    0x80806FE0
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl1Dev_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl1Dev"
    VALUE
    0x80806FE1
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl1OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl1OR"
    VALUE
    0x80806FE2
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl2_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl2"
    VALUE
    0x80806FE3
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl2Dev_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl2Dev"
    VALUE
    0x80806FE4
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl2OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl2OR"
    VALUE
    0x80806FE5
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl3_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl3"
    VALUE
    0x80806FE6
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl3Dev_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl3Dev"
    VALUE
    0x80806FE7
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl3OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl3OR"
    VALUE
    0x80806FE8
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl4_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl4"
    VALUE
    0x80806FE9
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl4Dev_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl4Dev"
    VALUE
    0x80806FEA
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl4OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl4OR"
    VALUE
    0x80806FEB
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl5_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl5"
    VALUE
    0x80806FEC
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl5Dev_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl5Dev"
    VALUE
    0x80806FED
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl5OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl5OR"
    VALUE
    0x80806FEE
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl6_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl6"
    VALUE
    0x80806FEF
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl6Dev_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl6Dev"
    VALUE
    0x80806FF0
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl6OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl6OR"
    VALUE
    0x80806FF1
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl7_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl7"
    VALUE
    0x80806FF2
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl7Dev_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl7Dev"
    VALUE
    0x80806FF3
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl7OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl7OR"
    VALUE
    0x80806FF4
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl8_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl8"
    VALUE
    0x80806FF5
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl8Dev_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl8Dev"
    VALUE
    0x80806FF6
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl8OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl8OR"
    VALUE
    0x80806FF7
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl9_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl9"
    VALUE
    0x80806FF8
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl9Dev_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl9Dev"
    VALUE
    0x80806FF9
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl9OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl9OR"
    VALUE
    0x80806FFA
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutDevError_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutDevError"
    VALUE
    0x80806FFB
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutGetStatus_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutGetStatus"
    VALUE
    0x80806FFC
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutIgnoreError_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutIgnoreError"
    VALUE
    0x80806FFD
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutResetError_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutResetError"
    VALUE
    0x80806FFE
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutUnlock_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutUnlock"
    VALUE
    0x80806FFF
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safout_cfgDiag_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safout_cfgDiag"
    VALUE
    0x80807000
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_secAccessDenied_RC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_secAccessDenied_RC"
    VALUE
    0x80807001
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_secAccessDenied_WDBI_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_secAccessDenied_WDBI"
    VALUE
    0x80807002
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_secEvalRespKey_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_secEvalRespKey"
    VALUE
    0x80807003
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_secFlashingFailure_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_secFlashingFailure"
    VALUE
    0x80807004
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_secGetLevel_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_secGetLevel"
    VALUE
    0x80807005
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_secGetRnd_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_secGetRnd"
    VALUE
    0x80807006
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_secGetSeed_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_secGetSeed"
    VALUE
    0x80807007
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_secInvalidPassword_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_secInvalidPassword"
    VALUE
    0x80807008
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_secIsRequestAllowed_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_secIsRequestAllowed"
    VALUE
    0x80807009
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_secResetLevel_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_secResetLevel"
    VALUE
    0x8080700A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_secSaveSecret_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_secSaveSecret"
    VALUE
    0x8080700B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_secSetLevel_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_secSetLevel"
    VALUE
    0x8080700C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_sysAit_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_sysAit"
    VALUE
    0x8080700D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_sysAiv_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_sysAiv"
    VALUE
    0x8080700E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_sysDi_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_sysDi"
    VALUE
    0x8080700F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_sysDo_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_sysDo"
    VALUE
    0x80807010
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_sysGetVss_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_sysGetVss"
    VALUE
    0x80807011
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_sysInit_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_sysInit"
    VALUE
    0x80807012
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_sysOperHrIntegrityErr_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_sysOperHrIntegrityErr"
    VALUE
    0x80807013
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_sysOperHrsSaturated_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_sysOperHrsSaturated"
    VALUE
    0x80807014
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_sysSetVss_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_sysSetVss"
    VALUE
    0x80807015
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_sys_coreload_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_sys_coreload"
    VALUE
    0x80807016
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_sys_taskload_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_sys_taskload"
    VALUE
    0x80807017
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_OV_VSS1_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_OV_VSS1"
    VALUE
    0x80807018
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_OV_VSS2_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_OV_VSS2"
    VALUE
    0x80807019
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_UV_VSS1_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_UV_VSS1"
    VALUE
    0x8080701A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_UV_VSS2_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_UV_VSS2"
    VALUE
    0x8080701B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_CANSM_E_BUS_OFF_NETWORK_0_C
    "AUTOSAR: DTC severity class / Check DFC_CANSM_E_BUS_OFF_NETWORK_0"
    VALUE
    0x8080701C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_CANSM_E_BUS_OFF_NETWORK_1_C
    "AUTOSAR: DTC severity class / Check DFC_CANSM_E_BUS_OFF_NETWORK_1"
    VALUE
    0x8080701D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_CANSM_E_BUS_OFF_NETWORK_2_C
    "AUTOSAR: DTC severity class / Check DFC_CANSM_E_BUS_OFF_NETWORK_2"
    VALUE
    0x8080701E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_CANSM_E_BUS_OFF_NETWORK_3_C
    "AUTOSAR: DTC severity class / Check DFC_CANSM_E_BUS_OFF_NETWORK_3"
    VALUE
    0x8080701F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_CANTRCV_E_NO_TRCV_CONTROL_0_C
    "AUTOSAR: DTC severity class / Check DFC_CANTRCV_E_NO_TRCV_CONTROL_0"
    VALUE
    0x80807020
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_CAN_E_TIMEOUT_C
    "AUTOSAR: DTC severity class / Check DFC_CAN_E_TIMEOUT"
    VALUE
    0x80807021
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_COMM_E_NET_START_IND_CHANNEL_0_C
    "AUTOSAR: DTC severity class / Check DFC_COMM_E_NET_START_IND_CHANNEL_0"
    VALUE
    0x80807022
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_COMM_E_NET_START_IND_CHANNEL_1_C
    "AUTOSAR: DTC severity class / Check DFC_COMM_E_NET_START_IND_CHANNEL_1"
    VALUE
    0x80807023
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_COMM_E_NET_START_IND_CHANNEL_2_C
    "AUTOSAR: DTC severity class / Check DFC_COMM_E_NET_START_IND_CHANNEL_2"
    VALUE
    0x80807024
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_COMM_E_NET_START_IND_CHANNEL_3_C
    "AUTOSAR: DTC severity class / Check DFC_COMM_E_NET_START_IND_CHANNEL_3"
    VALUE
    0x80807025
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_COMM_E_NET_START_IND_CHANNEL_4_C
    "AUTOSAR: DTC severity class / Check DFC_COMM_E_NET_START_IND_CHANNEL_4"
    VALUE
    0x80807026
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_COMM_E_NET_START_IND_CHANNEL_5_C
    "AUTOSAR: DTC severity class / Check DFC_COMM_E_NET_START_IND_CHANNEL_5"
    VALUE
    0x80807027
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_LIN_E_TIMEOUT_C
    "AUTOSAR: DTC severity class / Check DFC_LIN_E_TIMEOUT"
    VALUE
    0x80807028
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rba_MultiStackTrace_Threshold_C
    "AUTOSAR: DTC severity class / Check DFC_rba_MultiStackTrace_Threshold"
    VALUE
    0x80807029
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_ETH_E_ACCESS_0_C
    "AUTOSAR: DTC severity class / Check DFC_ETH_E_ACCESS_0"
    VALUE
    0x8080702A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_RBA_IOEXTLIB_KEEPALIVE_DRV_C
    "AUTOSAR: DTC severity class / Check DFC_RBA_IOEXTLIB_KEEPALIVE_DRV"
    VALUE
    0x8080702B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_RBA_IOEXTLIB_KEEPALIVE_INI_C
    "AUTOSAR: DTC severity class / Check DFC_RBA_IOEXTLIB_KEEPALIVE_INI"
    VALUE
    0x8080702C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rba_MRly_Diag_Stk_Event_C
    "AUTOSAR: DTC severity class / Check DFC_rba_MRly_Diag_Stk_Event"
    VALUE
    0x8080702D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rba_MemDiagExtd_MemReadSngErr_C
    "AUTOSAR: DTC severity class / Check DFC_rba_MemDiagExtd_MemReadSngErr"
    VALUE
    0x8080702E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rba_MemDiag_MemReadErr_C
    "AUTOSAR: DTC severity class / Check DFC_rba_MemDiag_MemReadErr"
    VALUE
    0x8080702F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rba_MemDiag_MemWrErr_C
    "AUTOSAR: DTC severity class / Check DFC_rba_MemDiag_MemWrErr"
    VALUE
    0x80807030
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rba_SyC_IrrSwOffTrigEngRun_Event_C
    "AUTOSAR: DTC severity class / Check DFC_rba_SyC_IrrSwOffTrigEngRun_Event"
    VALUE
    0x80807031
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rba_T15_Diag_ComInVld_Event_C
    "AUTOSAR: DTC severity class / Check DFC_rba_T15_Diag_ComInVld_Event"
    VALUE
    0x80807032
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rba_T15_Diag_ComOff_HwOn_Event_C
    "AUTOSAR: DTC severity class / Check DFC_rba_T15_Diag_ComOff_HwOn_Event"
    VALUE
    0x80807033
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rba_T15_Diag_ComOn_HwOff_Event_C
    "AUTOSAR: DTC severity class / Check DFC_rba_T15_Diag_ComOn_HwOff_Event"
    VALUE
    0x80807034
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM0_0_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM0_0"
    VALUE
    0x80807035
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM0_1_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM0_1"
    VALUE
    0x80807036
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM0_10_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM0_10"
    VALUE
    0x80807037
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM0_11_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM0_11"
    VALUE
    0x80807038
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM0_13_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM0_13"
    VALUE
    0x80807039
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM0_14_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM0_14"
    VALUE
    0x8080703A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM0_2_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM0_2"
    VALUE
    0x8080703B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM0_22_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM0_22"
    VALUE
    0x8080703C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM0_23_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM0_23"
    VALUE
    0x8080703D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM0_4_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM0_4"
    VALUE
    0x8080703E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM0_5_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM0_5"
    VALUE
    0x8080703F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM0_7_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM0_7"
    VALUE
    0x80807040
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM0_8_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM0_8"
    VALUE
    0x80807041
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM10_16_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM10_16"
    VALUE
    0x80807042
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM10_17_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM10_17"
    VALUE
    0x80807043
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM10_21_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM10_21"
    VALUE
    0x80807044
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM11_0_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM11_0"
    VALUE
    0x80807045
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM11_1_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM11_1"
    VALUE
    0x80807046
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM11_2_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM11_2"
    VALUE
    0x80807047
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM11_3_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM11_3"
    VALUE
    0x80807048
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM11_4_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM11_4"
    VALUE
    0x80807049
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM11_5_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM11_5"
    VALUE
    0x8080704A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM11_8_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM11_8"
    VALUE
    0x8080704B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM11_9_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM11_9"
    VALUE
    0x8080704C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM1_0_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM1_0"
    VALUE
    0x8080704D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM1_1_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM1_1"
    VALUE
    0x8080704E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM1_10_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM1_10"
    VALUE
    0x8080704F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM1_11_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM1_11"
    VALUE
    0x80807050
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM1_13_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM1_13"
    VALUE
    0x80807051
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM1_14_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM1_14"
    VALUE
    0x80807052
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM1_2_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM1_2"
    VALUE
    0x80807053
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM1_22_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM1_22"
    VALUE
    0x80807054
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM1_23_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM1_23"
    VALUE
    0x80807055
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM1_4_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM1_4"
    VALUE
    0x80807056
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM1_5_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM1_5"
    VALUE
    0x80807057
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM1_7_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM1_7"
    VALUE
    0x80807058
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM1_8_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM1_8"
    VALUE
    0x80807059
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM21_0_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM21_0"
    VALUE
    0x8080705A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM21_16_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM21_16"
    VALUE
    0x8080705B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM21_3_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM21_3"
    VALUE
    0x8080705C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM2_1_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM2_1"
    VALUE
    0x8080705D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM2_10_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM2_10"
    VALUE
    0x8080705E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM2_11_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM2_11"
    VALUE
    0x8080705F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM2_13_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM2_13"
    VALUE
    0x80807060
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM2_14_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM2_14"
    VALUE
    0x80807061
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM2_2_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM2_2"
    VALUE
    0x80807062
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM2_22_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM2_22"
    VALUE
    0x80807063
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM2_23_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM2_23"
    VALUE
    0x80807064
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM2_4_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM2_4"
    VALUE
    0x80807065
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM2_5_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM2_5"
    VALUE
    0x80807066
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM2_7_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM2_7"
    VALUE
    0x80807067
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM2_8_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM2_8"
    VALUE
    0x80807068
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM3_1_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM3_1"
    VALUE
    0x80807069
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM3_10_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM3_10"
    VALUE
    0x8080706A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM3_11_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM3_11"
    VALUE
    0x8080706B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM3_13_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM3_13"
    VALUE
    0x8080706C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM3_14_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM3_14"
    VALUE
    0x8080706D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM3_2_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM3_2"
    VALUE
    0x8080706E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM3_22_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM3_22"
    VALUE
    0x8080706F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM3_23_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM3_23"
    VALUE
    0x80807070
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM3_4_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM3_4"
    VALUE
    0x80807071
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM3_5_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM3_5"
    VALUE
    0x80807072
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM3_7_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM3_7"
    VALUE
    0x80807073
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM3_8_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM3_8"
    VALUE
    0x80807074
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM6_0_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM6_0"
    VALUE
    0x80807075
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM6_11_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM6_11"
    VALUE
    0x80807076
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM6_12_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM6_12"
    VALUE
    0x80807077
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM6_14_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM6_14"
    VALUE
    0x80807078
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM6_15_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM6_15"
    VALUE
    0x80807079
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM6_17_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM6_17"
    VALUE
    0x8080707A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM6_18_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM6_18"
    VALUE
    0x8080707B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM6_2_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM6_2"
    VALUE
    0x8080707C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM6_20_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM6_20"
    VALUE
    0x8080707D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM6_21_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM6_21"
    VALUE
    0x8080707E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM6_25_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM6_25"
    VALUE
    0x8080707F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM6_4_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM6_4"
    VALUE
    0x80807080
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM6_5_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM6_5"
    VALUE
    0x80807081
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM6_7_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM6_7"
    VALUE
    0x80807082
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM6_8_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM6_8"
    VALUE
    0x80807083
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM7_1_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM7_1"
    VALUE
    0x80807084
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM7_12_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM7_12"
    VALUE
    0x80807085
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM7_13_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM7_13"
    VALUE
    0x80807086
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM7_14_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM7_14"
    VALUE
    0x80807087
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM7_15_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM7_15"
    VALUE
    0x80807088
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM7_16_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM7_16"
    VALUE
    0x80807089
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM7_17_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM7_17"
    VALUE
    0x8080708A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM7_2_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM7_2"
    VALUE
    0x8080708B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM7_20_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM7_20"
    VALUE
    0x8080708C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM7_25_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM7_25"
    VALUE
    0x8080708D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM7_26_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM7_26"
    VALUE
    0x8080708E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM7_28_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM7_28"
    VALUE
    0x8080708F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM7_29_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM7_29"
    VALUE
    0x80807090
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM7_30_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM7_30"
    VALUE
    0x80807091
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM7_31_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM7_31"
    VALUE
    0x80807092
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM8_0_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM8_0"
    VALUE
    0x80807093
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM8_1_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM8_1"
    VALUE
    0x80807094
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM8_10_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM8_10"
    VALUE
    0x80807095
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM8_11_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM8_11"
    VALUE
    0x80807096
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM8_12_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM8_12"
    VALUE
    0x80807097
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM8_13_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM8_13"
    VALUE
    0x80807098
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM8_16_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM8_16"
    VALUE
    0x80807099
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM8_18_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM8_18"
    VALUE
    0x8080709A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM8_2_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM8_2"
    VALUE
    0x8080709B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM8_3_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM8_3"
    VALUE
    0x8080709C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM8_30_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM8_30"
    VALUE
    0x8080709D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM8_31_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM8_31"
    VALUE
    0x8080709E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM8_4_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM8_4"
    VALUE
    0x8080709F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM9_0_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM9_0"
    VALUE
    0x808070A0
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM9_1_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM9_1"
    VALUE
    0x808070A1
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM9_15_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM9_15"
    VALUE
    0x808070A2
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM9_3_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM9_3"
    VALUE
    0x808070A3
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MoCSOPICO_C
    "AUTOSAR: DTC severity class / Check DFC_MoCSOPICO"
    VALUE
    0x808070A4
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MoFVarPostBldSel_C
    "AUTOSAR: DTC severity class / Check DFC_MoFVarPostBldSel"
    VALUE
    0x808070A5
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MoSysCtrlReIni_C
    "AUTOSAR: DTC severity class / Check DFC_MoSysCtrlReIni"
    VALUE
    0x808070A6
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MoXEMMHwLTMCUFW_C
    "AUTOSAR: DTC severity class / Check DFC_MoXEMMHwLTMCUFW"
    VALUE
    0x808070A7
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MoXEMMHwLTMonBIST_C
    "AUTOSAR: DTC severity class / Check DFC_MoXEMMHwLTMonBIST"
    VALUE
    0x808070A8
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MoXEMMHwLTRegMonTest_C
    "AUTOSAR: DTC severity class / Check DFC_MoXEMMHwLTRegMonTest"
    VALUE
    0x808070A9
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MoXEMMHwLTStbySMUAlvTest_C
    "AUTOSAR: DTC severity class / Check DFC_MoXEMMHwLTStbySMUAlvTest"
    VALUE
    0x808070AA
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MoXEMMHwLTTempSens_C
    "AUTOSAR: DTC severity class / Check DFC_MoXEMMHwLTTempSens"
    VALUE
    0x808070AB
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MoXEMMHwLTUCBCfg_C
    "AUTOSAR: DTC severity class / Check DFC_MoXEMMHwLTUCBCfg"
    VALUE
    0x808070AC
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_OCWDAABEActv_C
    "AUTOSAR: DTC severity class / Check DFC_OCWDAABEActv"
    VALUE
    0x808070AD
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_OCWDACom_C
    "AUTOSAR: DTC severity class / Check DFC_OCWDACom"
    VALUE
    0x808070AE
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_OCWDAErrPin_C
    "AUTOSAR: DTC severity class / Check DFC_OCWDAErrPin"
    VALUE
    0x808070AF
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_SWReset_0_C
    "AUTOSAR: DTC severity class / Check DFC_SWReset_0"
    VALUE
    0x808070B0
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_SWReset_1_C
    "AUTOSAR: DTC severity class / Check DFC_SWReset_1"
    VALUE
    0x808070B1
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_SWReset_2_C
    "AUTOSAR: DTC severity class / Check DFC_SWReset_2"
    VALUE
    0x808070B2
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDebFault1_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDebFault1"
    VALUE
    0x808070B3
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_Unused_C
    "fault class per DFC / "
    VALUE
    0x80800F04
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    READ_ONLY

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_TimeInRowDebFault_C
    "fault class per DFC / Fault class for check DFC_bds_TimeInRowDebFault"
    VALUE
    0x80800F05
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_EventInRowDebFault_C
    "fault class per DFC / Fault class for check DFC_bds_EventInRowDebFault"
    VALUE
    0x80800F06
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_DevLibBattUHi_C
    "fault class per DFC / Fault class for check DFC_DevLibBattUHi"
    VALUE
    0x80800F07
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_DevLibBattULo_C
    "fault class per DFC / Fault class for check DFC_DevLibBattULo"
    VALUE
    0x80800F08
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_TimeUpDownDebFault_C
    "fault class per DFC / Fault class for check DFC_bds_TimeUpDownDebFault"
    VALUE
    0x80800F09
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA13OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inA13OR"
    VALUE
    0x80800F0A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA13SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA13SCB"
    VALUE
    0x80800F0B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA13SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inA13SCG"
    VALUE
    0x80800F0C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA14OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inA14OR"
    VALUE
    0x80800F0D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA14SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA14SCB"
    VALUE
    0x80800F0E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA14SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inA14SCG"
    VALUE
    0x80800F0F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA21OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inA21OR"
    VALUE
    0x80800F10
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA21SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA21SCB"
    VALUE
    0x80800F11
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA21SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inA21SCG"
    VALUE
    0x80800F12
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA22OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inA22OR"
    VALUE
    0x80800F13
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA22SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA22SCB"
    VALUE
    0x80800F14
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA22SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inA22SCG"
    VALUE
    0x80800F15
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA23OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inA23OR"
    VALUE
    0x80800F16
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA23SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA23SCB"
    VALUE
    0x80800F17
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA23SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inA23SCG"
    VALUE
    0x80800F18
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA24OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inA24OR"
    VALUE
    0x80800F19
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA24SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA24SCB"
    VALUE
    0x80800F1A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA24SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inA24SCG"
    VALUE
    0x80800F1B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA25OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inA25OR"
    VALUE
    0x80800F1C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA25SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA25SCB"
    VALUE
    0x80800F1D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA25SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inA25SCG"
    VALUE
    0x80800F1E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA26OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inA26OR"
    VALUE
    0x80800F1F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA26SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA26SCB"
    VALUE
    0x80800F20
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA26SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inA26SCG"
    VALUE
    0x80800F21
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA27OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inA27OR"
    VALUE
    0x80800F22
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA27SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA27SCB"
    VALUE
    0x80800F23
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA27SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inA27SCG"
    VALUE
    0x80800F24
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA28OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inA28OR"
    VALUE
    0x80800F25
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA28SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA28SCB"
    VALUE
    0x80800F26
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA28SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inA28SCG"
    VALUE
    0x80800F27
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA29OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inA29OR"
    VALUE
    0x80800F28
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA29SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA29SCB"
    VALUE
    0x80800F29
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA29SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inA29SCG"
    VALUE
    0x80800F2A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA36AicSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA36AicSCB"
    VALUE
    0x80800F2B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA36AicSCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inA36AicSCG"
    VALUE
    0x80800F2C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA36OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inA36OR"
    VALUE
    0x80800F2D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA36SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA36SCB"
    VALUE
    0x80800F2E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA36SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inA36SCG"
    VALUE
    0x80800F2F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA36ShuntSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA36ShuntSCB"
    VALUE
    0x80800F30
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA37AicSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA37AicSCB"
    VALUE
    0x80800F31
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA37AicSCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inA37AicSCG"
    VALUE
    0x80800F32
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA37OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inA37OR"
    VALUE
    0x80800F33
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA37SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA37SCB"
    VALUE
    0x80800F34
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA37SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inA37SCG"
    VALUE
    0x80800F35
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA37ShuntSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA37ShuntSCB"
    VALUE
    0x80800F36
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA38AicSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA38AicSCB"
    VALUE
    0x80800F37
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA38AicSCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inA38AicSCG"
    VALUE
    0x80800F38
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA38OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inA38OR"
    VALUE
    0x80800F39
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA38SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA38SCB"
    VALUE
    0x80800F3A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA38SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inA38SCG"
    VALUE
    0x80800F3B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA38ShuntSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA38ShuntSCB"
    VALUE
    0x80800F3C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA39AicSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA39AicSCB"
    VALUE
    0x80800F3D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA39AicSCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inA39AicSCG"
    VALUE
    0x80800F3E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA39OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inA39OR"
    VALUE
    0x80800F3F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA39SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA39SCB"
    VALUE
    0x80800F40
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA39SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inA39SCG"
    VALUE
    0x80800F41
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA39ShuntSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA39ShuntSCB"
    VALUE
    0x80800F42
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA40OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inA40OR"
    VALUE
    0x80800F43
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA40SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA40SCB"
    VALUE
    0x80800F44
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA40SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inA40SCG"
    VALUE
    0x80800F45
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA41OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inA41OR"
    VALUE
    0x80800F46
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA41SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA41SCB"
    VALUE
    0x80800F47
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA41SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inA41SCG"
    VALUE
    0x80800F48
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA42OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inA42OR"
    VALUE
    0x80800F49
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA42SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA42SCB"
    VALUE
    0x80800F4A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA42SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inA42SCG"
    VALUE
    0x80800F4B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA43AicSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA43AicSCB"
    VALUE
    0x80800F4C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA43AicSCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inA43AicSCG"
    VALUE
    0x80800F4D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA43OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inA43OR"
    VALUE
    0x80800F4E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA43SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA43SCB"
    VALUE
    0x80800F4F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA43SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inA43SCG"
    VALUE
    0x80800F50
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA43ShuntSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA43ShuntSCB"
    VALUE
    0x80800F51
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA44OL_C
    "fault class per DFC / Fault class for check DFC_rbr_inA44OL"
    VALUE
    0x80800F52
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA44SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA44SCB"
    VALUE
    0x80800F53
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA44SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inA44SCG"
    VALUE
    0x80800F54
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA57OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inA57OR"
    VALUE
    0x80800F55
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA57SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA57SCB"
    VALUE
    0x80800F56
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA57SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inA57SCG"
    VALUE
    0x80800F57
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA59OL_C
    "fault class per DFC / Fault class for check DFC_rbr_inA59OL"
    VALUE
    0x80800F58
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA59SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA59SCB"
    VALUE
    0x80800F59
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA59SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inA59SCG"
    VALUE
    0x80800F5A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK10OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK10OR"
    VALUE
    0x80800F5B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK10SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK10SCB"
    VALUE
    0x80800F5C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK10SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK10SCG"
    VALUE
    0x80800F5D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK11OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK11OR"
    VALUE
    0x80800F5E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK11SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK11SCB"
    VALUE
    0x80800F5F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK11SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK11SCG"
    VALUE
    0x80800F60
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK30AicSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK30AicSCB"
    VALUE
    0x80800F61
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK30AicSCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK30AicSCG"
    VALUE
    0x80800F62
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK30OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK30OR"
    VALUE
    0x80800F63
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK30SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK30SCB"
    VALUE
    0x80800F64
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK30SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK30SCG"
    VALUE
    0x80800F65
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK30ShuntSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK30ShuntSCB"
    VALUE
    0x80800F66
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK31OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK31OR"
    VALUE
    0x80800F67
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK31SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK31SCB"
    VALUE
    0x80800F68
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK31SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK31SCG"
    VALUE
    0x80800F69
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK32OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK32OR"
    VALUE
    0x80800F6A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK32SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK32SCB"
    VALUE
    0x80800F6B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK32SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK32SCG"
    VALUE
    0x80800F6C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK33OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK33OR"
    VALUE
    0x80800F6D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK33SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK33SCB"
    VALUE
    0x80800F6E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK33SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK33SCG"
    VALUE
    0x80800F6F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK34OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK34OR"
    VALUE
    0x80800F70
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK34SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK34SCB"
    VALUE
    0x80800F71
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK34SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK34SCG"
    VALUE
    0x80800F72
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK35OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK35OR"
    VALUE
    0x80800F73
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK35SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK35SCB"
    VALUE
    0x80800F74
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK35SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK35SCG"
    VALUE
    0x80800F75
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK36OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK36OR"
    VALUE
    0x80800F76
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK36SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK36SCB"
    VALUE
    0x80800F77
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK36SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK36SCG"
    VALUE
    0x80800F78
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK37AicSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK37AicSCB"
    VALUE
    0x80800F79
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK37AicSCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK37AicSCG"
    VALUE
    0x80800F7A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK37OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK37OR"
    VALUE
    0x80800F7B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK37SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK37SCB"
    VALUE
    0x80800F7C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK37SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK37SCG"
    VALUE
    0x80800F7D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK37ShuntSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK37ShuntSCB"
    VALUE
    0x80800F7E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK38AicSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK38AicSCB"
    VALUE
    0x80800F7F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK38AicSCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK38AicSCG"
    VALUE
    0x80800F80
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK38OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK38OR"
    VALUE
    0x80800F81
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK38SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK38SCB"
    VALUE
    0x80800F82
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK38SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK38SCG"
    VALUE
    0x80800F83
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK38ShuntSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK38ShuntSCB"
    VALUE
    0x80800F84
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK39AicSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK39AicSCB"
    VALUE
    0x80800F85
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK39AicSCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK39AicSCG"
    VALUE
    0x80800F86
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK39OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK39OR"
    VALUE
    0x80800F87
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK39SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK39SCB"
    VALUE
    0x80800F88
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK39SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK39SCG"
    VALUE
    0x80800F89
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK39ShuntSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK39ShuntSCB"
    VALUE
    0x80800F8A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK40AicSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK40AicSCB"
    VALUE
    0x80800F8B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK40AicSCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK40AicSCG"
    VALUE
    0x80800F8C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK40OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK40OR"
    VALUE
    0x80800F8D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK40SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK40SCB"
    VALUE
    0x80800F8E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK40SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK40SCG"
    VALUE
    0x80800F8F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK40ShuntSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK40ShuntSCB"
    VALUE
    0x80800F90
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK41AicSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK41AicSCB"
    VALUE
    0x80800F91
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK41AicSCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK41AicSCG"
    VALUE
    0x80800F92
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK41OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK41OR"
    VALUE
    0x80800F93
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK41SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK41SCB"
    VALUE
    0x80800F94
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK41SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK41SCG"
    VALUE
    0x80800F95
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK41ShuntSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK41ShuntSCB"
    VALUE
    0x80800F96
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK42AicSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK42AicSCB"
    VALUE
    0x80800F97
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK42AicSCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK42AicSCG"
    VALUE
    0x80800F98
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK42OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK42OR"
    VALUE
    0x80800F99
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK42SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK42SCB"
    VALUE
    0x80800F9A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK42SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK42SCG"
    VALUE
    0x80800F9B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK42ShuntSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK42ShuntSCB"
    VALUE
    0x80800F9C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK43OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK43OR"
    VALUE
    0x80800F9D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK43SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK43SCB"
    VALUE
    0x80800F9E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK43SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK43SCG"
    VALUE
    0x80800F9F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK44AicSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK44AicSCB"
    VALUE
    0x80800FA0
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK44AicSCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK44AicSCG"
    VALUE
    0x80800FA1
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK44OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK44OR"
    VALUE
    0x80800FA2
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK44SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK44SCB"
    VALUE
    0x80800FA3
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK44SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK44SCG"
    VALUE
    0x80800FA4
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK44ShuntSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK44ShuntSCB"
    VALUE
    0x80800FA5
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK45AicSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK45AicSCB"
    VALUE
    0x80800FA6
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK45AicSCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK45AicSCG"
    VALUE
    0x80800FA7
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK45OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK45OR"
    VALUE
    0x80800FA8
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK45SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK45SCB"
    VALUE
    0x80800FA9
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK45SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK45SCG"
    VALUE
    0x80800FAA
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK45ShuntSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK45ShuntSCB"
    VALUE
    0x80800FAB
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK52OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK52OR"
    VALUE
    0x80800FAC
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK52SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK52SCB"
    VALUE
    0x80800FAD
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK52SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK52SCG"
    VALUE
    0x80800FAE
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK53OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK53OR"
    VALUE
    0x80800FAF
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK53SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK53SCB"
    VALUE
    0x80800FB0
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK53SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK53SCG"
    VALUE
    0x80800FB1
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK54AicSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK54AicSCB"
    VALUE
    0x80800FB2
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK54AicSCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK54AicSCG"
    VALUE
    0x80800FB3
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK54OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK54OR"
    VALUE
    0x80800FB4
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK54SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK54SCB"
    VALUE
    0x80800FB5
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK54SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK54SCG"
    VALUE
    0x80800FB6
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK54ShuntSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK54ShuntSCB"
    VALUE
    0x80800FB7
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK55AicSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK55AicSCB"
    VALUE
    0x80800FB8
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK55AicSCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK55AicSCG"
    VALUE
    0x80800FB9
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK55OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK55OR"
    VALUE
    0x80800FBA
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK55SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK55SCB"
    VALUE
    0x80800FBB
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK55SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK55SCG"
    VALUE
    0x80800FBC
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK55ShuntSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK55ShuntSCB"
    VALUE
    0x80800FBD
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK56OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK56OR"
    VALUE
    0x80800FBE
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK56SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK56SCB"
    VALUE
    0x80800FBF
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK56SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK56SCG"
    VALUE
    0x80800FC0
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK57OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK57OR"
    VALUE
    0x80800FC1
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK57SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK57SCB"
    VALUE
    0x80800FC2
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK57SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK57SCG"
    VALUE
    0x80800FC3
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK58OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK58OR"
    VALUE
    0x80800FC4
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK58SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK58SCB"
    VALUE
    0x80800FC5
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK58SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK58SCG"
    VALUE
    0x80800FC6
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK59OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK59OR"
    VALUE
    0x80800FC7
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK59SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK59SCB"
    VALUE
    0x80800FC8
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK59SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK59SCG"
    VALUE
    0x80800FC9
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK60OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK60OR"
    VALUE
    0x80800FCA
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK60SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK60SCB"
    VALUE
    0x80800FCB
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK60SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK60SCG"
    VALUE
    0x80800FCC
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK61AicSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK61AicSCB"
    VALUE
    0x80800FCD
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK61AicSCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK61AicSCG"
    VALUE
    0x80800FCE
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK61OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK61OR"
    VALUE
    0x80800FCF
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK61SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK61SCB"
    VALUE
    0x80800FD0
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK61SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK61SCG"
    VALUE
    0x80800FD1
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK61ShuntSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK61ShuntSCB"
    VALUE
    0x80800FD2
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK62OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK62OR"
    VALUE
    0x80800FD3
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK62SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK62SCB"
    VALUE
    0x80800FD4
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK62SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK62SCG"
    VALUE
    0x80800FD5
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK63AicSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK63AicSCB"
    VALUE
    0x80800FD6
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK63AicSCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK63AicSCG"
    VALUE
    0x80800FD7
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK63OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK63OR"
    VALUE
    0x80800FD8
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK63SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK63SCB"
    VALUE
    0x80800FD9
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK63SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK63SCG"
    VALUE
    0x80800FDA
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK63ShuntSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK63ShuntSCB"
    VALUE
    0x80800FDB
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK64AicSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK64AicSCB"
    VALUE
    0x80800FDC
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK64AicSCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK64AicSCG"
    VALUE
    0x80800FDD
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK64OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK64OR"
    VALUE
    0x80800FDE
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK64SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK64SCB"
    VALUE
    0x80800FDF
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK64SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK64SCG"
    VALUE
    0x80800FE0
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK64ShuntSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK64ShuntSCB"
    VALUE
    0x80800FE1
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK65AicSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK65AicSCB"
    VALUE
    0x80800FE2
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK65AicSCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK65AicSCG"
    VALUE
    0x80800FE3
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK65OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK65OR"
    VALUE
    0x80800FE4
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK65SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK65SCB"
    VALUE
    0x80800FE5
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK65SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK65SCG"
    VALUE
    0x80800FE6
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK65ShuntSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK65ShuntSCB"
    VALUE
    0x80800FE7
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK74OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK74OR"
    VALUE
    0x80800FE8
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK74SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK74SCB"
    VALUE
    0x80800FE9
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK74SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK74SCG"
    VALUE
    0x80800FEA
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK75OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK75OR"
    VALUE
    0x80800FEB
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK75SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK75SCB"
    VALUE
    0x80800FEC
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK75SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK75SCG"
    VALUE
    0x80800FED
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK76OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK76OR"
    VALUE
    0x80800FEE
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK76SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK76SCB"
    VALUE
    0x80800FEF
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK76SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK76SCG"
    VALUE
    0x80800FF0
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK77OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK77OR"
    VALUE
    0x80800FF1
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK77SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK77SCB"
    VALUE
    0x80800FF2
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK77SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK77SCG"
    VALUE
    0x80800FF3
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK78OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK78OR"
    VALUE
    0x80800FF4
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK78SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK78SCB"
    VALUE
    0x80800FF5
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK78SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK78SCG"
    VALUE
    0x80800FF6
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_DvUBAT_FWs_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_DvUBAT_FWs"
    VALUE
    0x80800FF7
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_OVErr_VPR6_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_OVErr_VPR6"
    VALUE
    0x80800FF8
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_OVWarn_VPR6_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_OVWarn_VPR6"
    VALUE
    0x80800FF9
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3"
    VALUE
    0x80800FFA
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2"
    VALUE
    0x80800FFB
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_OV_UBAT_MON_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_OV_UBAT_MON"
    VALUE
    0x80800FFC
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_OV_UBRM24_FLEXIN_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_OV_UBRM24_FLEXIN"
    VALUE
    0x80800FFD
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_OV_UBRM24_LOADS_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_OV_UBRM24_LOADS"
    VALUE
    0x80800FFE
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_OV_UBRM24_MON_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_OV_UBRM24_MON"
    VALUE
    0x80800FFF
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_OV_VDD5_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_OV_VDD5"
    VALUE
    0x80801000
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_OV_VDD5_IN_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_OV_VDD5_IN"
    VALUE
    0x80801001
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_OV_VPR6_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_OV_VPR6"
    VALUE
    0x80801002
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_OV_VSS3_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_OV_VSS3"
    VALUE
    0x80801003
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_OV_VSS4_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_OV_VSS4"
    VALUE
    0x80801004
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_Temp1_HTErr_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_Temp1_HTErr"
    VALUE
    0x80801005
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_Temp1_HTWarn_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_Temp1_HTWarn"
    VALUE
    0x80801006
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_Temp2_HTErr_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_Temp2_HTErr"
    VALUE
    0x80801007
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_Temp2_HTWarn_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_Temp2_HTWarn"
    VALUE
    0x80801008
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3"
    VALUE
    0x80801009
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2"
    VALUE
    0x8080100A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_UV_VDD5_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_UV_VDD5"
    VALUE
    0x8080100B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_UV_VDD5_IN_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_UV_VDD5_IN"
    VALUE
    0x8080100C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_UV_VPR6_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_UV_VPR6"
    VALUE
    0x8080100D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_UV_VSS3_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_UV_VSS3"
    VALUE
    0x8080100E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_UV_VSS4_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_UV_VSS4"
    VALUE
    0x8080100F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA01OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA01OL"
    VALUE
    0x80801010
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA01OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA01OT"
    VALUE
    0x80801011
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA01SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA01SCB"
    VALUE
    0x80801012
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA01SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA01SCG"
    VALUE
    0x80801013
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA02OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA02OL"
    VALUE
    0x80801014
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA02OR_C
    "fault class per DFC / Fault class for check DFC_rbr_outA02OR"
    VALUE
    0x80801015
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA02OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA02OT"
    VALUE
    0x80801016
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA02SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA02SCB"
    VALUE
    0x80801017
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA02SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA02SCG"
    VALUE
    0x80801018
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA03OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA03OL"
    VALUE
    0x80801019
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA03OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA03OT"
    VALUE
    0x8080101A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA03SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA03SCB"
    VALUE
    0x8080101B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA03SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA03SCG"
    VALUE
    0x8080101C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA04OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA04OL"
    VALUE
    0x8080101D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA04OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA04OT"
    VALUE
    0x8080101E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA04SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA04SCB"
    VALUE
    0x8080101F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA04SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA04SCG"
    VALUE
    0x80801020
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA05OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA05OL"
    VALUE
    0x80801021
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA05OR_C
    "fault class per DFC / Fault class for check DFC_rbr_outA05OR"
    VALUE
    0x80801022
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA05OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA05OT"
    VALUE
    0x80801023
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA05SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA05SCB"
    VALUE
    0x80801024
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA05SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA05SCG"
    VALUE
    0x80801025
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA06OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA06OL"
    VALUE
    0x80801026
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA06OR_C
    "fault class per DFC / Fault class for check DFC_rbr_outA06OR"
    VALUE
    0x80801027
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA06OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA06OT"
    VALUE
    0x80801028
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA06SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA06SCB"
    VALUE
    0x80801029
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA06SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA06SCG"
    VALUE
    0x8080102A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA07OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA07OL"
    VALUE
    0x8080102B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA07OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA07OT"
    VALUE
    0x8080102C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA07SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA07SCB"
    VALUE
    0x8080102D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA07SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA07SCG"
    VALUE
    0x8080102E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA08OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA08OL"
    VALUE
    0x8080102F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA08OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA08OT"
    VALUE
    0x80801030
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA08SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA08SCB"
    VALUE
    0x80801031
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA08SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA08SCG"
    VALUE
    0x80801032
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA09OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA09OL"
    VALUE
    0x80801033
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA09OR_C
    "fault class per DFC / Fault class for check DFC_rbr_outA09OR"
    VALUE
    0x80801034
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA09OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA09OT"
    VALUE
    0x80801035
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA09SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA09SCB"
    VALUE
    0x80801036
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA09SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA09SCG"
    VALUE
    0x80801037
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA10OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA10OL"
    VALUE
    0x80801038
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA10OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA10OT"
    VALUE
    0x80801039
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA10SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA10SCB"
    VALUE
    0x8080103A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA10SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA10SCG"
    VALUE
    0x8080103B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA11OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA11OL"
    VALUE
    0x8080103C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA11OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA11OT"
    VALUE
    0x8080103D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA11SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA11SCB"
    VALUE
    0x8080103E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA11SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA11SCG"
    VALUE
    0x8080103F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA12OR_C
    "fault class per DFC / Fault class for check DFC_rbr_outA12OR"
    VALUE
    0x80801040
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA12SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA12SCB"
    VALUE
    0x80801041
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA12SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA12SCG"
    VALUE
    0x80801042
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA16OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA16OL"
    VALUE
    0x80801043
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA16OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA16OT"
    VALUE
    0x80801044
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA16SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA16SCB"
    VALUE
    0x80801045
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA16SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA16SCG"
    VALUE
    0x80801046
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA17OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA17OL"
    VALUE
    0x80801047
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA17OR_C
    "fault class per DFC / Fault class for check DFC_rbr_outA17OR"
    VALUE
    0x80801048
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA17OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA17OT"
    VALUE
    0x80801049
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA17SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA17SCB"
    VALUE
    0x8080104A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA17SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA17SCG"
    VALUE
    0x8080104B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA18OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA18OL"
    VALUE
    0x8080104C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA18OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA18OT"
    VALUE
    0x8080104D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA18SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA18SCB"
    VALUE
    0x8080104E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA18SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA18SCG"
    VALUE
    0x8080104F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA19OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA19OL"
    VALUE
    0x80801050
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA19OR_C
    "fault class per DFC / Fault class for check DFC_rbr_outA19OR"
    VALUE
    0x80801051
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA19OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA19OT"
    VALUE
    0x80801052
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA19SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA19SCB"
    VALUE
    0x80801053
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA19SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA19SCG"
    VALUE
    0x80801054
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA20OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA20OL"
    VALUE
    0x80801055
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA20OR_C
    "fault class per DFC / Fault class for check DFC_rbr_outA20OR"
    VALUE
    0x80801056
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA20OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA20OT"
    VALUE
    0x80801057
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA20SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA20SCB"
    VALUE
    0x80801058
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA20SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA20SCG"
    VALUE
    0x80801059
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA31OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA31OL"
    VALUE
    0x8080105A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA31OR_C
    "fault class per DFC / Fault class for check DFC_rbr_outA31OR"
    VALUE
    0x8080105B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA31OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA31OT"
    VALUE
    0x8080105C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA31SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA31SCB"
    VALUE
    0x8080105D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA31SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA31SCG"
    VALUE
    0x8080105E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA32OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA32OL"
    VALUE
    0x8080105F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA32OR_C
    "fault class per DFC / Fault class for check DFC_rbr_outA32OR"
    VALUE
    0x80801060
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA32OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA32OT"
    VALUE
    0x80801061
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA32SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA32SCB"
    VALUE
    0x80801062
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA32SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA32SCG"
    VALUE
    0x80801063
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA33OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA33OL"
    VALUE
    0x80801064
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA33OR_C
    "fault class per DFC / Fault class for check DFC_rbr_outA33OR"
    VALUE
    0x80801065
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA33OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA33OT"
    VALUE
    0x80801066
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA33SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA33SCB"
    VALUE
    0x80801067
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA33SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA33SCG"
    VALUE
    0x80801068
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA34OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA34OL"
    VALUE
    0x80801069
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA34OR_C
    "fault class per DFC / Fault class for check DFC_rbr_outA34OR"
    VALUE
    0x8080106A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA34OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA34OT"
    VALUE
    0x8080106B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA34SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA34SCB"
    VALUE
    0x8080106C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA34SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA34SCG"
    VALUE
    0x8080106D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA35OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA35OL"
    VALUE
    0x8080106E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA35OR_C
    "fault class per DFC / Fault class for check DFC_rbr_outA35OR"
    VALUE
    0x8080106F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA35OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA35OT"
    VALUE
    0x80801070
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA35SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA35SCB"
    VALUE
    0x80801071
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA35SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA35SCG"
    VALUE
    0x80801072
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA46OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA46OL"
    VALUE
    0x80801073
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA46OR_C
    "fault class per DFC / Fault class for check DFC_rbr_outA46OR"
    VALUE
    0x80801074
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA46OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA46OT"
    VALUE
    0x80801075
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA46SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA46SCB"
    VALUE
    0x80801076
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA46SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA46SCG"
    VALUE
    0x80801077
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA47OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA47OL"
    VALUE
    0x80801078
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA47OR_C
    "fault class per DFC / Fault class for check DFC_rbr_outA47OR"
    VALUE
    0x80801079
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA47OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA47OT"
    VALUE
    0x8080107A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA47SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA47SCB"
    VALUE
    0x8080107B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA47SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA47SCG"
    VALUE
    0x8080107C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA48OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA48OL"
    VALUE
    0x8080107D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA48OR_C
    "fault class per DFC / Fault class for check DFC_rbr_outA48OR"
    VALUE
    0x8080107E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA48OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA48OT"
    VALUE
    0x8080107F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA48SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA48SCB"
    VALUE
    0x80801080
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA48SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA48SCG"
    VALUE
    0x80801081
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA49OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA49OL"
    VALUE
    0x80801082
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA49OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA49OT"
    VALUE
    0x80801083
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA49SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA49SCB"
    VALUE
    0x80801084
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA49SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA49SCG"
    VALUE
    0x80801085
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA50OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA50OL"
    VALUE
    0x80801086
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA50OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA50OT"
    VALUE
    0x80801087
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA50SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA50SCB"
    VALUE
    0x80801088
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA50SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA50SCG"
    VALUE
    0x80801089
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA51OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA51OL"
    VALUE
    0x8080108A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA51OR_C
    "fault class per DFC / Fault class for check DFC_rbr_outA51OR"
    VALUE
    0x8080108B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA51OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA51OT"
    VALUE
    0x8080108C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA51SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA51SCB"
    VALUE
    0x8080108D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA51SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA51SCG"
    VALUE
    0x8080108E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA52OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA52OL"
    VALUE
    0x8080108F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA52OR_C
    "fault class per DFC / Fault class for check DFC_rbr_outA52OR"
    VALUE
    0x80801090
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA52OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA52OT"
    VALUE
    0x80801091
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA52SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA52SCB"
    VALUE
    0x80801092
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA52SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA52SCG"
    VALUE
    0x80801093
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA53OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA53OL"
    VALUE
    0x80801094
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA53OR_C
    "fault class per DFC / Fault class for check DFC_rbr_outA53OR"
    VALUE
    0x80801095
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA53OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA53OT"
    VALUE
    0x80801096
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA53SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA53SCB"
    VALUE
    0x80801097
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA53SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA53SCG"
    VALUE
    0x80801098
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA54OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA54OL"
    VALUE
    0x80801099
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA54OR_C
    "fault class per DFC / Fault class for check DFC_rbr_outA54OR"
    VALUE
    0x8080109A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA54OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA54OT"
    VALUE
    0x8080109B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA54SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA54SCB"
    VALUE
    0x8080109C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA54SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA54SCG"
    VALUE
    0x8080109D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA55OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA55OL"
    VALUE
    0x8080109E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA55OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA55OT"
    VALUE
    0x8080109F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA55SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA55SCB"
    VALUE
    0x808010A0
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA55SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA55SCG"
    VALUE
    0x808010A1
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA56OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA56OL"
    VALUE
    0x808010A2
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA56OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA56OT"
    VALUE
    0x808010A3
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA56SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA56SCB"
    VALUE
    0x808010A4
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA56SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA56SCG"
    VALUE
    0x808010A5
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA58OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA58OL"
    VALUE
    0x808010A6
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA58OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA58OT"
    VALUE
    0x808010A7
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA58SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA58SCB"
    VALUE
    0x808010A8
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA58SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA58SCG"
    VALUE
    0x808010A9
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK07OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outK07OL"
    VALUE
    0x808010AA
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK07OR_C
    "fault class per DFC / Fault class for check DFC_rbr_outK07OR"
    VALUE
    0x808010AB
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK07OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outK07OT"
    VALUE
    0x808010AC
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK07SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outK07SCB"
    VALUE
    0x808010AD
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK07SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outK07SCG"
    VALUE
    0x808010AE
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK08OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outK08OL"
    VALUE
    0x808010AF
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK08OR_C
    "fault class per DFC / Fault class for check DFC_rbr_outK08OR"
    VALUE
    0x808010B0
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK08OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outK08OT"
    VALUE
    0x808010B1
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK08SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outK08SCB"
    VALUE
    0x808010B2
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK08SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outK08SCG"
    VALUE
    0x808010B3
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK09OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outK09OL"
    VALUE
    0x808010B4
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK09OR_C
    "fault class per DFC / Fault class for check DFC_rbr_outK09OR"
    VALUE
    0x808010B5
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK09OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outK09OT"
    VALUE
    0x808010B6
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK09SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outK09SCB"
    VALUE
    0x808010B7
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK09SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outK09SCG"
    VALUE
    0x808010B8
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK12OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outK12OL"
    VALUE
    0x808010B9
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK12OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outK12OT"
    VALUE
    0x808010BA
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK12SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outK12SCB"
    VALUE
    0x808010BB
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK12SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outK12SCG"
    VALUE
    0x808010BC
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK13OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outK13OL"
    VALUE
    0x808010BD
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK13OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outK13OT"
    VALUE
    0x808010BE
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK13SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outK13SCB"
    VALUE
    0x808010BF
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK13SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outK13SCG"
    VALUE
    0x808010C0
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK14OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outK14OL"
    VALUE
    0x808010C1
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK14OR_C
    "fault class per DFC / Fault class for check DFC_rbr_outK14OR"
    VALUE
    0x808010C2
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK14OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outK14OT"
    VALUE
    0x808010C3
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK14SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outK14SCB"
    VALUE
    0x808010C4
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK14SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outK14SCG"
    VALUE
    0x808010C5
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK15OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outK15OL"
    VALUE
    0x808010C6
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK15OR_C
    "fault class per DFC / Fault class for check DFC_rbr_outK15OR"
    VALUE
    0x808010C7
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK15OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outK15OT"
    VALUE
    0x808010C8
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK15SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outK15SCB"
    VALUE
    0x808010C9
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK15SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outK15SCG"
    VALUE
    0x808010CA
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK16OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outK16OL"
    VALUE
    0x808010CB
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK16OR_C
    "fault class per DFC / Fault class for check DFC_rbr_outK16OR"
    VALUE
    0x808010CC
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK16OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outK16OT"
    VALUE
    0x808010CD
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK16SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outK16SCB"
    VALUE
    0x808010CE
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK16SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outK16SCG"
    VALUE
    0x808010CF
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK17OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outK17OL"
    VALUE
    0x808010D0
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK17OR_C
    "fault class per DFC / Fault class for check DFC_rbr_outK17OR"
    VALUE
    0x808010D1
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK17OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outK17OT"
    VALUE
    0x808010D2
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK17SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outK17SCB"
    VALUE
    0x808010D3
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK17SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outK17SCG"
    VALUE
    0x808010D4
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK25OR_C
    "fault class per DFC / Fault class for check DFC_rbr_outK25OR"
    VALUE
    0x808010D5
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK25SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outK25SCB"
    VALUE
    0x808010D6
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK25SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outK25SCG"
    VALUE
    0x808010D7
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK29OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outK29OL"
    VALUE
    0x808010D8
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK29OR_C
    "fault class per DFC / Fault class for check DFC_rbr_outK29OR"
    VALUE
    0x808010D9
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK29OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outK29OT"
    VALUE
    0x808010DA
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK29SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outK29SCB"
    VALUE
    0x808010DB
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK29SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outK29SCG"
    VALUE
    0x808010DC
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK51OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outK51OL"
    VALUE
    0x808010DD
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK51OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outK51OT"
    VALUE
    0x808010DE
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK51SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outK51SCB"
    VALUE
    0x808010DF
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK51SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outK51SCG"
    VALUE
    0x808010E0
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK62OR_C
    "fault class per DFC / Fault class for check DFC_rbr_outK62OR"
    VALUE
    0x808010E1
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK62SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outK62SCB"
    VALUE
    0x808010E2
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK62SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outK62SCG"
    VALUE
    0x808010E3
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK73OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outK73OL"
    VALUE
    0x808010E4
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK73OR_C
    "fault class per DFC / Fault class for check DFC_rbr_outK73OR"
    VALUE
    0x808010E5
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK73OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outK73OT"
    VALUE
    0x808010E6
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK73SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outK73SCB"
    VALUE
    0x808010E7
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK73SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outK73SCG"
    VALUE
    0x808010E8
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK80OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outK80OL"
    VALUE
    0x808010E9
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK80OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outK80OT"
    VALUE
    0x808010EA
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK80SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outK80SCB"
    VALUE
    0x808010EB
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK80SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outK80SCG"
    VALUE
    0x808010EC
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK81OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outK81OL"
    VALUE
    0x808010ED
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK81OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outK81OT"
    VALUE
    0x808010EE
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK81SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outK81SCB"
    VALUE
    0x808010EF
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK81SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outK81SCG"
    VALUE
    0x808010F0
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK82OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outK82OL"
    VALUE
    0x808010F1
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK82OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outK82OT"
    VALUE
    0x808010F2
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK82SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outK82SCB"
    VALUE
    0x808010F3
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK82SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outK82SCG"
    VALUE
    0x808010F4
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK83OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outK83OL"
    VALUE
    0x808010F5
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK83OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outK83OT"
    VALUE
    0x808010F6
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK83SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outK83SCB"
    VALUE
    0x808010F7
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK83SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outK83SCG"
    VALUE
    0x808010F8
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK84OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outK84OL"
    VALUE
    0x808010F9
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK84OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outK84OT"
    VALUE
    0x808010FA
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK84SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outK84SCB"
    VALUE
    0x808010FB
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK84SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outK84SCG"
    VALUE
    0x808010FC
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK85OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outK85OL"
    VALUE
    0x808010FD
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK85OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outK85OT"
    VALUE
    0x808010FE
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK85SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outK85SCB"
    VALUE
    0x808010FF
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK85SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outK85SCG"
    VALUE
    0x80801100
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK86OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outK86OL"
    VALUE
    0x80801101
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK86OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outK86OT"
    VALUE
    0x80801102
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK86SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outK86SCB"
    VALUE
    0x80801103
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK86SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outK86SCG"
    VALUE
    0x80801104
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK87OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outK87OL"
    VALUE
    0x80801105
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK87OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outK87OT"
    VALUE
    0x80801106
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK87SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outK87SCB"
    VALUE
    0x80801107
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK87SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outK87SCG"
    VALUE
    0x80801108
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_EventUpDownDebFault_C
    "fault class per DFC / Fault class for check DFC_bds_EventUpDownDebFault"
    VALUE
    0x80801109
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_DSMDummy_C
    "fault class per DFC / Fault class for check DFC_DSMDummy"
    VALUE
    0x8080110A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canGetDataNoBuf_C
    "fault class per DFC / Fault class for check DFC_rbr_canGetDataNoBuf"
    VALUE
    0x8080110B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canGetDataParam_C
    "fault class per DFC / Fault class for check DFC_rbr_canGetDataParam"
    VALUE
    0x8080110C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canGetDataboxNoInit_C
    "fault class per DFC / Fault class for check DFC_rbr_canGetDataboxNoInit"
    VALUE
    0x8080110D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canGetDataboxParam_C
    "fault class per DFC / Fault class for check DFC_rbr_canGetDataboxParam"
    VALUE
    0x8080110E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canGetRxBufStatusParam_C
    "fault class per DFC / Fault class for check DFC_rbr_canGetRxBufStatusParam"
    VALUE
    0x8080110F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canGetStatusParam_C
    "fault class per DFC / Fault class for check DFC_rbr_canGetStatusParam"
    VALUE
    0x80801110
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canGetTxBufStatusParam_C
    "fault class per DFC / Fault class for check DFC_rbr_canGetTxBufStatusParam"
    VALUE
    0x80801111
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canInitParam_C
    "fault class per DFC / Fault class for check DFC_rbr_canInitParam"
    VALUE
    0x80801112
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canInitRxDataboxOverlap_C
    "fault class per DFC / Fault class for check DFC_rbr_canInitRxDataboxOverlap"
    VALUE
    0x80801113
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canInitRxDataboxParam_C
    "fault class per DFC / Fault class for check DFC_rbr_canInitRxDataboxParam"
    VALUE
    0x80801114
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canInitTxDataboxParam_C
    "fault class per DFC / Fault class for check DFC_rbr_canInitTxDataboxParam"
    VALUE
    0x80801115
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canIpduGroupControl_C
    "fault class per DFC / Fault class for check DFC_rbr_canIpduGroupControl"
    VALUE
    0x80801116
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canIsDataboxFreeNoInit_C
    "fault class per DFC / Fault class for check DFC_rbr_canIsDataboxFreeNoInit"
    VALUE
    0x80801117
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canIsDataboxFreeParam_C
    "fault class per DFC / Fault class for check DFC_rbr_canIsDataboxFreeParam"
    VALUE
    0x80801118
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canIsTxEmptyParam_C
    "fault class per DFC / Fault class for check DFC_rbr_canIsTxEmptyParam"
    VALUE
    0x80801119
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canRegBusOffCallbInvState_C
    "fault class per DFC / Fault class for check DFC_rbr_canRegBusOffCallbInvState"
    VALUE
    0x8080111A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canRegBusOffCallbParam_C
    "fault class per DFC / Fault class for check DFC_rbr_canRegBusOffCallbParam"
    VALUE
    0x8080111B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canRegRxBufInvState_C
    "fault class per DFC / Fault class for check DFC_rbr_canRegRxBufInvState"
    VALUE
    0x8080111C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canRegRxBufOverlap_C
    "fault class per DFC / Fault class for check DFC_rbr_canRegRxBufOverlap"
    VALUE
    0x8080111D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canRegRxBufParam_C
    "fault class per DFC / Fault class for check DFC_rbr_canRegRxBufParam"
    VALUE
    0x8080111E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canRegRxCallbInvState_C
    "fault class per DFC / Fault class for check DFC_rbr_canRegRxCallbInvState"
    VALUE
    0x8080111F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canRegRxCallbParam_C
    "fault class per DFC / Fault class for check DFC_rbr_canRegRxCallbParam"
    VALUE
    0x80801120
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canRegRxDataboxInvNumb_C
    "fault class per DFC / Fault class for check DFC_rbr_canRegRxDataboxInvNumb"
    VALUE
    0x80801121
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canRegRxDataboxInvState_C
    "fault class per DFC / Fault class for check DFC_rbr_canRegRxDataboxInvState"
    VALUE
    0x80801122
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canRegRxDataboxOverlap_C
    "fault class per DFC / Fault class for check DFC_rbr_canRegRxDataboxOverlap"
    VALUE
    0x80801123
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canRegRxDataboxParam_C
    "fault class per DFC / Fault class for check DFC_rbr_canRegRxDataboxParam"
    VALUE
    0x80801124
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canRegTxBufInvState_C
    "fault class per DFC / Fault class for check DFC_rbr_canRegTxBufInvState"
    VALUE
    0x80801125
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canRegTxBufOverlap_C
    "fault class per DFC / Fault class for check DFC_rbr_canRegTxBufOverlap"
    VALUE
    0x80801126
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canRegTxBufParam_C
    "fault class per DFC / Fault class for check DFC_rbr_canRegTxBufParam"
    VALUE
    0x80801127
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canRegTxDataboxInvNumb_C
    "fault class per DFC / Fault class for check DFC_rbr_canRegTxDataboxInvNumb"
    VALUE
    0x80801128
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canRegTxDataboxInvState_C
    "fault class per DFC / Fault class for check DFC_rbr_canRegTxDataboxInvState"
    VALUE
    0x80801129
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canRegTxDataboxOverlap_C
    "fault class per DFC / Fault class for check DFC_rbr_canRegTxDataboxOverlap"
    VALUE
    0x8080112A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canRegTxDataboxParam_C
    "fault class per DFC / Fault class for check DFC_rbr_canRegTxDataboxParam"
    VALUE
    0x8080112B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canResetTxBufParam_C
    "fault class per DFC / Fault class for check DFC_rbr_canResetTxBufParam"
    VALUE
    0x8080112C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canSendDataBufOvfl_C
    "fault class per DFC / Fault class for check DFC_rbr_canSendDataBufOvfl"
    VALUE
    0x8080112D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canSendDataParam_C
    "fault class per DFC / Fault class for check DFC_rbr_canSendDataParam"
    VALUE
    0x8080112E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canSendDataboxNoInit_C
    "fault class per DFC / Fault class for check DFC_rbr_canSendDataboxNoInit"
    VALUE
    0x8080112F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canSendDataboxParam_C
    "fault class per DFC / Fault class for check DFC_rbr_canSendDataboxParam"
    VALUE
    0x80801130
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canSetTxCycleParam_C
    "fault class per DFC / Fault class for check DFC_rbr_canSetTxCycleParam"
    VALUE
    0x80801131
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canStartParam_C
    "fault class per DFC / Fault class for check DFC_rbr_canStartParam"
    VALUE
    0x80801132
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canStopParam_C
    "fault class per DFC / Fault class for check DFC_rbr_canStopParam"
    VALUE
    0x80801133
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_can_ClearIpduGroup_C
    "fault class per DFC / Fault class for check DFC_rbr_can_ClearIpduGroup"
    VALUE
    0x80801134
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_can_ReceiveSignal_C
    "fault class per DFC / Fault class for check DFC_rbr_can_ReceiveSignal"
    VALUE
    0x80801135
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_can_SendSignal_C
    "fault class per DFC / Fault class for check DFC_rbr_can_SendSignal"
    VALUE
    0x80801136
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_can_SetIpduGroup_C
    "fault class per DFC / Fault class for check DFC_rbr_can_SetIpduGroup"
    VALUE
    0x80801137
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_dsmDTCJ1939_C
    "fault class per DFC / Fault class for check DFC_rbr_dsmDTCJ1939"
    VALUE
    0x80801138
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_dsmDelDTCJ1939_C
    "fault class per DFC / Fault class for check DFC_rbr_dsmDelDTCJ1939"
    VALUE
    0x80801139
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_dsmDelErrors_C
    "fault class per DFC / Fault class for check DFC_rbr_dsmDelErrors"
    VALUE
    0x8080113A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_dsmGetDFES_C
    "fault class per DFC / Fault class for check DFC_rbr_dsmGetDFES"
    VALUE
    0x8080113B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_dsmGetDTCJ1939_C
    "fault class per DFC / Fault class for check DFC_rbr_dsmGetDTCJ1939"
    VALUE
    0x8080113C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_dsmGetErrors_C
    "fault class per DFC / Fault class for check DFC_rbr_dsmGetErrors"
    VALUE
    0x8080113D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_dsmGetNumErrors_C
    "fault class per DFC / Fault class for check DFC_rbr_dsmGetNumErrors"
    VALUE
    0x8080113E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_dsmInitQueueOverflow_C
    "fault class per DFC / Fault class for check DFC_rbr_dsmInitQueueOverflow"
    VALUE
    0x8080113F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_dsmNumDTCJ1939_C
    "fault class per DFC / Fault class for check DFC_rbr_dsmNumDTCJ1939"
    VALUE
    0x80801140
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_dsmTesterror_C
    "fault class per DFC / Fault class for check DFC_rbr_dsmTesterror"
    VALUE
    0x80801141
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_dsmUpdateDebError_C
    "fault class per DFC / Fault class for check DFC_rbr_dsmUpdateDebError"
    VALUE
    0x80801142
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_dsmUpdateError_C
    "fault class per DFC / Fault class for check DFC_rbr_dsmUpdateError"
    VALUE
    0x80801143
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_dsmgetDFCStatus_C
    "fault class per DFC / Fault class for check DFC_rbr_dsmgetDFCStatus"
    VALUE
    0x80801144
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_dsmtestErrorDFC_C
    "fault class per DFC / Fault class for check DFC_rbr_dsmtestErrorDFC"
    VALUE
    0x80801145
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inAi_C
    "fault class per DFC / Fault class for check DFC_rbr_inAi"
    VALUE
    0x80801146
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inAic_C
    "fault class per DFC / Fault class for check DFC_rbr_inAic"
    VALUE
    0x80801147
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inAicCfg_C
    "fault class per DFC / Fault class for check DFC_rbr_inAicCfg"
    VALUE
    0x80801148
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inAicGetStatus_C
    "fault class per DFC / Fault class for check DFC_rbr_inAicGetStatus"
    VALUE
    0x80801149
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inAid_C
    "fault class per DFC / Fault class for check DFC_rbr_inAid"
    VALUE
    0x8080114A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inAidCfg_C
    "fault class per DFC / Fault class for check DFC_rbr_inAidCfg"
    VALUE
    0x8080114B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inAiv_C
    "fault class per DFC / Fault class for check DFC_rbr_inAiv"
    VALUE
    0x8080114C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inAivCfg_C
    "fault class per DFC / Fault class for check DFC_rbr_inAivCfg"
    VALUE
    0x8080114D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inAivGetStatus_C
    "fault class per DFC / Fault class for check DFC_rbr_inAivGetStatus"
    VALUE
    0x8080114E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inDi_C
    "fault class per DFC / Fault class for check DFC_rbr_inDi"
    VALUE
    0x8080114F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inFi_C
    "fault class per DFC / Fault class for check DFC_rbr_inFi"
    VALUE
    0x80801150
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inFiCfg_C
    "fault class per DFC / Fault class for check DFC_rbr_inFiCfg"
    VALUE
    0x80801151
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inFiGetStatus_C
    "fault class per DFC / Fault class for check DFC_rbr_inFiGetStatus"
    VALUE
    0x80801152
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inFi_Buffered_C
    "fault class per DFC / Fault class for check DFC_rbr_inFi_Buffered"
    VALUE
    0x80801153
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inPhase_C
    "fault class per DFC / Fault class for check DFC_rbr_inPhase"
    VALUE
    0x80801154
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inPhaseGetStatus_C
    "fault class per DFC / Fault class for check DFC_rbr_inPhaseGetStatus"
    VALUE
    0x80801155
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inPhaseResetCounter_C
    "fault class per DFC / Fault class for check DFC_rbr_inPhaseResetCounter"
    VALUE
    0x80801156
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inRi_C
    "fault class per DFC / Fault class for check DFC_rbr_inRi"
    VALUE
    0x80801157
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inRiCfg_C
    "fault class per DFC / Fault class for check DFC_rbr_inRiCfg"
    VALUE
    0x80801158
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inRiCfgTemp_C
    "fault class per DFC / Fault class for check DFC_rbr_inRiCfgTemp"
    VALUE
    0x80801159
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inRiGetStatus_C
    "fault class per DFC / Fault class for check DFC_rbr_inRiGetStatus"
    VALUE
    0x8080115A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inRiGetTemp_C
    "fault class per DFC / Fault class for check DFC_rbr_inRiGetTemp"
    VALUE
    0x8080115B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inSentCopyFDFifo_C
    "fault class per DFC / Fault class for check DFC_rbr_inSentCopyFDFifo"
    VALUE
    0x8080115C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inSentDisable_C
    "fault class per DFC / Fault class for check DFC_rbr_inSentDisable"
    VALUE
    0x8080115D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inSentEnable_C
    "fault class per DFC / Fault class for check DFC_rbr_inSentEnable"
    VALUE
    0x8080115E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inSentGetErrorStatus_C
    "fault class per DFC / Fault class for check DFC_rbr_inSentGetErrorStatus"
    VALUE
    0x8080115F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inSentGetFD_C
    "fault class per DFC / Fault class for check DFC_rbr_inSentGetFD"
    VALUE
    0x80801160
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inSentGetSD_C
    "fault class per DFC / Fault class for check DFC_rbr_inSentGetSD"
    VALUE
    0x80801161
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inSentGetSDDatabox_C
    "fault class per DFC / Fault class for check DFC_rbr_inSentGetSDDatabox"
    VALUE
    0x80801162
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inSentGetStatus_C
    "fault class per DFC / Fault class for check DFC_rbr_inSentGetStatus"
    VALUE
    0x80801163
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inSentInitSDDatabox_C
    "fault class per DFC / Fault class for check DFC_rbr_inSentInitSDDatabox"
    VALUE
    0x80801164
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inSentRegisterCopyFDFifo_C
    "fault class per DFC / Fault class for check DFC_rbr_inSentRegisterCopyFDFifo"
    VALUE
    0x80801165
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inSentRegisterFDFifo_C
    "fault class per DFC / Fault class for check DFC_rbr_inSentRegisterFDFifo"
    VALUE
    0x80801166
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inSentRegisterSDDataboxes_C
    "fault class per DFC / Fault class for check DFC_rbr_inSentRegisterSDDataboxes"
    VALUE
    0x80801167
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_isobusCanRxBufferOverflow_C
    "fault class per DFC / Fault class for check DFC_rbr_isobusCanRxBufferOverflow"
    VALUE
    0x80801168
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_isobusGetCaAddrParam_C
    "fault class per DFC / Fault class for check DFC_rbr_isobusGetCaAddrParam"
    VALUE
    0x80801169
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_isobusGetDiagnosticParam_C
    "fault class per DFC / Fault class for check DFC_rbr_isobusGetDiagnosticParam"
    VALUE
    0x8080116A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_isobusGetRxDataboxStatusParam_C
    "fault class per DFC / Fault class for check DFC_rbr_isobusGetRxDataboxStatusParam"
    VALUE
    0x8080116B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_isobusGetStatusParam_C
    "fault class per DFC / Fault class for check DFC_rbr_isobusGetStatusParam"
    VALUE
    0x8080116C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_isobusInitCommCaMissing_C
    "fault class per DFC / Fault class for check DFC_rbr_isobusInitCommCaMissing"
    VALUE
    0x8080116D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_isobusInitCommParam_C
    "fault class per DFC / Fault class for check DFC_rbr_isobusInitCommParam"
    VALUE
    0x8080116E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_isobusInitCommState_C
    "fault class per DFC / Fault class for check DFC_rbr_isobusInitCommState"
    VALUE
    0x8080116F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_isobusInitDiagnosticParam_C
    "fault class per DFC / Fault class for check DFC_rbr_isobusInitDiagnosticParam"
    VALUE
    0x80801170
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_isobusInitFailureListParam_C
    "fault class per DFC / Fault class for check DFC_rbr_isobusInitFailureListParam"
    VALUE
    0x80801171
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_isobusInitRxDataboxParam_C
    "fault class per DFC / Fault class for check DFC_rbr_isobusInitRxDataboxParam"
    VALUE
    0x80801172
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_isobusInitTxDataboxParam_C
    "fault class per DFC / Fault class for check DFC_rbr_isobusInitTxDataboxParam"
    VALUE
    0x80801173
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_isobusRegRxDataboxOverlap_C
    "fault class per DFC / Fault class for check DFC_rbr_isobusRegRxDataboxOverlap"
    VALUE
    0x80801174
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_isobusRegRxDataboxParam_C
    "fault class per DFC / Fault class for check DFC_rbr_isobusRegRxDataboxParam"
    VALUE
    0x80801175
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_isobusRegRxDataboxState_C
    "fault class per DFC / Fault class for check DFC_rbr_isobusRegRxDataboxState"
    VALUE
    0x80801176
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_isobusRegTxDataboxOverlap_C
    "fault class per DFC / Fault class for check DFC_rbr_isobusRegTxDataboxOverlap"
    VALUE
    0x80801177
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_isobusRegTxDataboxParam_C
    "fault class per DFC / Fault class for check DFC_rbr_isobusRegTxDataboxParam"
    VALUE
    0x80801178
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_isobusRegTxDataboxState_C
    "fault class per DFC / Fault class for check DFC_rbr_isobusRegTxDataboxState"
    VALUE
    0x80801179
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_isobusRegisterErrClrCallbackParam_C
    "fault class per DFC / Fault class for check DFC_rbr_isobusRegisterErrClrCallbackParam"
    VALUE
    0x8080117A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_isobusRegisterInstancesOverlap_C
    "fault class per DFC / Fault class for check DFC_rbr_isobusRegisterInstancesOverlap"
    VALUE
    0x8080117B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_isobusRegisterInstancesParam_C
    "fault class per DFC / Fault class for check DFC_rbr_isobusRegisterInstancesParam"
    VALUE
    0x8080117C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_isobusRegisterInstancesState_C
    "fault class per DFC / Fault class for check DFC_rbr_isobusRegisterInstancesState"
    VALUE
    0x8080117D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_isobusSendDataboxParam_C
    "fault class per DFC / Fault class for check DFC_rbr_isobusSendDataboxParam"
    VALUE
    0x8080117E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_isobusSendRequestPGNParam_C
    "fault class per DFC / Fault class for check DFC_rbr_isobusSendRequestPGNParam"
    VALUE
    0x8080117F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_isobusSetCaAddrCaUsed_C
    "fault class per DFC / Fault class for check DFC_rbr_isobusSetCaAddrCaUsed"
    VALUE
    0x80801180
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_isobusSetCaAddrComm_C
    "fault class per DFC / Fault class for check DFC_rbr_isobusSetCaAddrComm"
    VALUE
    0x80801181
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_isobusSetCaAddrInvCan_C
    "fault class per DFC / Fault class for check DFC_rbr_isobusSetCaAddrInvCan"
    VALUE
    0x80801182
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_isobusSetCaAddrParam_C
    "fault class per DFC / Fault class for check DFC_rbr_isobusSetCaAddrParam"
    VALUE
    0x80801183
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_isobusSetCaInfoParam_C
    "fault class per DFC / Fault class for check DFC_rbr_isobusSetCaInfoParam"
    VALUE
    0x80801184
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_isobusSetCaNameParam_C
    "fault class per DFC / Fault class for check DFC_rbr_isobusSetCaNameParam"
    VALUE
    0x80801185
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_isobusSftyCanTxErr_C
    "fault class per DFC / Fault class for check DFC_rbr_isobusSftyCanTxErr"
    VALUE
    0x80801186
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_lin_ReceiveSignal_C
    "fault class per DFC / Fault class for check DFC_rbr_lin_ReceiveSignal"
    VALUE
    0x80801187
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_lin_SendSignal_C
    "fault class per DFC / Fault class for check DFC_rbr_lin_SendSignal"
    VALUE
    0x80801188
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_lin_getStatus_C
    "fault class per DFC / Fault class for check DFC_rbr_lin_getStatus"
    VALUE
    0x80801189
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_lin_gotoSleep_C
    "fault class per DFC / Fault class for check DFC_rbr_lin_gotoSleep"
    VALUE
    0x8080118A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_lin_scheduleRequest_C
    "fault class per DFC / Fault class for check DFC_rbr_lin_scheduleRequest"
    VALUE
    0x8080118B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_lin_wakeUp_C
    "fault class per DFC / Fault class for check DFC_rbr_lin_wakeUp"
    VALUE
    0x8080118C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_memFlsCfgShr_C
    "fault class per DFC / Fault class for check DFC_rbr_memFlsCfgShr"
    VALUE
    0x8080118D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_memGetStatus_C
    "fault class per DFC / Fault class for check DFC_rbr_memGetStatus"
    VALUE
    0x8080118E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_memMarkBlock_C
    "fault class per DFC / Fault class for check DFC_rbr_memMarkBlock"
    VALUE
    0x8080118F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_memReadApi1Error_C
    "fault class per DFC / Fault class for check DFC_rbr_memReadApi1Error"
    VALUE
    0x80801190
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_memReadApi2Error_C
    "fault class per DFC / Fault class for check DFC_rbr_memReadApi2Error"
    VALUE
    0x80801191
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_memReadBlock_C
    "fault class per DFC / Fault class for check DFC_rbr_memReadBlock"
    VALUE
    0x80801192
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_memReadCalibInputError_C
    "fault class per DFC / Fault class for check DFC_rbr_memReadCalibInputError"
    VALUE
    0x80801193
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_memReadCalibOuputError_C
    "fault class per DFC / Fault class for check DFC_rbr_memReadCalibOuputError"
    VALUE
    0x80801194
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_memReadSystemError_C
    "fault class per DFC / Fault class for check DFC_rbr_memReadSystemError"
    VALUE
    0x80801195
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_memWriteBlock_C
    "fault class per DFC / Fault class for check DFC_rbr_memWriteBlock"
    VALUE
    0x80801196
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_moOV_FirstConstADC_C
    "fault class per DFC / Fault class for check DFC_rbr_moOV_FirstConstADC"
    VALUE
    0x80801197
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_moOV_SecondConstADC_C
    "fault class per DFC / Fault class for check DFC_rbr_moOV_SecondConstADC"
    VALUE
    0x80801198
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_moUV_FirstConstADC_C
    "fault class per DFC / Fault class for check DFC_rbr_moUV_FirstConstADC"
    VALUE
    0x80801199
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_moUV_SecondConstADC_C
    "fault class per DFC / Fault class for check DFC_rbr_moUV_SecondConstADC"
    VALUE
    0x8080119A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_INH_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_INH"
    VALUE
    0x8080119B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_INHLatch_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_INHLatch"
    VALUE
    0x8080119C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_adcPDD_fail_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_adcPDD_fail"
    VALUE
    0x8080119D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_memoryProtection_err_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_memoryProtection_err"
    VALUE
    0x8080119E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA02OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outA02OC"
    VALUE
    0x8080119F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA02Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outA02Unintended"
    VALUE
    0x808011A0
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA03OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outA03OC"
    VALUE
    0x808011A1
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA03Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outA03Unintended"
    VALUE
    0x808011A2
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA04OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outA04OC"
    VALUE
    0x808011A3
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA04Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outA04Unintended"
    VALUE
    0x808011A4
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA05OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outA05OC"
    VALUE
    0x808011A5
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA05Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outA05Unintended"
    VALUE
    0x808011A6
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA07OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outA07OC"
    VALUE
    0x808011A7
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA07Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outA07Unintended"
    VALUE
    0x808011A8
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA08OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outA08OC"
    VALUE
    0x808011A9
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA08Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outA08Unintended"
    VALUE
    0x808011AA
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA09OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outA09OC"
    VALUE
    0x808011AB
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA09Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outA09Unintended"
    VALUE
    0x808011AC
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA10OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outA10OC"
    VALUE
    0x808011AD
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA10Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outA10Unintended"
    VALUE
    0x808011AE
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA17OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outA17OC"
    VALUE
    0x808011AF
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA17Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outA17Unintended"
    VALUE
    0x808011B0
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA18OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outA18OC"
    VALUE
    0x808011B1
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA18Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outA18Unintended"
    VALUE
    0x808011B2
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA19OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outA19OC"
    VALUE
    0x808011B3
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA19Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outA19Unintended"
    VALUE
    0x808011B4
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA20OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outA20OC"
    VALUE
    0x808011B5
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA20Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outA20Unintended"
    VALUE
    0x808011B6
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA31OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outA31OC"
    VALUE
    0x808011B7
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA31Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outA31Unintended"
    VALUE
    0x808011B8
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA32OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outA32OC"
    VALUE
    0x808011B9
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA32Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outA32Unintended"
    VALUE
    0x808011BA
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA33OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outA33OC"
    VALUE
    0x808011BB
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA33Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outA33Unintended"
    VALUE
    0x808011BC
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA34OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outA34OC"
    VALUE
    0x808011BD
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA34Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outA34Unintended"
    VALUE
    0x808011BE
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA35OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outA35OC"
    VALUE
    0x808011BF
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA35Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outA35Unintended"
    VALUE
    0x808011C0
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA46OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outA46OC"
    VALUE
    0x808011C1
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA46Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outA46Unintended"
    VALUE
    0x808011C2
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA47OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outA47OC"
    VALUE
    0x808011C3
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA47Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outA47Unintended"
    VALUE
    0x808011C4
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA48OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outA48OC"
    VALUE
    0x808011C5
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA48Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outA48Unintended"
    VALUE
    0x808011C6
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA51OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outA51OC"
    VALUE
    0x808011C7
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA51Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outA51Unintended"
    VALUE
    0x808011C8
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA52OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outA52OC"
    VALUE
    0x808011C9
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA52Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outA52Unintended"
    VALUE
    0x808011CA
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA53OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outA53OC"
    VALUE
    0x808011CB
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA53Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outA53Unintended"
    VALUE
    0x808011CC
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA54OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outA54OC"
    VALUE
    0x808011CD
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA54Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outA54Unintended"
    VALUE
    0x808011CE
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outAov_C
    "fault class per DFC / Fault class for check DFC_rbr_outAov"
    VALUE
    0x808011CF
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outAovCfg_C
    "fault class per DFC / Fault class for check DFC_rbr_outAovCfg"
    VALUE
    0x808011D0
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outAovCfgPI_C
    "fault class per DFC / Fault class for check DFC_rbr_outAovCfgPI"
    VALUE
    0x808011D1
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outAovGetStatus_C
    "fault class per DFC / Fault class for check DFC_rbr_outAovGetStatus"
    VALUE
    0x808011D2
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outAovGetVoltage_C
    "fault class per DFC / Fault class for check DFC_rbr_outAovGetVoltage"
    VALUE
    0x808011D3
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outAovResetError_C
    "fault class per DFC / Fault class for check DFC_rbr_outAovResetError"
    VALUE
    0x808011D4
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outDo_C
    "fault class per DFC / Fault class for check DFC_rbr_outDo"
    VALUE
    0x808011D5
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outDoCfgPwrLs_C
    "fault class per DFC / Fault class for check DFC_rbr_outDoCfgPwrLs"
    VALUE
    0x808011D6
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outDoDisable_C
    "fault class per DFC / Fault class for check DFC_rbr_outDoDisable"
    VALUE
    0x808011D7
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outDoGetCurrent_C
    "fault class per DFC / Fault class for check DFC_rbr_outDoGetCurrent"
    VALUE
    0x808011D8
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outDoGetStatus_C
    "fault class per DFC / Fault class for check DFC_rbr_outDoGetStatus"
    VALUE
    0x808011D9
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outDoResetError_C
    "fault class per DFC / Fault class for check DFC_rbr_outDoResetError"
    VALUE
    0x808011DA
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK07OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outK07OC"
    VALUE
    0x808011DB
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK07Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outK07Unintended"
    VALUE
    0x808011DC
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK08OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outK08OC"
    VALUE
    0x808011DD
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK08Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outK08Unintended"
    VALUE
    0x808011DE
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK09OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outK09OC"
    VALUE
    0x808011DF
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK09Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outK09Unintended"
    VALUE
    0x808011E0
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK12OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outK12OC"
    VALUE
    0x808011E1
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK12Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outK12Unintended"
    VALUE
    0x808011E2
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK13OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outK13OC"
    VALUE
    0x808011E3
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK13Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outK13Unintended"
    VALUE
    0x808011E4
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK14OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outK14OC"
    VALUE
    0x808011E5
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK14Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outK14Unintended"
    VALUE
    0x808011E6
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK15OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outK15OC"
    VALUE
    0x808011E7
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK15Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outK15Unintended"
    VALUE
    0x808011E8
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK16OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outK16OC"
    VALUE
    0x808011E9
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK16Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outK16Unintended"
    VALUE
    0x808011EA
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK17OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outK17OC"
    VALUE
    0x808011EB
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK17Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outK17Unintended"
    VALUE
    0x808011EC
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK29OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outK29OC"
    VALUE
    0x808011ED
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK29Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outK29Unintended"
    VALUE
    0x808011EE
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK51OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outK51OC"
    VALUE
    0x808011EF
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK51Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outK51Unintended"
    VALUE
    0x808011F0
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK73OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outK73OC"
    VALUE
    0x808011F1
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK73Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outK73Unintended"
    VALUE
    0x808011F2
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outPo_C
    "fault class per DFC / Fault class for check DFC_rbr_outPo"
    VALUE
    0x808011F3
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outPoCfg_C
    "fault class per DFC / Fault class for check DFC_rbr_outPoCfg"
    VALUE
    0x808011F4
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outPoCfgPeriod_C
    "fault class per DFC / Fault class for check DFC_rbr_outPoCfgPeriod"
    VALUE
    0x808011F5
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outPoCfgPwrLs_C
    "fault class per DFC / Fault class for check DFC_rbr_outPoCfgPwrLs"
    VALUE
    0x808011F6
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outPoDisable_C
    "fault class per DFC / Fault class for check DFC_rbr_outPoDisable"
    VALUE
    0x808011F7
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outPoGetCurrent_C
    "fault class per DFC / Fault class for check DFC_rbr_outPoGetCurrent"
    VALUE
    0x808011F8
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outPoGetStatus_C
    "fault class per DFC / Fault class for check DFC_rbr_outPoGetStatus"
    VALUE
    0x808011F9
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outPoResetError_C
    "fault class per DFC / Fault class for check DFC_rbr_outPoResetError"
    VALUE
    0x808011FA
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outPoc_C
    "fault class per DFC / Fault class for check DFC_rbr_outPoc"
    VALUE
    0x808011FB
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outPocCfg_C
    "fault class per DFC / Fault class for check DFC_rbr_outPocCfg"
    VALUE
    0x808011FC
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outPocCfgDither_C
    "fault class per DFC / Fault class for check DFC_rbr_outPocCfgDither"
    VALUE
    0x808011FD
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outPocCfgPI_C
    "fault class per DFC / Fault class for check DFC_rbr_outPocCfgPI"
    VALUE
    0x808011FE
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outPod_C
    "fault class per DFC / Fault class for check DFC_rbr_outPod"
    VALUE
    0x808011FF
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outPodCfg_C
    "fault class per DFC / Fault class for check DFC_rbr_outPodCfg"
    VALUE
    0x80801200
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outPodCfgPeriod_C
    "fault class per DFC / Fault class for check DFC_rbr_outPodCfgPeriod"
    VALUE
    0x80801201
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_rsmFfiApiCallErr_C
    "fault class per DFC / Fault class for check DFC_rbr_rsmFfiApiCallErr"
    VALUE
    0x80801202
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safout_C
    "fault class per DFC / Fault class for check DFC_rbr_safout"
    VALUE
    0x80801203
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutCfg_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutCfg"
    VALUE
    0x80801204
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl1_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl1"
    VALUE
    0x80801205
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl10_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl10"
    VALUE
    0x80801206
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl10Dev_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl10Dev"
    VALUE
    0x80801207
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl10OR_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl10OR"
    VALUE
    0x80801208
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl11_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl11"
    VALUE
    0x80801209
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl11Dev_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl11Dev"
    VALUE
    0x8080120A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl11OR_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl11OR"
    VALUE
    0x8080120B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl12_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl12"
    VALUE
    0x8080120C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl12Dev_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl12Dev"
    VALUE
    0x8080120D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl12OR_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl12OR"
    VALUE
    0x8080120E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl13_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl13"
    VALUE
    0x8080120F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl13Dev_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl13Dev"
    VALUE
    0x80801210
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl13OR_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl13OR"
    VALUE
    0x80801211
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl14_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl14"
    VALUE
    0x80801212
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl14Dev_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl14Dev"
    VALUE
    0x80801213
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl14OR_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl14OR"
    VALUE
    0x80801214
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl15_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl15"
    VALUE
    0x80801215
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl15Dev_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl15Dev"
    VALUE
    0x80801216
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl15OR_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl15OR"
    VALUE
    0x80801217
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl16_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl16"
    VALUE
    0x80801218
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl16Dev_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl16Dev"
    VALUE
    0x80801219
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl16OR_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl16OR"
    VALUE
    0x8080121A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl17_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl17"
    VALUE
    0x8080121B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl17Dev_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl17Dev"
    VALUE
    0x8080121C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl17OR_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl17OR"
    VALUE
    0x8080121D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl18_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl18"
    VALUE
    0x8080121E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl18Dev_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl18Dev"
    VALUE
    0x8080121F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl18OR_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl18OR"
    VALUE
    0x80801220
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl1Dev_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl1Dev"
    VALUE
    0x80801221
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl1OR_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl1OR"
    VALUE
    0x80801222
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl2_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl2"
    VALUE
    0x80801223
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl2Dev_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl2Dev"
    VALUE
    0x80801224
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl2OR_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl2OR"
    VALUE
    0x80801225
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl3_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl3"
    VALUE
    0x80801226
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl3Dev_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl3Dev"
    VALUE
    0x80801227
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl3OR_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl3OR"
    VALUE
    0x80801228
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl4_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl4"
    VALUE
    0x80801229
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl4Dev_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl4Dev"
    VALUE
    0x8080122A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl4OR_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl4OR"
    VALUE
    0x8080122B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl5_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl5"
    VALUE
    0x8080122C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl5Dev_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl5Dev"
    VALUE
    0x8080122D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl5OR_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl5OR"
    VALUE
    0x8080122E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl6_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl6"
    VALUE
    0x8080122F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl6Dev_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl6Dev"
    VALUE
    0x80801230
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl6OR_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl6OR"
    VALUE
    0x80801231
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl7_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl7"
    VALUE
    0x80801232
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl7Dev_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl7Dev"
    VALUE
    0x80801233
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl7OR_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl7OR"
    VALUE
    0x80801234
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl8_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl8"
    VALUE
    0x80801235
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl8Dev_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl8Dev"
    VALUE
    0x80801236
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl8OR_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl8OR"
    VALUE
    0x80801237
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl9_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl9"
    VALUE
    0x80801238
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl9Dev_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl9Dev"
    VALUE
    0x80801239
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl9OR_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl9OR"
    VALUE
    0x8080123A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutDevError_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutDevError"
    VALUE
    0x8080123B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutGetStatus_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutGetStatus"
    VALUE
    0x8080123C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutIgnoreError_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutIgnoreError"
    VALUE
    0x8080123D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutResetError_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutResetError"
    VALUE
    0x8080123E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutUnlock_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutUnlock"
    VALUE
    0x8080123F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safout_cfgDiag_C
    "fault class per DFC / Fault class for check DFC_rbr_safout_cfgDiag"
    VALUE
    0x80801240
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_secAccessDenied_RC_C
    "fault class per DFC / Fault class for check DFC_rbr_secAccessDenied_RC"
    VALUE
    0x80801241
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_secAccessDenied_WDBI_C
    "fault class per DFC / Fault class for check DFC_rbr_secAccessDenied_WDBI"
    VALUE
    0x80801242
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_secEvalRespKey_C
    "fault class per DFC / Fault class for check DFC_rbr_secEvalRespKey"
    VALUE
    0x80801243
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_secFlashingFailure_C
    "fault class per DFC / Fault class for check DFC_rbr_secFlashingFailure"
    VALUE
    0x80801244
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_secGetLevel_C
    "fault class per DFC / Fault class for check DFC_rbr_secGetLevel"
    VALUE
    0x80801245
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_secGetRnd_C
    "fault class per DFC / Fault class for check DFC_rbr_secGetRnd"
    VALUE
    0x80801246
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_secGetSeed_C
    "fault class per DFC / Fault class for check DFC_rbr_secGetSeed"
    VALUE
    0x80801247
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_secInvalidPassword_C
    "fault class per DFC / Fault class for check DFC_rbr_secInvalidPassword"
    VALUE
    0x80801248
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_secIsRequestAllowed_C
    "fault class per DFC / Fault class for check DFC_rbr_secIsRequestAllowed"
    VALUE
    0x80801249
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_secResetLevel_C
    "fault class per DFC / Fault class for check DFC_rbr_secResetLevel"
    VALUE
    0x8080124A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_secSaveSecret_C
    "fault class per DFC / Fault class for check DFC_rbr_secSaveSecret"
    VALUE
    0x8080124B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_secSetLevel_C
    "fault class per DFC / Fault class for check DFC_rbr_secSetLevel"
    VALUE
    0x8080124C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_sysAit_C
    "fault class per DFC / Fault class for check DFC_rbr_sysAit"
    VALUE
    0x8080124D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_sysAiv_C
    "fault class per DFC / Fault class for check DFC_rbr_sysAiv"
    VALUE
    0x8080124E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_sysDi_C
    "fault class per DFC / Fault class for check DFC_rbr_sysDi"
    VALUE
    0x8080124F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_sysDo_C
    "fault class per DFC / Fault class for check DFC_rbr_sysDo"
    VALUE
    0x80801250
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_sysGetVss_C
    "fault class per DFC / Fault class for check DFC_rbr_sysGetVss"
    VALUE
    0x80801251
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_sysInit_C
    "fault class per DFC / Fault class for check DFC_rbr_sysInit"
    VALUE
    0x80801252
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_sysOperHrIntegrityErr_C
    "fault class per DFC / Fault class for check DFC_rbr_sysOperHrIntegrityErr"
    VALUE
    0x80801253
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_sysOperHrsSaturated_C
    "fault class per DFC / Fault class for check DFC_rbr_sysOperHrsSaturated"
    VALUE
    0x80801254
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_sysSetVss_C
    "fault class per DFC / Fault class for check DFC_rbr_sysSetVss"
    VALUE
    0x80801255
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_sys_coreload_C
    "fault class per DFC / Fault class for check DFC_rbr_sys_coreload"
    VALUE
    0x80801256
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_sys_taskload_C
    "fault class per DFC / Fault class for check DFC_rbr_sys_taskload"
    VALUE
    0x80801257
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_OV_VSS1_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_OV_VSS1"
    VALUE
    0x80801258
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_OV_VSS2_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_OV_VSS2"
    VALUE
    0x80801259
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_UV_VSS1_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_UV_VSS1"
    VALUE
    0x8080125A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_UV_VSS2_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_UV_VSS2"
    VALUE
    0x8080125B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_CANSM_E_BUS_OFF_NETWORK_0_C
    "fault class per DFC / Fault class for check DFC_CANSM_E_BUS_OFF_NETWORK_0"
    VALUE
    0x8080125C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_CANSM_E_BUS_OFF_NETWORK_1_C
    "fault class per DFC / Fault class for check DFC_CANSM_E_BUS_OFF_NETWORK_1"
    VALUE
    0x8080125D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_CANSM_E_BUS_OFF_NETWORK_2_C
    "fault class per DFC / Fault class for check DFC_CANSM_E_BUS_OFF_NETWORK_2"
    VALUE
    0x8080125E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_CANSM_E_BUS_OFF_NETWORK_3_C
    "fault class per DFC / Fault class for check DFC_CANSM_E_BUS_OFF_NETWORK_3"
    VALUE
    0x8080125F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_CANTRCV_E_NO_TRCV_CONTROL_0_C
    "fault class per DFC / Fault class for check DFC_CANTRCV_E_NO_TRCV_CONTROL_0"
    VALUE
    0x80801260
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_CAN_E_TIMEOUT_C
    "fault class per DFC / Fault class for check DFC_CAN_E_TIMEOUT"
    VALUE
    0x80801261
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_COMM_E_NET_START_IND_CHANNEL_0_C
    "fault class per DFC / Fault class for check DFC_COMM_E_NET_START_IND_CHANNEL_0"
    VALUE
    0x80801262
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_COMM_E_NET_START_IND_CHANNEL_1_C
    "fault class per DFC / Fault class for check DFC_COMM_E_NET_START_IND_CHANNEL_1"
    VALUE
    0x80801263
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_COMM_E_NET_START_IND_CHANNEL_2_C
    "fault class per DFC / Fault class for check DFC_COMM_E_NET_START_IND_CHANNEL_2"
    VALUE
    0x80801264
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_COMM_E_NET_START_IND_CHANNEL_3_C
    "fault class per DFC / Fault class for check DFC_COMM_E_NET_START_IND_CHANNEL_3"
    VALUE
    0x80801265
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_COMM_E_NET_START_IND_CHANNEL_4_C
    "fault class per DFC / Fault class for check DFC_COMM_E_NET_START_IND_CHANNEL_4"
    VALUE
    0x80801266
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_COMM_E_NET_START_IND_CHANNEL_5_C
    "fault class per DFC / Fault class for check DFC_COMM_E_NET_START_IND_CHANNEL_5"
    VALUE
    0x80801267
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_LIN_E_TIMEOUT_C
    "fault class per DFC / Fault class for check DFC_LIN_E_TIMEOUT"
    VALUE
    0x80801268
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rba_MultiStackTrace_Threshold_C
    "fault class per DFC / Fault class for check DFC_rba_MultiStackTrace_Threshold"
    VALUE
    0x80801269
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_ETH_E_ACCESS_0_C
    "fault class per DFC / Fault class for check DFC_ETH_E_ACCESS_0"
    VALUE
    0x8080126A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_RBA_IOEXTLIB_KEEPALIVE_DRV_C
    "fault class per DFC / Fault class for check DFC_RBA_IOEXTLIB_KEEPALIVE_DRV"
    VALUE
    0x8080126B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_RBA_IOEXTLIB_KEEPALIVE_INI_C
    "fault class per DFC / Fault class for check DFC_RBA_IOEXTLIB_KEEPALIVE_INI"
    VALUE
    0x8080126C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rba_MRly_Diag_Stk_Event_C
    "fault class per DFC / Fault class for check DFC_rba_MRly_Diag_Stk_Event"
    VALUE
    0x8080126D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rba_MemDiagExtd_MemReadSngErr_C
    "fault class per DFC / Fault class for check DFC_rba_MemDiagExtd_MemReadSngErr"
    VALUE
    0x8080126E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rba_MemDiag_MemReadErr_C
    "fault class per DFC / Fault class for check DFC_rba_MemDiag_MemReadErr"
    VALUE
    0x8080126F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rba_MemDiag_MemWrErr_C
    "fault class per DFC / Fault class for check DFC_rba_MemDiag_MemWrErr"
    VALUE
    0x80801270
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rba_SyC_IrrSwOffTrigEngRun_Event_C
    "fault class per DFC / Fault class for check DFC_rba_SyC_IrrSwOffTrigEngRun_Event"
    VALUE
    0x80801271
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rba_T15_Diag_ComInVld_Event_C
    "fault class per DFC / Fault class for check DFC_rba_T15_Diag_ComInVld_Event"
    VALUE
    0x80801272
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rba_T15_Diag_ComOff_HwOn_Event_C
    "fault class per DFC / Fault class for check DFC_rba_T15_Diag_ComOff_HwOn_Event"
    VALUE
    0x80801273
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rba_T15_Diag_ComOn_HwOff_Event_C
    "fault class per DFC / Fault class for check DFC_rba_T15_Diag_ComOn_HwOff_Event"
    VALUE
    0x80801274
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM0_0_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM0_0"
    VALUE
    0x80801275
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM0_1_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM0_1"
    VALUE
    0x80801276
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM0_10_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM0_10"
    VALUE
    0x80801277
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM0_11_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM0_11"
    VALUE
    0x80801278
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM0_13_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM0_13"
    VALUE
    0x80801279
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM0_14_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM0_14"
    VALUE
    0x8080127A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM0_2_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM0_2"
    VALUE
    0x8080127B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM0_22_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM0_22"
    VALUE
    0x8080127C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM0_23_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM0_23"
    VALUE
    0x8080127D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM0_4_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM0_4"
    VALUE
    0x8080127E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM0_5_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM0_5"
    VALUE
    0x8080127F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM0_7_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM0_7"
    VALUE
    0x80801280
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM0_8_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM0_8"
    VALUE
    0x80801281
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM10_16_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM10_16"
    VALUE
    0x80801282
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM10_17_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM10_17"
    VALUE
    0x80801283
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM10_21_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM10_21"
    VALUE
    0x80801284
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM11_0_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM11_0"
    VALUE
    0x80801285
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM11_1_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM11_1"
    VALUE
    0x80801286
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM11_2_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM11_2"
    VALUE
    0x80801287
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM11_3_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM11_3"
    VALUE
    0x80801288
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM11_4_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM11_4"
    VALUE
    0x80801289
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM11_5_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM11_5"
    VALUE
    0x8080128A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM11_8_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM11_8"
    VALUE
    0x8080128B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM11_9_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM11_9"
    VALUE
    0x8080128C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM1_0_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM1_0"
    VALUE
    0x8080128D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM1_1_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM1_1"
    VALUE
    0x8080128E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM1_10_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM1_10"
    VALUE
    0x8080128F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM1_11_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM1_11"
    VALUE
    0x80801290
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM1_13_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM1_13"
    VALUE
    0x80801291
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM1_14_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM1_14"
    VALUE
    0x80801292
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM1_2_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM1_2"
    VALUE
    0x80801293
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM1_22_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM1_22"
    VALUE
    0x80801294
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM1_23_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM1_23"
    VALUE
    0x80801295
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM1_4_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM1_4"
    VALUE
    0x80801296
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM1_5_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM1_5"
    VALUE
    0x80801297
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM1_7_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM1_7"
    VALUE
    0x80801298
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM1_8_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM1_8"
    VALUE
    0x80801299
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM21_0_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM21_0"
    VALUE
    0x8080129A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM21_16_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM21_16"
    VALUE
    0x8080129B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM21_3_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM21_3"
    VALUE
    0x8080129C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM2_1_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM2_1"
    VALUE
    0x8080129D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM2_10_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM2_10"
    VALUE
    0x8080129E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM2_11_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM2_11"
    VALUE
    0x8080129F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM2_13_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM2_13"
    VALUE
    0x808012A0
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM2_14_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM2_14"
    VALUE
    0x808012A1
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM2_2_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM2_2"
    VALUE
    0x808012A2
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM2_22_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM2_22"
    VALUE
    0x808012A3
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM2_23_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM2_23"
    VALUE
    0x808012A4
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM2_4_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM2_4"
    VALUE
    0x808012A5
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM2_5_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM2_5"
    VALUE
    0x808012A6
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM2_7_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM2_7"
    VALUE
    0x808012A7
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM2_8_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM2_8"
    VALUE
    0x808012A8
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM3_1_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM3_1"
    VALUE
    0x808012A9
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM3_10_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM3_10"
    VALUE
    0x808012AA
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM3_11_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM3_11"
    VALUE
    0x808012AB
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM3_13_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM3_13"
    VALUE
    0x808012AC
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM3_14_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM3_14"
    VALUE
    0x808012AD
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM3_2_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM3_2"
    VALUE
    0x808012AE
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM3_22_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM3_22"
    VALUE
    0x808012AF
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM3_23_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM3_23"
    VALUE
    0x808012B0
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM3_4_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM3_4"
    VALUE
    0x808012B1
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM3_5_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM3_5"
    VALUE
    0x808012B2
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM3_7_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM3_7"
    VALUE
    0x808012B3
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM3_8_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM3_8"
    VALUE
    0x808012B4
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM6_0_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM6_0"
    VALUE
    0x808012B5
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM6_11_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM6_11"
    VALUE
    0x808012B6
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM6_12_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM6_12"
    VALUE
    0x808012B7
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM6_14_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM6_14"
    VALUE
    0x808012B8
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

