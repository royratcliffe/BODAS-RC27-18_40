      DFES_DTCSAEFMI.DFC_rbr_isobusRegTxDataboxParam_C DFES_DTCSAEFMI.DFC_rbr_isobusRegTxDataboxState_C DFES_DTCSAEFMI.DFC_rbr_isobusRegisterErrClrCallbackParam_C DFES_DTCSAEFMI.DFC_rbr_isobusRegisterInstancesOverlap_C DFES_DTCSAEFMI.DFC_rbr_isobusRegisterInstancesParam_C DFES_DTCSAEFMI.DFC_rbr_isobusRegisterInstancesState_C
      DFES_DTCSAEFMI.DFC_rbr_isobusSendDataboxParam_C DFES_DTCSAEFMI.DFC_rbr_isobusSendRequestPGNParam_C DFES_DTCSAEFMI.DFC_rbr_isobusSetCaAddrCaUsed_C DFES_DTCSAEFMI.DFC_rbr_isobusSetCaAddrComm_C DFES_DTCSAEFMI.DFC_rbr_isobusSetCaAddrInvCan_C DFES_DTCSAEFMI.DFC_rbr_isobusSetCaAddrParam_C
      DFES_DTCSAEFMI.DFC_rbr_isobusSetCaInfoParam_C DFES_DTCSAEFMI.DFC_rbr_isobusSetCaNameParam_C DFES_DTCSAEFMI.DFC_rbr_isobusSftyCanTxErr_C DFES_DTCSAEFMI.DFC_rbr_lin_ReceiveSignal_C DFES_DTCSAEFMI.DFC_rbr_lin_SendSignal_C DFES_DTCSAEFMI.DFC_rbr_lin_getStatus_C
      DFES_DTCSAEFMI.DFC_rbr_lin_gotoSleep_C DFES_DTCSAEFMI.DFC_rbr_lin_scheduleRequest_C DFES_DTCSAEFMI.DFC_rbr_lin_wakeUp_C DFES_DTCSAEFMI.DFC_rbr_memFlsCfgShr_C DFES_DTCSAEFMI.DFC_rbr_memGetStatus_C DFES_DTCSAEFMI.DFC_rbr_memMarkBlock_C
      DFES_DTCSAEFMI.DFC_rbr_memReadApi1Error_C DFES_DTCSAEFMI.DFC_rbr_memReadApi2Error_C DFES_DTCSAEFMI.DFC_rbr_memReadBlock_C DFES_DTCSAEFMI.DFC_rbr_memReadCalibInputError_C DFES_DTCSAEFMI.DFC_rbr_memReadCalibOuputError_C DFES_DTCSAEFMI.DFC_rbr_memReadSystemError_C
      DFES_DTCSAEFMI.DFC_rbr_memWriteBlock_C DFES_DTCSAEFMI.DFC_rbr_moOV_FirstConstADC_C DFES_DTCSAEFMI.DFC_rbr_moOV_SecondConstADC_C DFES_DTCSAEFMI.DFC_rbr_moUV_FirstConstADC_C DFES_DTCSAEFMI.DFC_rbr_moUV_SecondConstADC_C DFES_DTCSAEFMI.DFC_rbr_mo_INH_C
      DFES_DTCSAEFMI.DFC_rbr_mo_INHLatch_C DFES_DTCSAEFMI.DFC_rbr_mo_adcPDD_fail_C DFES_DTCSAEFMI.DFC_rbr_mo_memoryProtection_err_C DFES_DTCSAEFMI.DFC_rbr_outA02OC_C DFES_DTCSAEFMI.DFC_rbr_outA02Unintended_C DFES_DTCSAEFMI.DFC_rbr_outA03OC_C
      DFES_DTCSAEFMI.DFC_rbr_outA03Unintended_C DFES_DTCSAEFMI.DFC_rbr_outA04OC_C DFES_DTCSAEFMI.DFC_rbr_outA04Unintended_C DFES_DTCSAEFMI.DFC_rbr_outA05OC_C DFES_DTCSAEFMI.DFC_rbr_outA05Unintended_C DFES_DTCSAEFMI.DFC_rbr_outA07OC_C
      DFES_DTCSAEFMI.DFC_rbr_outA07Unintended_C DFES_DTCSAEFMI.DFC_rbr_outA08OC_C DFES_DTCSAEFMI.DFC_rbr_outA08Unintended_C DFES_DTCSAEFMI.DFC_rbr_outA09OC_C DFES_DTCSAEFMI.DFC_rbr_outA09Unintended_C DFES_DTCSAEFMI.DFC_rbr_outA10OC_C
      DFES_DTCSAEFMI.DFC_rbr_outA10Unintended_C DFES_DTCSAEFMI.DFC_rbr_outA17OC_C DFES_DTCSAEFMI.DFC_rbr_outA17Unintended_C DFES_DTCSAEFMI.DFC_rbr_outA18OC_C DFES_DTCSAEFMI.DFC_rbr_outA18Unintended_C DFES_DTCSAEFMI.DFC_rbr_outA19OC_C
      DFES_DTCSAEFMI.DFC_rbr_outA19Unintended_C DFES_DTCSAEFMI.DFC_rbr_outA20OC_C DFES_DTCSAEFMI.DFC_rbr_outA20Unintended_C DFES_DTCSAEFMI.DFC_rbr_outA31OC_C DFES_DTCSAEFMI.DFC_rbr_outA31Unintended_C DFES_DTCSAEFMI.DFC_rbr_outA32OC_C
      DFES_DTCSAEFMI.DFC_rbr_outA32Unintended_C DFES_DTCSAEFMI.DFC_rbr_outA33OC_C DFES_DTCSAEFMI.DFC_rbr_outA33Unintended_C DFES_DTCSAEFMI.DFC_rbr_outA34OC_C DFES_DTCSAEFMI.DFC_rbr_outA34Unintended_C DFES_DTCSAEFMI.DFC_rbr_outA35OC_C
      DFES_DTCSAEFMI.DFC_rbr_outA35Unintended_C DFES_DTCSAEFMI.DFC_rbr_outA46OC_C DFES_DTCSAEFMI.DFC_rbr_outA46Unintended_C DFES_DTCSAEFMI.DFC_rbr_outA47OC_C DFES_DTCSAEFMI.DFC_rbr_outA47Unintended_C DFES_DTCSAEFMI.DFC_rbr_outA48OC_C
      DFES_DTCSAEFMI.DFC_rbr_outA48Unintended_C DFES_DTCSAEFMI.DFC_rbr_outA51OC_C DFES_DTCSAEFMI.DFC_rbr_outA51Unintended_C DFES_DTCSAEFMI.DFC_rbr_outA52OC_C DFES_DTCSAEFMI.DFC_rbr_outA52Unintended_C DFES_DTCSAEFMI.DFC_rbr_outA53OC_C
      DFES_DTCSAEFMI.DFC_rbr_outA53Unintended_C DFES_DTCSAEFMI.DFC_rbr_outA54OC_C DFES_DTCSAEFMI.DFC_rbr_outA54Unintended_C DFES_DTCSAEFMI.DFC_rbr_outAov_C DFES_DTCSAEFMI.DFC_rbr_outAovCfg_C DFES_DTCSAEFMI.DFC_rbr_outAovCfgPI_C
      DFES_DTCSAEFMI.DFC_rbr_outAovGetStatus_C DFES_DTCSAEFMI.DFC_rbr_outAovGetVoltage_C DFES_DTCSAEFMI.DFC_rbr_outAovResetError_C DFES_DTCSAEFMI.DFC_rbr_outDo_C DFES_DTCSAEFMI.DFC_rbr_outDoCfgPwrLs_C DFES_DTCSAEFMI.DFC_rbr_outDoDisable_C
      DFES_DTCSAEFMI.DFC_rbr_outDoGetCurrent_C DFES_DTCSAEFMI.DFC_rbr_outDoGetStatus_C DFES_DTCSAEFMI.DFC_rbr_outDoResetError_C DFES_DTCSAEFMI.DFC_rbr_outK07OC_C DFES_DTCSAEFMI.DFC_rbr_outK07Unintended_C DFES_DTCSAEFMI.DFC_rbr_outK08OC_C
      DFES_DTCSAEFMI.DFC_rbr_outK08Unintended_C DFES_DTCSAEFMI.DFC_rbr_outK09OC_C DFES_DTCSAEFMI.DFC_rbr_outK09Unintended_C DFES_DTCSAEFMI.DFC_rbr_outK12OC_C DFES_DTCSAEFMI.DFC_rbr_outK12Unintended_C DFES_DTCSAEFMI.DFC_rbr_outK13OC_C
      DFES_DTCSAEFMI.DFC_rbr_outK13Unintended_C DFES_DTCSAEFMI.DFC_rbr_outK14OC_C DFES_DTCSAEFMI.DFC_rbr_outK14Unintended_C DFES_DTCSAEFMI.DFC_rbr_outK15OC_C DFES_DTCSAEFMI.DFC_rbr_outK15Unintended_C DFES_DTCSAEFMI.DFC_rbr_outK16OC_C
      DFES_DTCSAEFMI.DFC_rbr_outK16Unintended_C DFES_DTCSAEFMI.DFC_rbr_outK17OC_C DFES_DTCSAEFMI.DFC_rbr_outK17Unintended_C DFES_DTCSAEFMI.DFC_rbr_outK29OC_C DFES_DTCSAEFMI.DFC_rbr_outK29Unintended_C DFES_DTCSAEFMI.DFC_rbr_outK51OC_C
      DFES_DTCSAEFMI.DFC_rbr_outK51Unintended_C DFES_DTCSAEFMI.DFC_rbr_outK73OC_C DFES_DTCSAEFMI.DFC_rbr_outK73Unintended_C DFES_DTCSAEFMI.DFC_rbr_outPo_C DFES_DTCSAEFMI.DFC_rbr_outPoCfg_C DFES_DTCSAEFMI.DFC_rbr_outPoCfgPeriod_C
      DFES_DTCSAEFMI.DFC_rbr_outPoCfgPwrLs_C DFES_DTCSAEFMI.DFC_rbr_outPoDisable_C DFES_DTCSAEFMI.DFC_rbr_outPoGetCurrent_C DFES_DTCSAEFMI.DFC_rbr_outPoGetStatus_C DFES_DTCSAEFMI.DFC_rbr_outPoResetError_C DFES_DTCSAEFMI.DFC_rbr_outPoc_C
      DFES_DTCSAEFMI.DFC_rbr_outPocCfg_C DFES_DTCSAEFMI.DFC_rbr_outPocCfgDither_C DFES_DTCSAEFMI.DFC_rbr_outPocCfgPI_C DFES_DTCSAEFMI.DFC_rbr_outPod_C DFES_DTCSAEFMI.DFC_rbr_outPodCfg_C DFES_DTCSAEFMI.DFC_rbr_outPodCfgPeriod_C
      DFES_DTCSAEFMI.DFC_rbr_rsmFfiApiCallErr_C DFES_DTCSAEFMI.DFC_rbr_safout_C DFES_DTCSAEFMI.DFC_rbr_safoutCfg_C DFES_DTCSAEFMI.DFC_rbr_safoutChnl1_C DFES_DTCSAEFMI.DFC_rbr_safoutChnl10_C DFES_DTCSAEFMI.DFC_rbr_safoutChnl10Dev_C
      DFES_DTCSAEFMI.DFC_rbr_safoutChnl10OR_C DFES_DTCSAEFMI.DFC_rbr_safoutChnl11_C DFES_DTCSAEFMI.DFC_rbr_safoutChnl11Dev_C DFES_DTCSAEFMI.DFC_rbr_safoutChnl11OR_C DFES_DTCSAEFMI.DFC_rbr_safoutChnl12_C DFES_DTCSAEFMI.DFC_rbr_safoutChnl12Dev_C
      DFES_DTCSAEFMI.DFC_rbr_safoutChnl12OR_C DFES_DTCSAEFMI.DFC_rbr_safoutChnl13_C DFES_DTCSAEFMI.DFC_rbr_safoutChnl13Dev_C DFES_DTCSAEFMI.DFC_rbr_safoutChnl13OR_C DFES_DTCSAEFMI.DFC_rbr_safoutChnl14_C DFES_DTCSAEFMI.DFC_rbr_safoutChnl14Dev_C
      DFES_DTCSAEFMI.DFC_rbr_safoutChnl14OR_C DFES_DTCSAEFMI.DFC_rbr_safoutChnl15_C DFES_DTCSAEFMI.DFC_rbr_safoutChnl15Dev_C DFES_DTCSAEFMI.DFC_rbr_safoutChnl15OR_C DFES_DTCSAEFMI.DFC_rbr_safoutChnl16_C DFES_DTCSAEFMI.DFC_rbr_safoutChnl16Dev_C
      DFES_DTCSAEFMI.DFC_rbr_safoutChnl16OR_C DFES_DTCSAEFMI.DFC_rbr_safoutChnl17_C DFES_DTCSAEFMI.DFC_rbr_safoutChnl17Dev_C DFES_DTCSAEFMI.DFC_rbr_safoutChnl17OR_C DFES_DTCSAEFMI.DFC_rbr_safoutChnl18_C DFES_DTCSAEFMI.DFC_rbr_safoutChnl18Dev_C
      DFES_DTCSAEFMI.DFC_rbr_safoutChnl18OR_C DFES_DTCSAEFMI.DFC_rbr_safoutChnl1Dev_C DFES_DTCSAEFMI.DFC_rbr_safoutChnl1OR_C DFES_DTCSAEFMI.DFC_rbr_safoutChnl2_C DFES_DTCSAEFMI.DFC_rbr_safoutChnl2Dev_C DFES_DTCSAEFMI.DFC_rbr_safoutChnl2OR_C
      DFES_DTCSAEFMI.DFC_rbr_safoutChnl3_C DFES_DTCSAEFMI.DFC_rbr_safoutChnl3Dev_C DFES_DTCSAEFMI.DFC_rbr_safoutChnl3OR_C DFES_DTCSAEFMI.DFC_rbr_safoutChnl4_C DFES_DTCSAEFMI.DFC_rbr_safoutChnl4Dev_C DFES_DTCSAEFMI.DFC_rbr_safoutChnl4OR_C
      DFES_DTCSAEFMI.DFC_rbr_safoutChnl5_C DFES_DTCSAEFMI.DFC_rbr_safoutChnl5Dev_C DFES_DTCSAEFMI.DFC_rbr_safoutChnl5OR_C DFES_DTCSAEFMI.DFC_rbr_safoutChnl6_C DFES_DTCSAEFMI.DFC_rbr_safoutChnl6Dev_C DFES_DTCSAEFMI.DFC_rbr_safoutChnl6OR_C
      DFES_DTCSAEFMI.DFC_rbr_safoutChnl7_C DFES_DTCSAEFMI.DFC_rbr_safoutChnl7Dev_C DFES_DTCSAEFMI.DFC_rbr_safoutChnl7OR_C DFES_DTCSAEFMI.DFC_rbr_safoutChnl8_C DFES_DTCSAEFMI.DFC_rbr_safoutChnl8Dev_C DFES_DTCSAEFMI.DFC_rbr_safoutChnl8OR_C
      DFES_DTCSAEFMI.DFC_rbr_safoutChnl9_C DFES_DTCSAEFMI.DFC_rbr_safoutChnl9Dev_C DFES_DTCSAEFMI.DFC_rbr_safoutChnl9OR_C DFES_DTCSAEFMI.DFC_rbr_safoutDevError_C DFES_DTCSAEFMI.DFC_rbr_safoutGetStatus_C DFES_DTCSAEFMI.DFC_rbr_safoutIgnoreError_C
      DFES_DTCSAEFMI.DFC_rbr_safoutResetError_C DFES_DTCSAEFMI.DFC_rbr_safoutUnlock_C DFES_DTCSAEFMI.DFC_rbr_safout_cfgDiag_C DFES_DTCSAEFMI.DFC_rbr_secAccessDenied_RC_C DFES_DTCSAEFMI.DFC_rbr_secAccessDenied_WDBI_C DFES_DTCSAEFMI.DFC_rbr_secEvalRespKey_C
      DFES_DTCSAEFMI.DFC_rbr_secFlashingFailure_C DFES_DTCSAEFMI.DFC_rbr_secGetLevel_C DFES_DTCSAEFMI.DFC_rbr_secGetRnd_C DFES_DTCSAEFMI.DFC_rbr_secGetSeed_C DFES_DTCSAEFMI.DFC_rbr_secInvalidPassword_C DFES_DTCSAEFMI.DFC_rbr_secIsRequestAllowed_C
      DFES_DTCSAEFMI.DFC_rbr_secResetLevel_C DFES_DTCSAEFMI.DFC_rbr_secSaveSecret_C DFES_DTCSAEFMI.DFC_rbr_secSetLevel_C DFES_DTCSAEFMI.DFC_rbr_sysAit_C DFES_DTCSAEFMI.DFC_rbr_sysAiv_C DFES_DTCSAEFMI.DFC_rbr_sysDi_C
      DFES_DTCSAEFMI.DFC_rbr_sysDo_C DFES_DTCSAEFMI.DFC_rbr_sysGetVss_C DFES_DTCSAEFMI.DFC_rbr_sysInit_C DFES_DTCSAEFMI.DFC_rbr_sysOperHrIntegrityErr_C DFES_DTCSAEFMI.DFC_rbr_sysOperHrsSaturated_C DFES_DTCSAEFMI.DFC_rbr_sysSetVss_C
      DFES_DTCSAEFMI.DFC_rbr_sys_coreload_C DFES_DTCSAEFMI.DFC_rbr_sys_taskload_C DFES_DTCSAEFMI.DFC_rbr_mo_OV_VSS1_C DFES_DTCSAEFMI.DFC_rbr_mo_OV_VSS2_C DFES_DTCSAEFMI.DFC_rbr_mo_UV_VSS1_C DFES_DTCSAEFMI.DFC_rbr_mo_UV_VSS2_C
      DFES_DTCSAEFMI.DFC_CANSM_E_BUS_OFF_NETWORK_0_C DFES_DTCSAEFMI.DFC_CANSM_E_BUS_OFF_NETWORK_1_C DFES_DTCSAEFMI.DFC_CANSM_E_BUS_OFF_NETWORK_2_C DFES_DTCSAEFMI.DFC_CANSM_E_BUS_OFF_NETWORK_3_C DFES_DTCSAEFMI.DFC_CANTRCV_E_NO_TRCV_CONTROL_0_C DFES_DTCSAEFMI.DFC_CAN_E_TIMEOUT_C
      DFES_DTCSAEFMI.DFC_COMM_E_NET_START_IND_CHANNEL_0_C DFES_DTCSAEFMI.DFC_COMM_E_NET_START_IND_CHANNEL_1_C DFES_DTCSAEFMI.DFC_COMM_E_NET_START_IND_CHANNEL_2_C DFES_DTCSAEFMI.DFC_COMM_E_NET_START_IND_CHANNEL_3_C DFES_DTCSAEFMI.DFC_COMM_E_NET_START_IND_CHANNEL_4_C DFES_DTCSAEFMI.DFC_COMM_E_NET_START_IND_CHANNEL_5_C
      DFES_DTCSAEFMI.DFC_LIN_E_TIMEOUT_C DFES_DTCSAEFMI.DFC_rba_MultiStackTrace_Threshold_C DFES_DTCSAEFMI.DFC_ETH_E_ACCESS_0_C DFES_DTCSAEFMI.DFC_RBA_IOEXTLIB_KEEPALIVE_DRV_C DFES_DTCSAEFMI.DFC_RBA_IOEXTLIB_KEEPALIVE_INI_C DFES_DTCSAEFMI.DFC_rba_MRly_Diag_Stk_Event_C
      DFES_DTCSAEFMI.DFC_rba_MemDiagExtd_MemReadSngErr_C DFES_DTCSAEFMI.DFC_rba_MemDiag_MemReadErr_C DFES_DTCSAEFMI.DFC_rba_MemDiag_MemWrErr_C DFES_DTCSAEFMI.DFC_rba_SyC_IrrSwOffTrigEngRun_Event_C DFES_DTCSAEFMI.DFC_rba_T15_Diag_ComInVld_Event_C DFES_DTCSAEFMI.DFC_rba_T15_Diag_ComOff_HwOn_Event_C
      DFES_DTCSAEFMI.DFC_rba_T15_Diag_ComOn_HwOff_Event_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM0_0_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM0_1_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM0_10_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM0_11_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM0_13_C
      DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM0_14_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM0_2_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM0_22_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM0_23_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM0_4_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM0_5_C
      DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM0_7_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM0_8_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM10_16_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM10_17_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM10_21_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM11_0_C
      DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM11_1_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM11_2_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM11_3_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM11_4_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM11_5_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM11_8_C
      DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM11_9_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM1_0_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM1_1_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM1_10_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM1_11_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM1_13_C
      DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM1_14_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM1_2_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM1_22_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM1_23_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM1_4_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM1_5_C
      DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM1_7_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM1_8_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM21_0_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM21_16_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM21_3_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM2_1_C
      DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM2_10_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM2_11_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM2_13_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM2_14_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM2_2_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM2_22_C
      DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM2_23_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM2_4_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM2_5_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM2_7_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM2_8_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM3_1_C
      DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM3_10_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM3_11_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM3_13_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM3_14_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM3_2_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM3_22_C
      DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM3_23_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM3_4_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM3_5_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM3_7_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM3_8_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM6_0_C
      DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM6_11_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM6_12_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM6_14_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM6_15_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM6_17_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM6_18_C
      DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM6_2_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM6_20_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM6_21_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM6_25_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM6_4_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM6_5_C
      DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM6_7_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM6_8_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM7_1_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM7_12_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM7_13_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM7_14_C
      DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM7_15_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM7_16_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM7_17_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM7_2_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM7_20_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM7_25_C
      DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM7_26_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM7_28_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM7_29_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM7_30_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM7_31_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM8_0_C
      DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM8_1_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM8_10_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM8_11_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM8_12_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM8_13_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM8_16_C
      DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM8_18_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM8_2_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM8_3_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM8_30_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM8_31_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM8_4_C
      DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM9_0_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM9_1_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM9_15_C DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM9_3_C DFES_DTCSAEFMI.DFC_MoCSOPICO_C DFES_DTCSAEFMI.DFC_MoFVarPostBldSel_C
      DFES_DTCSAEFMI.DFC_MoSysCtrlReIni_C DFES_DTCSAEFMI.DFC_MoXEMMHwLTMCUFW_C DFES_DTCSAEFMI.DFC_MoXEMMHwLTMonBIST_C DFES_DTCSAEFMI.DFC_MoXEMMHwLTRegMonTest_C DFES_DTCSAEFMI.DFC_MoXEMMHwLTStbySMUAlvTest_C DFES_DTCSAEFMI.DFC_MoXEMMHwLTTempSens_C
      DFES_DTCSAEFMI.DFC_MoXEMMHwLTUCBCfg_C DFES_DTCSAEFMI.DFC_OCWDAABEActv_C DFES_DTCSAEFMI.DFC_OCWDACom_C DFES_DTCSAEFMI.DFC_OCWDAErrPin_C DFES_DTCSAEFMI.DFC_SWReset_0_C DFES_DTCSAEFMI.DFC_SWReset_1_C
      DFES_DTCSAEFMI.DFC_SWReset_2_C DFES_DTCSAEFMI.DFC_bds_NoDebFault1_C DFES_Env.xSet1_CA DFES_Env.xSet2_CA DFES_Env.xSet3_CA DFES_Env.xSet4_CA
      DFES_Env.xSet5_CA DFES_EnvRef.DFC_Unused_C DFES_EnvRef.DFC_bds_TimeInRowDebFault_C DFES_EnvRef.DFC_bds_EventInRowDebFault_C DFES_EnvRef.DFC_DevLibBattUHi_C DFES_EnvRef.DFC_DevLibBattULo_C
      DFES_EnvRef.DFC_bds_TimeUpDownDebFault_C DFES_EnvRef.DFC_rbr_inA13OR_C DFES_EnvRef.DFC_rbr_inA13SCB_C DFES_EnvRef.DFC_rbr_inA13SCG_C DFES_EnvRef.DFC_rbr_inA14OR_C DFES_EnvRef.DFC_rbr_inA14SCB_C
      DFES_EnvRef.DFC_rbr_inA14SCG_C DFES_EnvRef.DFC_rbr_inA21OR_C DFES_EnvRef.DFC_rbr_inA21SCB_C DFES_EnvRef.DFC_rbr_inA21SCG_C DFES_EnvRef.DFC_rbr_inA22OR_C DFES_EnvRef.DFC_rbr_inA22SCB_C
      DFES_EnvRef.DFC_rbr_inA22SCG_C DFES_EnvRef.DFC_rbr_inA23OR_C DFES_EnvRef.DFC_rbr_inA23SCB_C DFES_EnvRef.DFC_rbr_inA23SCG_C DFES_EnvRef.DFC_rbr_inA24OR_C DFES_EnvRef.DFC_rbr_inA24SCB_C
      DFES_EnvRef.DFC_rbr_inA24SCG_C DFES_EnvRef.DFC_rbr_inA25OR_C DFES_EnvRef.DFC_rbr_inA25SCB_C DFES_EnvRef.DFC_rbr_inA25SCG_C DFES_EnvRef.DFC_rbr_inA26OR_C DFES_EnvRef.DFC_rbr_inA26SCB_C
      DFES_EnvRef.DFC_rbr_inA26SCG_C DFES_EnvRef.DFC_rbr_inA27OR_C DFES_EnvRef.DFC_rbr_inA27SCB_C DFES_EnvRef.DFC_rbr_inA27SCG_C DFES_EnvRef.DFC_rbr_inA28OR_C DFES_EnvRef.DFC_rbr_inA28SCB_C
      DFES_EnvRef.DFC_rbr_inA28SCG_C DFES_EnvRef.DFC_rbr_inA29OR_C DFES_EnvRef.DFC_rbr_inA29SCB_C DFES_EnvRef.DFC_rbr_inA29SCG_C DFES_EnvRef.DFC_rbr_inA36AicSCB_C DFES_EnvRef.DFC_rbr_inA36AicSCG_C
      DFES_EnvRef.DFC_rbr_inA36OR_C DFES_EnvRef.DFC_rbr_inA36SCB_C DFES_EnvRef.DFC_rbr_inA36SCG_C DFES_EnvRef.DFC_rbr_inA36ShuntSCB_C DFES_EnvRef.DFC_rbr_inA37AicSCB_C DFES_EnvRef.DFC_rbr_inA37AicSCG_C
      DFES_EnvRef.DFC_rbr_inA37OR_C DFES_EnvRef.DFC_rbr_inA37SCB_C DFES_EnvRef.DFC_rbr_inA37SCG_C DFES_EnvRef.DFC_rbr_inA37ShuntSCB_C DFES_EnvRef.DFC_rbr_inA38AicSCB_C DFES_EnvRef.DFC_rbr_inA38AicSCG_C
      DFES_EnvRef.DFC_rbr_inA38OR_C DFES_EnvRef.DFC_rbr_inA38SCB_C DFES_EnvRef.DFC_rbr_inA38SCG_C DFES_EnvRef.DFC_rbr_inA38ShuntSCB_C DFES_EnvRef.DFC_rbr_inA39AicSCB_C DFES_EnvRef.DFC_rbr_inA39AicSCG_C
      DFES_EnvRef.DFC_rbr_inA39OR_C DFES_EnvRef.DFC_rbr_inA39SCB_C DFES_EnvRef.DFC_rbr_inA39SCG_C DFES_EnvRef.DFC_rbr_inA39ShuntSCB_C DFES_EnvRef.DFC_rbr_inA40OR_C DFES_EnvRef.DFC_rbr_inA40SCB_C
      DFES_EnvRef.DFC_rbr_inA40SCG_C DFES_EnvRef.DFC_rbr_inA41OR_C DFES_EnvRef.DFC_rbr_inA41SCB_C DFES_EnvRef.DFC_rbr_inA41SCG_C DFES_EnvRef.DFC_rbr_inA42OR_C DFES_EnvRef.DFC_rbr_inA42SCB_C
      DFES_EnvRef.DFC_rbr_inA42SCG_C DFES_EnvRef.DFC_rbr_inA43AicSCB_C DFES_EnvRef.DFC_rbr_inA43AicSCG_C DFES_EnvRef.DFC_rbr_inA43OR_C DFES_EnvRef.DFC_rbr_inA43SCB_C DFES_EnvRef.DFC_rbr_inA43SCG_C
      DFES_EnvRef.DFC_rbr_inA43ShuntSCB_C DFES_EnvRef.DFC_rbr_inA44OL_C DFES_EnvRef.DFC_rbr_inA44SCB_C DFES_EnvRef.DFC_rbr_inA44SCG_C DFES_EnvRef.DFC_rbr_inA57OR_C DFES_EnvRef.DFC_rbr_inA57SCB_C
      DFES_EnvRef.DFC_rbr_inA57SCG_C DFES_EnvRef.DFC_rbr_inA59OL_C DFES_EnvRef.DFC_rbr_inA59SCB_C DFES_EnvRef.DFC_rbr_inA59SCG_C DFES_EnvRef.DFC_rbr_inK10OR_C DFES_EnvRef.DFC_rbr_inK10SCB_C
      DFES_EnvRef.DFC_rbr_inK10SCG_C DFES_EnvRef.DFC_rbr_inK11OR_C DFES_EnvRef.DFC_rbr_inK11SCB_C DFES_EnvRef.DFC_rbr_inK11SCG_C DFES_EnvRef.DFC_rbr_inK30AicSCB_C DFES_EnvRef.DFC_rbr_inK30AicSCG_C
      DFES_EnvRef.DFC_rbr_inK30OR_C DFES_EnvRef.DFC_rbr_inK30SCB_C DFES_EnvRef.DFC_rbr_inK30SCG_C DFES_EnvRef.DFC_rbr_inK30ShuntSCB_C DFES_EnvRef.DFC_rbr_inK31OR_C DFES_EnvRef.DFC_rbr_inK31SCB_C
      DFES_EnvRef.DFC_rbr_inK31SCG_C DFES_EnvRef.DFC_rbr_inK32OR_C DFES_EnvRef.DFC_rbr_inK32SCB_C DFES_EnvRef.DFC_rbr_inK32SCG_C DFES_EnvRef.DFC_rbr_inK33OR_C DFES_EnvRef.DFC_rbr_inK33SCB_C
      DFES_EnvRef.DFC_rbr_inK33SCG_C DFES_EnvRef.DFC_rbr_inK34OR_C DFES_EnvRef.DFC_rbr_inK34SCB_C DFES_EnvRef.DFC_rbr_inK34SCG_C DFES_EnvRef.DFC_rbr_inK35OR_C DFES_EnvRef.DFC_rbr_inK35SCB_C
      DFES_EnvRef.DFC_rbr_inK35SCG_C DFES_EnvRef.DFC_rbr_inK36OR_C DFES_EnvRef.DFC_rbr_inK36SCB_C DFES_EnvRef.DFC_rbr_inK36SCG_C DFES_EnvRef.DFC_rbr_inK37AicSCB_C DFES_EnvRef.DFC_rbr_inK37AicSCG_C
      DFES_EnvRef.DFC_rbr_inK37OR_C DFES_EnvRef.DFC_rbr_inK37SCB_C DFES_EnvRef.DFC_rbr_inK37SCG_C DFES_EnvRef.DFC_rbr_inK37ShuntSCB_C DFES_EnvRef.DFC_rbr_inK38AicSCB_C DFES_EnvRef.DFC_rbr_inK38AicSCG_C
      DFES_EnvRef.DFC_rbr_inK38OR_C DFES_EnvRef.DFC_rbr_inK38SCB_C DFES_EnvRef.DFC_rbr_inK38SCG_C DFES_EnvRef.DFC_rbr_inK38ShuntSCB_C DFES_EnvRef.DFC_rbr_inK39AicSCB_C DFES_EnvRef.DFC_rbr_inK39AicSCG_C
      DFES_EnvRef.DFC_rbr_inK39OR_C DFES_EnvRef.DFC_rbr_inK39SCB_C DFES_EnvRef.DFC_rbr_inK39SCG_C DFES_EnvRef.DFC_rbr_inK39ShuntSCB_C DFES_EnvRef.DFC_rbr_inK40AicSCB_C DFES_EnvRef.DFC_rbr_inK40AicSCG_C
      DFES_EnvRef.DFC_rbr_inK40OR_C DFES_EnvRef.DFC_rbr_inK40SCB_C DFES_EnvRef.DFC_rbr_inK40SCG_C DFES_EnvRef.DFC_rbr_inK40ShuntSCB_C DFES_EnvRef.DFC_rbr_inK41AicSCB_C DFES_EnvRef.DFC_rbr_inK41AicSCG_C
      DFES_EnvRef.DFC_rbr_inK41OR_C DFES_EnvRef.DFC_rbr_inK41SCB_C DFES_EnvRef.DFC_rbr_inK41SCG_C DFES_EnvRef.DFC_rbr_inK41ShuntSCB_C DFES_EnvRef.DFC_rbr_inK42AicSCB_C DFES_EnvRef.DFC_rbr_inK42AicSCG_C
      DFES_EnvRef.DFC_rbr_inK42OR_C DFES_EnvRef.DFC_rbr_inK42SCB_C DFES_EnvRef.DFC_rbr_inK42SCG_C DFES_EnvRef.DFC_rbr_inK42ShuntSCB_C DFES_EnvRef.DFC_rbr_inK43OR_C DFES_EnvRef.DFC_rbr_inK43SCB_C
      DFES_EnvRef.DFC_rbr_inK43SCG_C DFES_EnvRef.DFC_rbr_inK44AicSCB_C DFES_EnvRef.DFC_rbr_inK44AicSCG_C DFES_EnvRef.DFC_rbr_inK44OR_C DFES_EnvRef.DFC_rbr_inK44SCB_C DFES_EnvRef.DFC_rbr_inK44SCG_C
      DFES_EnvRef.DFC_rbr_inK44ShuntSCB_C DFES_EnvRef.DFC_rbr_inK45AicSCB_C DFES_EnvRef.DFC_rbr_inK45AicSCG_C DFES_EnvRef.DFC_rbr_inK45OR_C DFES_EnvRef.DFC_rbr_inK45SCB_C DFES_EnvRef.DFC_rbr_inK45SCG_C
      DFES_EnvRef.DFC_rbr_inK45ShuntSCB_C DFES_EnvRef.DFC_rbr_inK52OR_C DFES_EnvRef.DFC_rbr_inK52SCB_C DFES_EnvRef.DFC_rbr_inK52SCG_C DFES_EnvRef.DFC_rbr_inK53OR_C DFES_EnvRef.DFC_rbr_inK53SCB_C
      DFES_EnvRef.DFC_rbr_inK53SCG_C DFES_EnvRef.DFC_rbr_inK54AicSCB_C DFES_EnvRef.DFC_rbr_inK54AicSCG_C DFES_EnvRef.DFC_rbr_inK54OR_C DFES_EnvRef.DFC_rbr_inK54SCB_C DFES_EnvRef.DFC_rbr_inK54SCG_C
      DFES_EnvRef.DFC_rbr_inK54ShuntSCB_C DFES_EnvRef.DFC_rbr_inK55AicSCB_C DFES_EnvRef.DFC_rbr_inK55AicSCG_C DFES_EnvRef.DFC_rbr_inK55OR_C DFES_EnvRef.DFC_rbr_inK55SCB_C DFES_EnvRef.DFC_rbr_inK55SCG_C
      DFES_EnvRef.DFC_rbr_inK55ShuntSCB_C DFES_EnvRef.DFC_rbr_inK56OR_C DFES_EnvRef.DFC_rbr_inK56SCB_C DFES_EnvRef.DFC_rbr_inK56SCG_C DFES_EnvRef.DFC_rbr_inK57OR_C DFES_EnvRef.DFC_rbr_inK57SCB_C
      DFES_EnvRef.DFC_rbr_inK57SCG_C DFES_EnvRef.DFC_rbr_inK58OR_C DFES_EnvRef.DFC_rbr_inK58SCB_C DFES_EnvRef.DFC_rbr_inK58SCG_C DFES_EnvRef.DFC_rbr_inK59OR_C DFES_EnvRef.DFC_rbr_inK59SCB_C
      DFES_EnvRef.DFC_rbr_inK59SCG_C DFES_EnvRef.DFC_rbr_inK60OR_C DFES_EnvRef.DFC_rbr_inK60SCB_C DFES_EnvRef.DFC_rbr_inK60SCG_C DFES_EnvRef.DFC_rbr_inK61AicSCB_C DFES_EnvRef.DFC_rbr_inK61AicSCG_C
      DFES_EnvRef.DFC_rbr_inK61OR_C DFES_EnvRef.DFC_rbr_inK61SCB_C DFES_EnvRef.DFC_rbr_inK61SCG_C DFES_EnvRef.DFC_rbr_inK61ShuntSCB_C DFES_EnvRef.DFC_rbr_inK62OR_C DFES_EnvRef.DFC_rbr_inK62SCB_C
      DFES_EnvRef.DFC_rbr_inK62SCG_C DFES_EnvRef.DFC_rbr_inK63AicSCB_C DFES_EnvRef.DFC_rbr_inK63AicSCG_C DFES_EnvRef.DFC_rbr_inK63OR_C DFES_EnvRef.DFC_rbr_inK63SCB_C DFES_EnvRef.DFC_rbr_inK63SCG_C
      DFES_EnvRef.DFC_rbr_inK63ShuntSCB_C DFES_EnvRef.DFC_rbr_inK64AicSCB_C DFES_EnvRef.DFC_rbr_inK64AicSCG_C DFES_EnvRef.DFC_rbr_inK64OR_C DFES_EnvRef.DFC_rbr_inK64SCB_C DFES_EnvRef.DFC_rbr_inK64SCG_C
      DFES_EnvRef.DFC_rbr_inK64ShuntSCB_C DFES_EnvRef.DFC_rbr_inK65AicSCB_C DFES_EnvRef.DFC_rbr_inK65AicSCG_C DFES_EnvRef.DFC_rbr_inK65OR_C DFES_EnvRef.DFC_rbr_inK65SCB_C DFES_EnvRef.DFC_rbr_inK65SCG_C
      DFES_EnvRef.DFC_rbr_inK65ShuntSCB_C DFES_EnvRef.DFC_rbr_inK74OR_C DFES_EnvRef.DFC_rbr_inK74SCB_C DFES_EnvRef.DFC_rbr_inK74SCG_C DFES_EnvRef.DFC_rbr_inK75OR_C DFES_EnvRef.DFC_rbr_inK75SCB_C
      DFES_EnvRef.DFC_rbr_inK75SCG_C DFES_EnvRef.DFC_rbr_inK76OR_C DFES_EnvRef.DFC_rbr_inK76SCB_C DFES_EnvRef.DFC_rbr_inK76SCG_C DFES_EnvRef.DFC_rbr_inK77OR_C DFES_EnvRef.DFC_rbr_inK77SCB_C
      DFES_EnvRef.DFC_rbr_inK77SCG_C DFES_EnvRef.DFC_rbr_inK78OR_C DFES_EnvRef.DFC_rbr_inK78SCB_C DFES_EnvRef.DFC_rbr_inK78SCG_C DFES_EnvRef.DFC_rbr_mo_DvUBAT_FWs_C DFES_EnvRef.DFC_rbr_mo_OVErr_VPR6_C
      DFES_EnvRef.DFC_rbr_mo_OVWarn_VPR6_C DFES_EnvRef.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3_C DFES_EnvRef.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2_C DFES_EnvRef.DFC_rbr_mo_OV_UBAT_MON_C DFES_EnvRef.DFC_rbr_mo_OV_UBRM24_FLEXIN_C DFES_EnvRef.DFC_rbr_mo_OV_UBRM24_LOADS_C
      DFES_EnvRef.DFC_rbr_mo_OV_UBRM24_MON_C DFES_EnvRef.DFC_rbr_mo_OV_VDD5_C DFES_EnvRef.DFC_rbr_mo_OV_VDD5_IN_C DFES_EnvRef.DFC_rbr_mo_OV_VPR6_C DFES_EnvRef.DFC_rbr_mo_OV_VSS3_C DFES_EnvRef.DFC_rbr_mo_OV_VSS4_C
      DFES_EnvRef.DFC_rbr_mo_Temp1_HTErr_C DFES_EnvRef.DFC_rbr_mo_Temp1_HTWarn_C DFES_EnvRef.DFC_rbr_mo_Temp2_HTErr_C DFES_EnvRef.DFC_rbr_mo_Temp2_HTWarn_C DFES_EnvRef.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3_C DFES_EnvRef.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2_C
      DFES_EnvRef.DFC_rbr_mo_UV_VDD5_C DFES_EnvRef.DFC_rbr_mo_UV_VDD5_IN_C DFES_EnvRef.DFC_rbr_mo_UV_VPR6_C DFES_EnvRef.DFC_rbr_mo_UV_VSS3_C DFES_EnvRef.DFC_rbr_mo_UV_VSS4_C DFES_EnvRef.DFC_rbr_outA01OL_C
      DFES_EnvRef.DFC_rbr_outA01OT_C DFES_EnvRef.DFC_rbr_outA01SCB_C DFES_EnvRef.DFC_rbr_outA01SCG_C DFES_EnvRef.DFC_rbr_outA02OL_C DFES_EnvRef.DFC_rbr_outA02OR_C DFES_EnvRef.DFC_rbr_outA02OT_C
      DFES_EnvRef.DFC_rbr_outA02SCB_C DFES_EnvRef.DFC_rbr_outA02SCG_C DFES_EnvRef.DFC_rbr_outA03OL_C DFES_EnvRef.DFC_rbr_outA03OT_C DFES_EnvRef.DFC_rbr_outA03SCB_C DFES_EnvRef.DFC_rbr_outA03SCG_C
      DFES_EnvRef.DFC_rbr_outA04OL_C DFES_EnvRef.DFC_rbr_outA04OT_C DFES_EnvRef.DFC_rbr_outA04SCB_C DFES_EnvRef.DFC_rbr_outA04SCG_C DFES_EnvRef.DFC_rbr_outA05OL_C DFES_EnvRef.DFC_rbr_outA05OR_C
      DFES_EnvRef.DFC_rbr_outA05OT_C DFES_EnvRef.DFC_rbr_outA05SCB_C DFES_EnvRef.DFC_rbr_outA05SCG_C DFES_EnvRef.DFC_rbr_outA06OL_C DFES_EnvRef.DFC_rbr_outA06OR_C DFES_EnvRef.DFC_rbr_outA06OT_C
      DFES_EnvRef.DFC_rbr_outA06SCB_C DFES_EnvRef.DFC_rbr_outA06SCG_C DFES_EnvRef.DFC_rbr_outA07OL_C DFES_EnvRef.DFC_rbr_outA07OT_C DFES_EnvRef.DFC_rbr_outA07SCB_C DFES_EnvRef.DFC_rbr_outA07SCG_C
      DFES_EnvRef.DFC_rbr_outA08OL_C DFES_EnvRef.DFC_rbr_outA08OT_C DFES_EnvRef.DFC_rbr_outA08SCB_C DFES_EnvRef.DFC_rbr_outA08SCG_C DFES_EnvRef.DFC_rbr_outA09OL_C DFES_EnvRef.DFC_rbr_outA09OR_C
      DFES_EnvRef.DFC_rbr_outA09OT_C DFES_EnvRef.DFC_rbr_outA09SCB_C DFES_EnvRef.DFC_rbr_outA09SCG_C DFES_EnvRef.DFC_rbr_outA10OL_C DFES_EnvRef.DFC_rbr_outA10OT_C DFES_EnvRef.DFC_rbr_outA10SCB_C
      DFES_EnvRef.DFC_rbr_outA10SCG_C DFES_EnvRef.DFC_rbr_outA11OL_C DFES_EnvRef.DFC_rbr_outA11OT_C DFES_EnvRef.DFC_rbr_outA11SCB_C DFES_EnvRef.DFC_rbr_outA11SCG_C DFES_EnvRef.DFC_rbr_outA12OR_C
      DFES_EnvRef.DFC_rbr_outA12SCB_C DFES_EnvRef.DFC_rbr_outA12SCG_C DFES_EnvRef.DFC_rbr_outA16OL_C DFES_EnvRef.DFC_rbr_outA16OT_C DFES_EnvRef.DFC_rbr_outA16SCB_C DFES_EnvRef.DFC_rbr_outA16SCG_C
      DFES_EnvRef.DFC_rbr_outA17OL_C DFES_EnvRef.DFC_rbr_outA17OR_C DFES_EnvRef.DFC_rbr_outA17OT_C DFES_EnvRef.DFC_rbr_outA17SCB_C DFES_EnvRef.DFC_rbr_outA17SCG_C DFES_EnvRef.DFC_rbr_outA18OL_C
      DFES_EnvRef.DFC_rbr_outA18OT_C DFES_EnvRef.DFC_rbr_outA18SCB_C DFES_EnvRef.DFC_rbr_outA18SCG_C DFES_EnvRef.DFC_rbr_outA19OL_C DFES_EnvRef.DFC_rbr_outA19OR_C DFES_EnvRef.DFC_rbr_outA19OT_C
      DFES_EnvRef.DFC_rbr_outA19SCB_C DFES_EnvRef.DFC_rbr_outA19SCG_C DFES_EnvRef.DFC_rbr_outA20OL_C DFES_EnvRef.DFC_rbr_outA20OR_C DFES_EnvRef.DFC_rbr_outA20OT_C DFES_EnvRef.DFC_rbr_outA20SCB_C
      DFES_EnvRef.DFC_rbr_outA20SCG_C DFES_EnvRef.DFC_rbr_outA31OL_C DFES_EnvRef.DFC_rbr_outA31OR_C DFES_EnvRef.DFC_rbr_outA31OT_C DFES_EnvRef.DFC_rbr_outA31SCB_C DFES_EnvRef.DFC_rbr_outA31SCG_C
      DFES_EnvRef.DFC_rbr_outA32OL_C DFES_EnvRef.DFC_rbr_outA32OR_C DFES_EnvRef.DFC_rbr_outA32OT_C DFES_EnvRef.DFC_rbr_outA32SCB_C DFES_EnvRef.DFC_rbr_outA32SCG_C DFES_EnvRef.DFC_rbr_outA33OL_C
      DFES_EnvRef.DFC_rbr_outA33OR_C DFES_EnvRef.DFC_rbr_outA33OT_C DFES_EnvRef.DFC_rbr_outA33SCB_C DFES_EnvRef.DFC_rbr_outA33SCG_C DFES_EnvRef.DFC_rbr_outA34OL_C DFES_EnvRef.DFC_rbr_outA34OR_C
      DFES_EnvRef.DFC_rbr_outA34OT_C DFES_EnvRef.DFC_rbr_outA34SCB_C DFES_EnvRef.DFC_rbr_outA34SCG_C DFES_EnvRef.DFC_rbr_outA35OL_C DFES_EnvRef.DFC_rbr_outA35OR_C DFES_EnvRef.DFC_rbr_outA35OT_C
      DFES_EnvRef.DFC_rbr_outA35SCB_C DFES_EnvRef.DFC_rbr_outA35SCG_C DFES_EnvRef.DFC_rbr_outA46OL_C DFES_EnvRef.DFC_rbr_outA46OR_C DFES_EnvRef.DFC_rbr_outA46OT_C DFES_EnvRef.DFC_rbr_outA46SCB_C
      DFES_EnvRef.DFC_rbr_outA46SCG_C DFES_EnvRef.DFC_rbr_outA47OL_C DFES_EnvRef.DFC_rbr_outA47OR_C DFES_EnvRef.DFC_rbr_outA47OT_C DFES_EnvRef.DFC_rbr_outA47SCB_C DFES_EnvRef.DFC_rbr_outA47SCG_C
      DFES_EnvRef.DFC_rbr_outA48OL_C DFES_EnvRef.DFC_rbr_outA48OR_C DFES_EnvRef.DFC_rbr_outA48OT_C DFES_EnvRef.DFC_rbr_outA48SCB_C DFES_EnvRef.DFC_rbr_outA48SCG_C DFES_EnvRef.DFC_rbr_outA49OL_C
      DFES_EnvRef.DFC_rbr_outA49OT_C DFES_EnvRef.DFC_rbr_outA49SCB_C DFES_EnvRef.DFC_rbr_outA49SCG_C DFES_EnvRef.DFC_rbr_outA50OL_C DFES_EnvRef.DFC_rbr_outA50OT_C DFES_EnvRef.DFC_rbr_outA50SCB_C
      DFES_EnvRef.DFC_rbr_outA50SCG_C DFES_EnvRef.DFC_rbr_outA51OL_C DFES_EnvRef.DFC_rbr_outA51OR_C DFES_EnvRef.DFC_rbr_outA51OT_C DFES_EnvRef.DFC_rbr_outA51SCB_C DFES_EnvRef.DFC_rbr_outA51SCG_C
      DFES_EnvRef.DFC_rbr_outA52OL_C DFES_EnvRef.DFC_rbr_outA52OR_C DFES_EnvRef.DFC_rbr_outA52OT_C DFES_EnvRef.DFC_rbr_outA52SCB_C DFES_EnvRef.DFC_rbr_outA52SCG_C DFES_EnvRef.DFC_rbr_outA53OL_C
      DFES_EnvRef.DFC_rbr_outA53OR_C DFES_EnvRef.DFC_rbr_outA53OT_C DFES_EnvRef.DFC_rbr_outA53SCB_C DFES_EnvRef.DFC_rbr_outA53SCG_C DFES_EnvRef.DFC_rbr_outA54OL_C DFES_EnvRef.DFC_rbr_outA54OR_C
      DFES_EnvRef.DFC_rbr_outA54OT_C DFES_EnvRef.DFC_rbr_outA54SCB_C DFES_EnvRef.DFC_rbr_outA54SCG_C DFES_EnvRef.DFC_rbr_outA55OL_C DFES_EnvRef.DFC_rbr_outA55OT_C DFES_EnvRef.DFC_rbr_outA55SCB_C
      DFES_EnvRef.DFC_rbr_outA55SCG_C DFES_EnvRef.DFC_rbr_outA56OL_C DFES_EnvRef.DFC_rbr_outA56OT_C DFES_EnvRef.DFC_rbr_outA56SCB_C DFES_EnvRef.DFC_rbr_outA56SCG_C DFES_EnvRef.DFC_rbr_outA58OL_C
      DFES_EnvRef.DFC_rbr_outA58OT_C DFES_EnvRef.DFC_rbr_outA58SCB_C DFES_EnvRef.DFC_rbr_outA58SCG_C DFES_EnvRef.DFC_rbr_outK07OL_C DFES_EnvRef.DFC_rbr_outK07OR_C DFES_EnvRef.DFC_rbr_outK07OT_C
      DFES_EnvRef.DFC_rbr_outK07SCB_C DFES_EnvRef.DFC_rbr_outK07SCG_C DFES_EnvRef.DFC_rbr_outK08OL_C DFES_EnvRef.DFC_rbr_outK08OR_C DFES_EnvRef.DFC_rbr_outK08OT_C DFES_EnvRef.DFC_rbr_outK08SCB_C
      DFES_EnvRef.DFC_rbr_outK08SCG_C DFES_EnvRef.DFC_rbr_outK09OL_C DFES_EnvRef.DFC_rbr_outK09OR_C DFES_EnvRef.DFC_rbr_outK09OT_C DFES_EnvRef.DFC_rbr_outK09SCB_C DFES_EnvRef.DFC_rbr_outK09SCG_C
      DFES_EnvRef.DFC_rbr_outK12OL_C DFES_EnvRef.DFC_rbr_outK12OT_C DFES_EnvRef.DFC_rbr_outK12SCB_C DFES_EnvRef.DFC_rbr_outK12SCG_C DFES_EnvRef.DFC_rbr_outK13OL_C DFES_EnvRef.DFC_rbr_outK13OT_C
      DFES_EnvRef.DFC_rbr_outK13SCB_C DFES_EnvRef.DFC_rbr_outK13SCG_C DFES_EnvRef.DFC_rbr_outK14OL_C DFES_EnvRef.DFC_rbr_outK14OR_C DFES_EnvRef.DFC_rbr_outK14OT_C DFES_EnvRef.DFC_rbr_outK14SCB_C
      DFES_EnvRef.DFC_rbr_outK14SCG_C DFES_EnvRef.DFC_rbr_outK15OL_C DFES_EnvRef.DFC_rbr_outK15OR_C DFES_EnvRef.DFC_rbr_outK15OT_C DFES_EnvRef.DFC_rbr_outK15SCB_C DFES_EnvRef.DFC_rbr_outK15SCG_C
      DFES_EnvRef.DFC_rbr_outK16OL_C DFES_EnvRef.DFC_rbr_outK16OR_C DFES_EnvRef.DFC_rbr_outK16OT_C DFES_EnvRef.DFC_rbr_outK16SCB_C DFES_EnvRef.DFC_rbr_outK16SCG_C DFES_EnvRef.DFC_rbr_outK17OL_C
      DFES_EnvRef.DFC_rbr_outK17OR_C DFES_EnvRef.DFC_rbr_outK17OT_C DFES_EnvRef.DFC_rbr_outK17SCB_C DFES_EnvRef.DFC_rbr_outK17SCG_C DFES_EnvRef.DFC_rbr_outK25OR_C DFES_EnvRef.DFC_rbr_outK25SCB_C
      DFES_EnvRef.DFC_rbr_outK25SCG_C DFES_EnvRef.DFC_rbr_outK29OL_C DFES_EnvRef.DFC_rbr_outK29OR_C DFES_EnvRef.DFC_rbr_outK29OT_C DFES_EnvRef.DFC_rbr_outK29SCB_C DFES_EnvRef.DFC_rbr_outK29SCG_C
      DFES_EnvRef.DFC_rbr_outK51OL_C DFES_EnvRef.DFC_rbr_outK51OT_C DFES_EnvRef.DFC_rbr_outK51SCB_C DFES_EnvRef.DFC_rbr_outK51SCG_C DFES_EnvRef.DFC_rbr_outK62OR_C DFES_EnvRef.DFC_rbr_outK62SCB_C
      DFES_EnvRef.DFC_rbr_outK62SCG_C DFES_EnvRef.DFC_rbr_outK73OL_C DFES_EnvRef.DFC_rbr_outK73OR_C DFES_EnvRef.DFC_rbr_outK73OT_C DFES_EnvRef.DFC_rbr_outK73SCB_C DFES_EnvRef.DFC_rbr_outK73SCG_C
      DFES_EnvRef.DFC_rbr_outK80OL_C DFES_EnvRef.DFC_rbr_outK80OT_C DFES_EnvRef.DFC_rbr_outK80SCB_C DFES_EnvRef.DFC_rbr_outK80SCG_C DFES_EnvRef.DFC_rbr_outK81OL_C DFES_EnvRef.DFC_rbr_outK81OT_C
      DFES_EnvRef.DFC_rbr_outK81SCB_C DFES_EnvRef.DFC_rbr_outK81SCG_C DFES_EnvRef.DFC_rbr_outK82OL_C DFES_EnvRef.DFC_rbr_outK82OT_C DFES_EnvRef.DFC_rbr_outK82SCB_C DFES_EnvRef.DFC_rbr_outK82SCG_C
      DFES_EnvRef.DFC_rbr_outK83OL_C DFES_EnvRef.DFC_rbr_outK83OT_C DFES_EnvRef.DFC_rbr_outK83SCB_C DFES_EnvRef.DFC_rbr_outK83SCG_C DFES_EnvRef.DFC_rbr_outK84OL_C DFES_EnvRef.DFC_rbr_outK84OT_C
      DFES_EnvRef.DFC_rbr_outK84SCB_C DFES_EnvRef.DFC_rbr_outK84SCG_C DFES_EnvRef.DFC_rbr_outK85OL_C DFES_EnvRef.DFC_rbr_outK85OT_C DFES_EnvRef.DFC_rbr_outK85SCB_C DFES_EnvRef.DFC_rbr_outK85SCG_C
      DFES_EnvRef.DFC_rbr_outK86OL_C DFES_EnvRef.DFC_rbr_outK86OT_C DFES_EnvRef.DFC_rbr_outK86SCB_C DFES_EnvRef.DFC_rbr_outK86SCG_C DFES_EnvRef.DFC_rbr_outK87OL_C DFES_EnvRef.DFC_rbr_outK87OT_C
      DFES_EnvRef.DFC_rbr_outK87SCB_C DFES_EnvRef.DFC_rbr_outK87SCG_C DFES_EnvRef.DFC_bds_EventUpDownDebFault_C DFES_EnvRef.DFC_DSMDummy_C DFES_EnvRef.DFC_rbr_canGetDataNoBuf_C DFES_EnvRef.DFC_rbr_canGetDataParam_C
      DFES_EnvRef.DFC_rbr_canGetDataboxNoInit_C DFES_EnvRef.DFC_rbr_canGetDataboxParam_C DFES_EnvRef.DFC_rbr_canGetRxBufStatusParam_C DFES_EnvRef.DFC_rbr_canGetStatusParam_C DFES_EnvRef.DFC_rbr_canGetTxBufStatusParam_C DFES_EnvRef.DFC_rbr_canInitParam_C
      DFES_EnvRef.DFC_rbr_canInitRxDataboxOverlap_C DFES_EnvRef.DFC_rbr_canInitRxDataboxParam_C DFES_EnvRef.DFC_rbr_canInitTxDataboxParam_C DFES_EnvRef.DFC_rbr_canIpduGroupControl_C DFES_EnvRef.DFC_rbr_canIsDataboxFreeNoInit_C DFES_EnvRef.DFC_rbr_canIsDataboxFreeParam_C
      DFES_EnvRef.DFC_rbr_canIsTxEmptyParam_C DFES_EnvRef.DFC_rbr_canRegBusOffCallbInvState_C DFES_EnvRef.DFC_rbr_canRegBusOffCallbParam_C DFES_EnvRef.DFC_rbr_canRegRxBufInvState_C DFES_EnvRef.DFC_rbr_canRegRxBufOverlap_C DFES_EnvRef.DFC_rbr_canRegRxBufParam_C
      DFES_EnvRef.DFC_rbr_canRegRxCallbInvState_C DFES_EnvRef.DFC_rbr_canRegRxCallbParam_C DFES_EnvRef.DFC_rbr_canRegRxDataboxInvNumb_C DFES_EnvRef.DFC_rbr_canRegRxDataboxInvState_C DFES_EnvRef.DFC_rbr_canRegRxDataboxOverlap_C DFES_EnvRef.DFC_rbr_canRegRxDataboxParam_C
      DFES_EnvRef.DFC_rbr_canRegTxBufInvState_C DFES_EnvRef.DFC_rbr_canRegTxBufOverlap_C DFES_EnvRef.DFC_rbr_canRegTxBufParam_C DFES_EnvRef.DFC_rbr_canRegTxDataboxInvNumb_C DFES_EnvRef.DFC_rbr_canRegTxDataboxInvState_C DFES_EnvRef.DFC_rbr_canRegTxDataboxOverlap_C
      DFES_EnvRef.DFC_rbr_canRegTxDataboxParam_C DFES_EnvRef.DFC_rbr_canResetTxBufParam_C DFES_EnvRef.DFC_rbr_canSendDataBufOvfl_C DFES_EnvRef.DFC_rbr_canSendDataParam_C DFES_EnvRef.DFC_rbr_canSendDataboxNoInit_C DFES_EnvRef.DFC_rbr_canSendDataboxParam_C
      DFES_EnvRef.DFC_rbr_canSetTxCycleParam_C DFES_EnvRef.DFC_rbr_canStartParam_C DFES_EnvRef.DFC_rbr_canStopParam_C DFES_EnvRef.DFC_rbr_can_ClearIpduGroup_C DFES_EnvRef.DFC_rbr_can_ReceiveSignal_C DFES_EnvRef.DFC_rbr_can_SendSignal_C
      DFES_EnvRef.DFC_rbr_can_SetIpduGroup_C DFES_EnvRef.DFC_rbr_dsmDTCJ1939_C DFES_EnvRef.DFC_rbr_dsmDelDTCJ1939_C DFES_EnvRef.DFC_rbr_dsmDelErrors_C DFES_EnvRef.DFC_rbr_dsmGetDFES_C DFES_EnvRef.DFC_rbr_dsmGetDTCJ1939_C
      DFES_EnvRef.DFC_rbr_dsmGetErrors_C DFES_EnvRef.DFC_rbr_dsmGetNumErrors_C DFES_EnvRef.DFC_rbr_dsmInitQueueOverflow_C DFES_EnvRef.DFC_rbr_dsmNumDTCJ1939_C DFES_EnvRef.DFC_rbr_dsmTesterror_C DFES_EnvRef.DFC_rbr_dsmUpdateDebError_C
      DFES_EnvRef.DFC_rbr_dsmUpdateError_C DFES_EnvRef.DFC_rbr_dsmgetDFCStatus_C DFES_EnvRef.DFC_rbr_dsmtestErrorDFC_C DFES_EnvRef.DFC_rbr_inAi_C DFES_EnvRef.DFC_rbr_inAic_C DFES_EnvRef.DFC_rbr_inAicCfg_C
      DFES_EnvRef.DFC_rbr_inAicGetStatus_C DFES_EnvRef.DFC_rbr_inAid_C DFES_EnvRef.DFC_rbr_inAidCfg_C DFES_EnvRef.DFC_rbr_inAiv_C DFES_EnvRef.DFC_rbr_inAivCfg_C DFES_EnvRef.DFC_rbr_inAivGetStatus_C
      DFES_EnvRef.DFC_rbr_inDi_C DFES_EnvRef.DFC_rbr_inFi_C DFES_EnvRef.DFC_rbr_inFiCfg_C DFES_EnvRef.DFC_rbr_inFiGetStatus_C DFES_EnvRef.DFC_rbr_inFi_Buffered_C DFES_EnvRef.DFC_rbr_inPhase_C
      DFES_EnvRef.DFC_rbr_inPhaseGetStatus_C DFES_EnvRef.DFC_rbr_inPhaseResetCounter_C DFES_EnvRef.DFC_rbr_inRi_C DFES_EnvRef.DFC_rbr_inRiCfg_C DFES_EnvRef.DFC_rbr_inRiCfgTemp_C DFES_EnvRef.DFC_rbr_inRiGetStatus_C
      DFES_EnvRef.DFC_rbr_inRiGetTemp_C DFES_EnvRef.DFC_rbr_inSentCopyFDFifo_C DFES_EnvRef.DFC_rbr_inSentDisable_C DFES_EnvRef.DFC_rbr_inSentEnable_C DFES_EnvRef.DFC_rbr_inSentGetErrorStatus_C DFES_EnvRef.DFC_rbr_inSentGetFD_C
      DFES_EnvRef.DFC_rbr_inSentGetSD_C DFES_EnvRef.DFC_rbr_inSentGetSDDatabox_C DFES_EnvRef.DFC_rbr_inSentGetStatus_C DFES_EnvRef.DFC_rbr_inSentInitSDDatabox_C DFES_EnvRef.DFC_rbr_inSentRegisterCopyFDFifo_C DFES_EnvRef.DFC_rbr_inSentRegisterFDFifo_C
      DFES_EnvRef.DFC_rbr_inSentRegisterSDDataboxes_C DFES_EnvRef.DFC_rbr_isobusCanRxBufferOverflow_C DFES_EnvRef.DFC_rbr_isobusGetCaAddrParam_C DFES_EnvRef.DFC_rbr_isobusGetDiagnosticParam_C DFES_EnvRef.DFC_rbr_isobusGetRxDataboxStatusParam_C DFES_EnvRef.DFC_rbr_isobusGetStatusParam_C
      DFES_EnvRef.DFC_rbr_isobusInitCommCaMissing_C DFES_EnvRef.DFC_rbr_isobusInitCommParam_C DFES_EnvRef.DFC_rbr_isobusInitCommState_C DFES_EnvRef.DFC_rbr_isobusInitDiagnosticParam_C DFES_EnvRef.DFC_rbr_isobusInitFailureListParam_C DFES_EnvRef.DFC_rbr_isobusInitRxDataboxParam_C
      DFES_EnvRef.DFC_rbr_isobusInitTxDataboxParam_C DFES_EnvRef.DFC_rbr_isobusRegRxDataboxOverlap_C DFES_EnvRef.DFC_rbr_isobusRegRxDataboxParam_C DFES_EnvRef.DFC_rbr_isobusRegRxDataboxState_C DFES_EnvRef.DFC_rbr_isobusRegTxDataboxOverlap_C DFES_EnvRef.DFC_rbr_isobusRegTxDataboxParam_C
      DFES_EnvRef.DFC_rbr_isobusRegTxDataboxState_C DFES_EnvRef.DFC_rbr_isobusRegisterErrClrCallbackParam_C DFES_EnvRef.DFC_rbr_isobusRegisterInstancesOverlap_C DFES_EnvRef.DFC_rbr_isobusRegisterInstancesParam_C DFES_EnvRef.DFC_rbr_isobusRegisterInstancesState_C DFES_EnvRef.DFC_rbr_isobusSendDataboxParam_C
      DFES_EnvRef.DFC_rbr_isobusSendRequestPGNParam_C DFES_EnvRef.DFC_rbr_isobusSetCaAddrCaUsed_C DFES_EnvRef.DFC_rbr_isobusSetCaAddrComm_C DFES_EnvRef.DFC_rbr_isobusSetCaAddrInvCan_C DFES_EnvRef.DFC_rbr_isobusSetCaAddrParam_C DFES_EnvRef.DFC_rbr_isobusSetCaInfoParam_C
      DFES_EnvRef.DFC_rbr_isobusSetCaNameParam_C DFES_EnvRef.DFC_rbr_isobusSftyCanTxErr_C DFES_EnvRef.DFC_rbr_lin_ReceiveSignal_C DFES_EnvRef.DFC_rbr_lin_SendSignal_C DFES_EnvRef.DFC_rbr_lin_getStatus_C DFES_EnvRef.DFC_rbr_lin_gotoSleep_C
      DFES_EnvRef.DFC_rbr_lin_scheduleRequest_C DFES_EnvRef.DFC_rbr_lin_wakeUp_C DFES_EnvRef.DFC_rbr_memFlsCfgShr_C DFES_EnvRef.DFC_rbr_memGetStatus_C DFES_EnvRef.DFC_rbr_memMarkBlock_C DFES_EnvRef.DFC_rbr_memReadApi1Error_C
      DFES_EnvRef.DFC_rbr_memReadApi2Error_C DFES_EnvRef.DFC_rbr_memReadBlock_C DFES_EnvRef.DFC_rbr_memReadCalibInputError_C DFES_EnvRef.DFC_rbr_memReadCalibOuputError_C DFES_EnvRef.DFC_rbr_memReadSystemError_C DFES_EnvRef.DFC_rbr_memWriteBlock_C
      DFES_EnvRef.DFC_rbr_moOV_FirstConstADC_C DFES_EnvRef.DFC_rbr_moOV_SecondConstADC_C DFES_EnvRef.DFC_rbr_moUV_FirstConstADC_C DFES_EnvRef.DFC_rbr_moUV_SecondConstADC_C DFES_EnvRef.DFC_rbr_mo_INH_C DFES_EnvRef.DFC_rbr_mo_INHLatch_C
      DFES_EnvRef.DFC_rbr_mo_adcPDD_fail_C DFES_EnvRef.DFC_rbr_mo_memoryProtection_err_C DFES_EnvRef.DFC_rbr_outA02OC_C DFES_EnvRef.DFC_rbr_outA02Unintended_C DFES_EnvRef.DFC_rbr_outA03OC_C DFES_EnvRef.DFC_rbr_outA03Unintended_C
      DFES_EnvRef.DFC_rbr_outA04OC_C DFES_EnvRef.DFC_rbr_outA04Unintended_C DFES_EnvRef.DFC_rbr_outA05OC_C DFES_EnvRef.DFC_rbr_outA05Unintended_C DFES_EnvRef.DFC_rbr_outA07OC_C DFES_EnvRef.DFC_rbr_outA07Unintended_C
      DFES_EnvRef.DFC_rbr_outA08OC_C DFES_EnvRef.DFC_rbr_outA08Unintended_C DFES_EnvRef.DFC_rbr_outA09OC_C DFES_EnvRef.DFC_rbr_outA09Unintended_C DFES_EnvRef.DFC_rbr_outA10OC_C DFES_EnvRef.DFC_rbr_outA10Unintended_C
      DFES_EnvRef.DFC_rbr_outA17OC_C DFES_EnvRef.DFC_rbr_outA17Unintended_C DFES_EnvRef.DFC_rbr_outA18OC_C DFES_EnvRef.DFC_rbr_outA18Unintended_C DFES_EnvRef.DFC_rbr_outA19OC_C DFES_EnvRef.DFC_rbr_outA19Unintended_C
      DFES_EnvRef.DFC_rbr_outA20OC_C DFES_EnvRef.DFC_rbr_outA20Unintended_C DFES_EnvRef.DFC_rbr_outA31OC_C DFES_EnvRef.DFC_rbr_outA31Unintended_C DFES_EnvRef.DFC_rbr_outA32OC_C DFES_EnvRef.DFC_rbr_outA32Unintended_C
      DFES_EnvRef.DFC_rbr_outA33OC_C DFES_EnvRef.DFC_rbr_outA33Unintended_C DFES_EnvRef.DFC_rbr_outA34OC_C DFES_EnvRef.DFC_rbr_outA34Unintended_C DFES_EnvRef.DFC_rbr_outA35OC_C DFES_EnvRef.DFC_rbr_outA35Unintended_C
      DFES_EnvRef.DFC_rbr_outA46OC_C DFES_EnvRef.DFC_rbr_outA46Unintended_C DFES_EnvRef.DFC_rbr_outA47OC_C DFES_EnvRef.DFC_rbr_outA47Unintended_C DFES_EnvRef.DFC_rbr_outA48OC_C DFES_EnvRef.DFC_rbr_outA48Unintended_C
      DFES_EnvRef.DFC_rbr_outA51OC_C DFES_EnvRef.DFC_rbr_outA51Unintended_C DFES_EnvRef.DFC_rbr_outA52OC_C DFES_EnvRef.DFC_rbr_outA52Unintended_C DFES_EnvRef.DFC_rbr_outA53OC_C DFES_EnvRef.DFC_rbr_outA53Unintended_C
      DFES_EnvRef.DFC_rbr_outA54OC_C DFES_EnvRef.DFC_rbr_outA54Unintended_C DFES_EnvRef.DFC_rbr_outAov_C DFES_EnvRef.DFC_rbr_outAovCfg_C DFES_EnvRef.DFC_rbr_outAovCfgPI_C DFES_EnvRef.DFC_rbr_outAovGetStatus_C
      DFES_EnvRef.DFC_rbr_outAovGetVoltage_C DFES_EnvRef.DFC_rbr_outAovResetError_C DFES_EnvRef.DFC_rbr_outDo_C DFES_EnvRef.DFC_rbr_outDoCfgPwrLs_C DFES_EnvRef.DFC_rbr_outDoDisable_C DFES_EnvRef.DFC_rbr_outDoGetCurrent_C
      DFES_EnvRef.DFC_rbr_outDoGetStatus_C DFES_EnvRef.DFC_rbr_outDoResetError_C DFES_EnvRef.DFC_rbr_outK07OC_C DFES_EnvRef.DFC_rbr_outK07Unintended_C DFES_EnvRef.DFC_rbr_outK08OC_C DFES_EnvRef.DFC_rbr_outK08Unintended_C
      DFES_EnvRef.DFC_rbr_outK09OC_C DFES_EnvRef.DFC_rbr_outK09Unintended_C DFES_EnvRef.DFC_rbr_outK12OC_C DFES_EnvRef.DFC_rbr_outK12Unintended_C DFES_EnvRef.DFC_rbr_outK13OC_C DFES_EnvRef.DFC_rbr_outK13Unintended_C
      DFES_EnvRef.DFC_rbr_outK14OC_C DFES_EnvRef.DFC_rbr_outK14Unintended_C DFES_EnvRef.DFC_rbr_outK15OC_C DFES_EnvRef.DFC_rbr_outK15Unintended_C DFES_EnvRef.DFC_rbr_outK16OC_C DFES_EnvRef.DFC_rbr_outK16Unintended_C
      DFES_EnvRef.DFC_rbr_outK17OC_C DFES_EnvRef.DFC_rbr_outK17Unintended_C DFES_EnvRef.DFC_rbr_outK29OC_C DFES_EnvRef.DFC_rbr_outK29Unintended_C DFES_EnvRef.DFC_rbr_outK51OC_C DFES_EnvRef.DFC_rbr_outK51Unintended_C
      DFES_EnvRef.DFC_rbr_outK73OC_C DFES_EnvRef.DFC_rbr_outK73Unintended_C DFES_EnvRef.DFC_rbr_outPo_C DFES_EnvRef.DFC_rbr_outPoCfg_C DFES_EnvRef.DFC_rbr_outPoCfgPeriod_C DFES_EnvRef.DFC_rbr_outPoCfgPwrLs_C
      DFES_EnvRef.DFC_rbr_outPoDisable_C DFES_EnvRef.DFC_rbr_outPoGetCurrent_C DFES_EnvRef.DFC_rbr_outPoGetStatus_C DFES_EnvRef.DFC_rbr_outPoResetError_C DFES_EnvRef.DFC_rbr_outPoc_C DFES_EnvRef.DFC_rbr_outPocCfg_C
      DFES_EnvRef.DFC_rbr_outPocCfgDither_C DFES_EnvRef.DFC_rbr_outPocCfgPI_C DFES_EnvRef.DFC_rbr_outPod_C DFES_EnvRef.DFC_rbr_outPodCfg_C DFES_EnvRef.DFC_rbr_outPodCfgPeriod_C DFES_EnvRef.DFC_rbr_rsmFfiApiCallErr_C
      DFES_EnvRef.DFC_rbr_safout_C DFES_EnvRef.DFC_rbr_safoutCfg_C DFES_EnvRef.DFC_rbr_safoutChnl1_C DFES_EnvRef.DFC_rbr_safoutChnl10_C DFES_EnvRef.DFC_rbr_safoutChnl10Dev_C DFES_EnvRef.DFC_rbr_safoutChnl10OR_C
      DFES_EnvRef.DFC_rbr_safoutChnl11_C DFES_EnvRef.DFC_rbr_safoutChnl11Dev_C DFES_EnvRef.DFC_rbr_safoutChnl11OR_C DFES_EnvRef.DFC_rbr_safoutChnl12_C DFES_EnvRef.DFC_rbr_safoutChnl12Dev_C DFES_EnvRef.DFC_rbr_safoutChnl12OR_C
      DFES_EnvRef.DFC_rbr_safoutChnl13_C DFES_EnvRef.DFC_rbr_safoutChnl13Dev_C DFES_EnvRef.DFC_rbr_safoutChnl13OR_C DFES_EnvRef.DFC_rbr_safoutChnl14_C DFES_EnvRef.DFC_rbr_safoutChnl14Dev_C DFES_EnvRef.DFC_rbr_safoutChnl14OR_C
      DFES_EnvRef.DFC_rbr_safoutChnl15_C DFES_EnvRef.DFC_rbr_safoutChnl15Dev_C DFES_EnvRef.DFC_rbr_safoutChnl15OR_C DFES_EnvRef.DFC_rbr_safoutChnl16_C DFES_EnvRef.DFC_rbr_safoutChnl16Dev_C DFES_EnvRef.DFC_rbr_safoutChnl16OR_C
      DFES_EnvRef.DFC_rbr_safoutChnl17_C DFES_EnvRef.DFC_rbr_safoutChnl17Dev_C DFES_EnvRef.DFC_rbr_safoutChnl17OR_C DFES_EnvRef.DFC_rbr_safoutChnl18_C DFES_EnvRef.DFC_rbr_safoutChnl18Dev_C DFES_EnvRef.DFC_rbr_safoutChnl18OR_C
      DFES_EnvRef.DFC_rbr_safoutChnl1Dev_C DFES_EnvRef.DFC_rbr_safoutChnl1OR_C DFES_EnvRef.DFC_rbr_safoutChnl2_C DFES_EnvRef.DFC_rbr_safoutChnl2Dev_C DFES_EnvRef.DFC_rbr_safoutChnl2OR_C DFES_EnvRef.DFC_rbr_safoutChnl3_C
      DFES_EnvRef.DFC_rbr_safoutChnl3Dev_C DFES_EnvRef.DFC_rbr_safoutChnl3OR_C DFES_EnvRef.DFC_rbr_safoutChnl4_C DFES_EnvRef.DFC_rbr_safoutChnl4Dev_C DFES_EnvRef.DFC_rbr_safoutChnl4OR_C DFES_EnvRef.DFC_rbr_safoutChnl5_C
      DFES_EnvRef.DFC_rbr_safoutChnl5Dev_C DFES_EnvRef.DFC_rbr_safoutChnl5OR_C DFES_EnvRef.DFC_rbr_safoutChnl6_C DFES_EnvRef.DFC_rbr_safoutChnl6Dev_C DFES_EnvRef.DFC_rbr_safoutChnl6OR_C DFES_EnvRef.DFC_rbr_safoutChnl7_C
      DFES_EnvRef.DFC_rbr_safoutChnl7Dev_C DFES_EnvRef.DFC_rbr_safoutChnl7OR_C DFES_EnvRef.DFC_rbr_safoutChnl8_C DFES_EnvRef.DFC_rbr_safoutChnl8Dev_C DFES_EnvRef.DFC_rbr_safoutChnl8OR_C DFES_EnvRef.DFC_rbr_safoutChnl9_C
      DFES_EnvRef.DFC_rbr_safoutChnl9Dev_C DFES_EnvRef.DFC_rbr_safoutChnl9OR_C DFES_EnvRef.DFC_rbr_safoutDevError_C DFES_EnvRef.DFC_rbr_safoutGetStatus_C DFES_EnvRef.DFC_rbr_safoutIgnoreError_C DFES_EnvRef.DFC_rbr_safoutResetError_C
      DFES_EnvRef.DFC_rbr_safoutUnlock_C DFES_EnvRef.DFC_rbr_safout_cfgDiag_C DFES_EnvRef.DFC_rbr_secAccessDenied_RC_C DFES_EnvRef.DFC_rbr_secAccessDenied_WDBI_C DFES_EnvRef.DFC_rbr_secEvalRespKey_C DFES_EnvRef.DFC_rbr_secFlashingFailure_C
      DFES_EnvRef.DFC_rbr_secGetLevel_C DFES_EnvRef.DFC_rbr_secGetRnd_C DFES_EnvRef.DFC_rbr_secGetSeed_C DFES_EnvRef.DFC_rbr_secInvalidPassword_C DFES_EnvRef.DFC_rbr_secIsRequestAllowed_C DFES_EnvRef.DFC_rbr_secResetLevel_C
      DFES_EnvRef.DFC_rbr_secSaveSecret_C DFES_EnvRef.DFC_rbr_secSetLevel_C DFES_EnvRef.DFC_rbr_sysAit_C DFES_EnvRef.DFC_rbr_sysAiv_C DFES_EnvRef.DFC_rbr_sysDi_C DFES_EnvRef.DFC_rbr_sysDo_C
      DFES_EnvRef.DFC_rbr_sysGetVss_C DFES_EnvRef.DFC_rbr_sysInit_C DFES_EnvRef.DFC_rbr_sysOperHrIntegrityErr_C DFES_EnvRef.DFC_rbr_sysOperHrsSaturated_C DFES_EnvRef.DFC_rbr_sysSetVss_C DFES_EnvRef.DFC_rbr_sys_coreload_C
      DFES_EnvRef.DFC_rbr_sys_taskload_C DFES_EnvRef.DFC_rbr_mo_OV_VSS1_C DFES_EnvRef.DFC_rbr_mo_OV_VSS2_C DFES_EnvRef.DFC_rbr_mo_UV_VSS1_C DFES_EnvRef.DFC_rbr_mo_UV_VSS2_C DFES_EnvRef.DFC_CANSM_E_BUS_OFF_NETWORK_0_C
      DFES_EnvRef.DFC_CANSM_E_BUS_OFF_NETWORK_1_C DFES_EnvRef.DFC_CANSM_E_BUS_OFF_NETWORK_2_C DFES_EnvRef.DFC_CANSM_E_BUS_OFF_NETWORK_3_C DFES_EnvRef.DFC_CANTRCV_E_NO_TRCV_CONTROL_0_C DFES_EnvRef.DFC_CAN_E_TIMEOUT_C DFES_EnvRef.DFC_COMM_E_NET_START_IND_CHANNEL_0_C
      DFES_EnvRef.DFC_COMM_E_NET_START_IND_CHANNEL_1_C DFES_EnvRef.DFC_COMM_E_NET_START_IND_CHANNEL_2_C DFES_EnvRef.DFC_COMM_E_NET_START_IND_CHANNEL_3_C DFES_EnvRef.DFC_COMM_E_NET_START_IND_CHANNEL_4_C DFES_EnvRef.DFC_COMM_E_NET_START_IND_CHANNEL_5_C DFES_EnvRef.DFC_LIN_E_TIMEOUT_C
      DFES_EnvRef.DFC_rba_MultiStackTrace_Threshold_C DFES_EnvRef.DFC_ETH_E_ACCESS_0_C DFES_EnvRef.DFC_RBA_IOEXTLIB_KEEPALIVE_DRV_C DFES_EnvRef.DFC_RBA_IOEXTLIB_KEEPALIVE_INI_C DFES_EnvRef.DFC_rba_MRly_Diag_Stk_Event_C DFES_EnvRef.DFC_rba_MemDiagExtd_MemReadSngErr_C
      DFES_EnvRef.DFC_rba_MemDiag_MemReadErr_C DFES_EnvRef.DFC_rba_MemDiag_MemWrErr_C DFES_EnvRef.DFC_rba_SyC_IrrSwOffTrigEngRun_Event_C DFES_EnvRef.DFC_rba_T15_Diag_ComInVld_Event_C DFES_EnvRef.DFC_rba_T15_Diag_ComOff_HwOn_Event_C DFES_EnvRef.DFC_rba_T15_Diag_ComOn_HwOff_Event_C
      DFES_EnvRef.DFC_MOXEMM_SMU_ALM0_0_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM0_1_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM0_10_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM0_11_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM0_13_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM0_14_C
      DFES_EnvRef.DFC_MOXEMM_SMU_ALM0_2_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM0_22_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM0_23_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM0_4_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM0_5_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM0_7_C
      DFES_EnvRef.DFC_MOXEMM_SMU_ALM0_8_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM10_16_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM10_17_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM10_21_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM11_0_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM11_1_C
      DFES_EnvRef.DFC_MOXEMM_SMU_ALM11_2_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM11_3_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM11_4_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM11_5_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM11_8_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM11_9_C
      DFES_EnvRef.DFC_MOXEMM_SMU_ALM1_0_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM1_1_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM1_10_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM1_11_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM1_13_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM1_14_C
      DFES_EnvRef.DFC_MOXEMM_SMU_ALM1_2_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM1_22_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM1_23_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM1_4_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM1_5_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM1_7_C
      DFES_EnvRef.DFC_MOXEMM_SMU_ALM1_8_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM21_0_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM21_16_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM21_3_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM2_1_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM2_10_C
      DFES_EnvRef.DFC_MOXEMM_SMU_ALM2_11_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM2_13_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM2_14_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM2_2_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM2_22_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM2_23_C
      DFES_EnvRef.DFC_MOXEMM_SMU_ALM2_4_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM2_5_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM2_7_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM2_8_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM3_1_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM3_10_C
      DFES_EnvRef.DFC_MOXEMM_SMU_ALM3_11_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM3_13_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM3_14_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM3_2_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM3_22_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM3_23_C
      DFES_EnvRef.DFC_MOXEMM_SMU_ALM3_4_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM3_5_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM3_7_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM3_8_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM6_0_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM6_11_C
      DFES_EnvRef.DFC_MOXEMM_SMU_ALM6_12_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM6_14_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM6_15_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM6_17_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM6_18_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM6_2_C
      DFES_EnvRef.DFC_MOXEMM_SMU_ALM6_20_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM6_21_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM6_25_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM6_4_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM6_5_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM6_7_C
      DFES_EnvRef.DFC_MOXEMM_SMU_ALM6_8_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM7_1_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM7_12_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM7_13_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM7_14_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM7_15_C
      DFES_EnvRef.DFC_MOXEMM_SMU_ALM7_16_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM7_17_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM7_2_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM7_20_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM7_25_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM7_26_C
      DFES_EnvRef.DFC_MOXEMM_SMU_ALM7_28_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM7_29_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM7_30_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM7_31_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM8_0_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM8_1_C
      DFES_EnvRef.DFC_MOXEMM_SMU_ALM8_10_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM8_11_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM8_12_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM8_13_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM8_16_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM8_18_C
      DFES_EnvRef.DFC_MOXEMM_SMU_ALM8_2_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM8_3_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM8_30_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM8_31_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM8_4_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM9_0_C
      DFES_EnvRef.DFC_MOXEMM_SMU_ALM9_1_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM9_15_C DFES_EnvRef.DFC_MOXEMM_SMU_ALM9_3_C DFES_EnvRef.DFC_MoCSOPICO_C DFES_EnvRef.DFC_MoFVarPostBldSel_C DFES_EnvRef.DFC_MoSysCtrlReIni_C
      DFES_EnvRef.DFC_MoXEMMHwLTMCUFW_C DFES_EnvRef.DFC_MoXEMMHwLTMonBIST_C DFES_EnvRef.DFC_MoXEMMHwLTRegMonTest_C DFES_EnvRef.DFC_MoXEMMHwLTStbySMUAlvTest_C DFES_EnvRef.DFC_MoXEMMHwLTTempSens_C DFES_EnvRef.DFC_MoXEMMHwLTUCBCfg_C
      DFES_EnvRef.DFC_OCWDAABEActv_C DFES_EnvRef.DFC_OCWDACom_C DFES_EnvRef.DFC_OCWDAErrPin_C DFES_EnvRef.DFC_SWReset_0_C DFES_EnvRef.DFC_SWReset_1_C DFES_EnvRef.DFC_SWReset_2_C
      DFES_EnvRef.DFC_bds_NoDebFault1_C DFES_FaultTyp.DFC_Unused_C DFES_FaultTyp.DFC_bds_TimeInRowDebFault_C DFES_FaultTyp.DFC_bds_EventInRowDebFault_C DFES_FaultTyp.DFC_DevLibBattUHi_C DFES_FaultTyp.DFC_DevLibBattULo_C
      DFES_FaultTyp.DFC_bds_TimeUpDownDebFault_C DFES_FaultTyp.DFC_rbr_inA13OR_C DFES_FaultTyp.DFC_rbr_inA13SCB_C DFES_FaultTyp.DFC_rbr_inA13SCG_C DFES_FaultTyp.DFC_rbr_inA14OR_C DFES_FaultTyp.DFC_rbr_inA14SCB_C
      DFES_FaultTyp.DFC_rbr_inA14SCG_C DFES_FaultTyp.DFC_rbr_inA21OR_C DFES_FaultTyp.DFC_rbr_inA21SCB_C DFES_FaultTyp.DFC_rbr_inA21SCG_C DFES_FaultTyp.DFC_rbr_inA22OR_C DFES_FaultTyp.DFC_rbr_inA22SCB_C
      DFES_FaultTyp.DFC_rbr_inA22SCG_C DFES_FaultTyp.DFC_rbr_inA23OR_C DFES_FaultTyp.DFC_rbr_inA23SCB_C DFES_FaultTyp.DFC_rbr_inA23SCG_C DFES_FaultTyp.DFC_rbr_inA24OR_C DFES_FaultTyp.DFC_rbr_inA24SCB_C
      DFES_FaultTyp.DFC_rbr_inA24SCG_C DFES_FaultTyp.DFC_rbr_inA25OR_C DFES_FaultTyp.DFC_rbr_inA25SCB_C DFES_FaultTyp.DFC_rbr_inA25SCG_C DFES_FaultTyp.DFC_rbr_inA26OR_C DFES_FaultTyp.DFC_rbr_inA26SCB_C
      DFES_FaultTyp.DFC_rbr_inA26SCG_C DFES_FaultTyp.DFC_rbr_inA27OR_C DFES_FaultTyp.DFC_rbr_inA27SCB_C DFES_FaultTyp.DFC_rbr_inA27SCG_C DFES_FaultTyp.DFC_rbr_inA28OR_C DFES_FaultTyp.DFC_rbr_inA28SCB_C
      DFES_FaultTyp.DFC_rbr_inA28SCG_C DFES_FaultTyp.DFC_rbr_inA29OR_C DFES_FaultTyp.DFC_rbr_inA29SCB_C DFES_FaultTyp.DFC_rbr_inA29SCG_C DFES_FaultTyp.DFC_rbr_inA36AicSCB_C DFES_FaultTyp.DFC_rbr_inA36AicSCG_C
      DFES_FaultTyp.DFC_rbr_inA36OR_C DFES_FaultTyp.DFC_rbr_inA36SCB_C DFES_FaultTyp.DFC_rbr_inA36SCG_C DFES_FaultTyp.DFC_rbr_inA36ShuntSCB_C DFES_FaultTyp.DFC_rbr_inA37AicSCB_C DFES_FaultTyp.DFC_rbr_inA37AicSCG_C
      DFES_FaultTyp.DFC_rbr_inA37OR_C DFES_FaultTyp.DFC_rbr_inA37SCB_C DFES_FaultTyp.DFC_rbr_inA37SCG_C DFES_FaultTyp.DFC_rbr_inA37ShuntSCB_C DFES_FaultTyp.DFC_rbr_inA38AicSCB_C DFES_FaultTyp.DFC_rbr_inA38AicSCG_C
      DFES_FaultTyp.DFC_rbr_inA38OR_C DFES_FaultTyp.DFC_rbr_inA38SCB_C DFES_FaultTyp.DFC_rbr_inA38SCG_C DFES_FaultTyp.DFC_rbr_inA38ShuntSCB_C DFES_FaultTyp.DFC_rbr_inA39AicSCB_C DFES_FaultTyp.DFC_rbr_inA39AicSCG_C
      DFES_FaultTyp.DFC_rbr_inA39OR_C DFES_FaultTyp.DFC_rbr_inA39SCB_C DFES_FaultTyp.DFC_rbr_inA39SCG_C DFES_FaultTyp.DFC_rbr_inA39ShuntSCB_C DFES_FaultTyp.DFC_rbr_inA40OR_C DFES_FaultTyp.DFC_rbr_inA40SCB_C
      DFES_FaultTyp.DFC_rbr_inA40SCG_C DFES_FaultTyp.DFC_rbr_inA41OR_C DFES_FaultTyp.DFC_rbr_inA41SCB_C DFES_FaultTyp.DFC_rbr_inA41SCG_C DFES_FaultTyp.DFC_rbr_inA42OR_C DFES_FaultTyp.DFC_rbr_inA42SCB_C
      DFES_FaultTyp.DFC_rbr_inA42SCG_C DFES_FaultTyp.DFC_rbr_inA43AicSCB_C DFES_FaultTyp.DFC_rbr_inA43AicSCG_C DFES_FaultTyp.DFC_rbr_inA43OR_C DFES_FaultTyp.DFC_rbr_inA43SCB_C DFES_FaultTyp.DFC_rbr_inA43SCG_C
      DFES_FaultTyp.DFC_rbr_inA43ShuntSCB_C DFES_FaultTyp.DFC_rbr_inA44OL_C DFES_FaultTyp.DFC_rbr_inA44SCB_C DFES_FaultTyp.DFC_rbr_inA44SCG_C DFES_FaultTyp.DFC_rbr_inA57OR_C DFES_FaultTyp.DFC_rbr_inA57SCB_C
      DFES_FaultTyp.DFC_rbr_inA57SCG_C DFES_FaultTyp.DFC_rbr_inA59OL_C DFES_FaultTyp.DFC_rbr_inA59SCB_C DFES_FaultTyp.DFC_rbr_inA59SCG_C DFES_FaultTyp.DFC_rbr_inK10OR_C DFES_FaultTyp.DFC_rbr_inK10SCB_C
      DFES_FaultTyp.DFC_rbr_inK10SCG_C DFES_FaultTyp.DFC_rbr_inK11OR_C DFES_FaultTyp.DFC_rbr_inK11SCB_C DFES_FaultTyp.DFC_rbr_inK11SCG_C DFES_FaultTyp.DFC_rbr_inK30AicSCB_C DFES_FaultTyp.DFC_rbr_inK30AicSCG_C
      DFES_FaultTyp.DFC_rbr_inK30OR_C DFES_FaultTyp.DFC_rbr_inK30SCB_C DFES_FaultTyp.DFC_rbr_inK30SCG_C DFES_FaultTyp.DFC_rbr_inK30ShuntSCB_C DFES_FaultTyp.DFC_rbr_inK31OR_C DFES_FaultTyp.DFC_rbr_inK31SCB_C
      DFES_FaultTyp.DFC_rbr_inK31SCG_C DFES_FaultTyp.DFC_rbr_inK32OR_C DFES_FaultTyp.DFC_rbr_inK32SCB_C DFES_FaultTyp.DFC_rbr_inK32SCG_C DFES_FaultTyp.DFC_rbr_inK33OR_C DFES_FaultTyp.DFC_rbr_inK33SCB_C
      DFES_FaultTyp.DFC_rbr_inK33SCG_C DFES_FaultTyp.DFC_rbr_inK34OR_C DFES_FaultTyp.DFC_rbr_inK34SCB_C DFES_FaultTyp.DFC_rbr_inK34SCG_C DFES_FaultTyp.DFC_rbr_inK35OR_C DFES_FaultTyp.DFC_rbr_inK35SCB_C
      DFES_FaultTyp.DFC_rbr_inK35SCG_C DFES_FaultTyp.DFC_rbr_inK36OR_C DFES_FaultTyp.DFC_rbr_inK36SCB_C DFES_FaultTyp.DFC_rbr_inK36SCG_C DFES_FaultTyp.DFC_rbr_inK37AicSCB_C DFES_FaultTyp.DFC_rbr_inK37AicSCG_C
      DFES_FaultTyp.DFC_rbr_inK37OR_C DFES_FaultTyp.DFC_rbr_inK37SCB_C DFES_FaultTyp.DFC_rbr_inK37SCG_C DFES_FaultTyp.DFC_rbr_inK37ShuntSCB_C DFES_FaultTyp.DFC_rbr_inK38AicSCB_C DFES_FaultTyp.DFC_rbr_inK38AicSCG_C
      DFES_FaultTyp.DFC_rbr_inK38OR_C DFES_FaultTyp.DFC_rbr_inK38SCB_C DFES_FaultTyp.DFC_rbr_inK38SCG_C DFES_FaultTyp.DFC_rbr_inK38ShuntSCB_C DFES_FaultTyp.DFC_rbr_inK39AicSCB_C DFES_FaultTyp.DFC_rbr_inK39AicSCG_C
      DFES_FaultTyp.DFC_rbr_inK39OR_C DFES_FaultTyp.DFC_rbr_inK39SCB_C DFES_FaultTyp.DFC_rbr_inK39SCG_C DFES_FaultTyp.DFC_rbr_inK39ShuntSCB_C DFES_FaultTyp.DFC_rbr_inK40AicSCB_C DFES_FaultTyp.DFC_rbr_inK40AicSCG_C
      DFES_FaultTyp.DFC_rbr_inK40OR_C DFES_FaultTyp.DFC_rbr_inK40SCB_C DFES_FaultTyp.DFC_rbr_inK40SCG_C DFES_FaultTyp.DFC_rbr_inK40ShuntSCB_C DFES_FaultTyp.DFC_rbr_inK41AicSCB_C DFES_FaultTyp.DFC_rbr_inK41AicSCG_C
      DFES_FaultTyp.DFC_rbr_inK41OR_C DFES_FaultTyp.DFC_rbr_inK41SCB_C DFES_FaultTyp.DFC_rbr_inK41SCG_C DFES_FaultTyp.DFC_rbr_inK41ShuntSCB_C DFES_FaultTyp.DFC_rbr_inK42AicSCB_C DFES_FaultTyp.DFC_rbr_inK42AicSCG_C
      DFES_FaultTyp.DFC_rbr_inK42OR_C DFES_FaultTyp.DFC_rbr_inK42SCB_C DFES_FaultTyp.DFC_rbr_inK42SCG_C DFES_FaultTyp.DFC_rbr_inK42ShuntSCB_C DFES_FaultTyp.DFC_rbr_inK43OR_C DFES_FaultTyp.DFC_rbr_inK43SCB_C
      DFES_FaultTyp.DFC_rbr_inK43SCG_C DFES_FaultTyp.DFC_rbr_inK44AicSCB_C DFES_FaultTyp.DFC_rbr_inK44AicSCG_C DFES_FaultTyp.DFC_rbr_inK44OR_C DFES_FaultTyp.DFC_rbr_inK44SCB_C DFES_FaultTyp.DFC_rbr_inK44SCG_C
      DFES_FaultTyp.DFC_rbr_inK44ShuntSCB_C DFES_FaultTyp.DFC_rbr_inK45AicSCB_C DFES_FaultTyp.DFC_rbr_inK45AicSCG_C DFES_FaultTyp.DFC_rbr_inK45OR_C DFES_FaultTyp.DFC_rbr_inK45SCB_C DFES_FaultTyp.DFC_rbr_inK45SCG_C
      DFES_FaultTyp.DFC_rbr_inK45ShuntSCB_C DFES_FaultTyp.DFC_rbr_inK52OR_C DFES_FaultTyp.DFC_rbr_inK52SCB_C DFES_FaultTyp.DFC_rbr_inK52SCG_C DFES_FaultTyp.DFC_rbr_inK53OR_C DFES_FaultTyp.DFC_rbr_inK53SCB_C
      DFES_FaultTyp.DFC_rbr_inK53SCG_C DFES_FaultTyp.DFC_rbr_inK54AicSCB_C DFES_FaultTyp.DFC_rbr_inK54AicSCG_C DFES_FaultTyp.DFC_rbr_inK54OR_C DFES_FaultTyp.DFC_rbr_inK54SCB_C DFES_FaultTyp.DFC_rbr_inK54SCG_C
      DFES_FaultTyp.DFC_rbr_inK54ShuntSCB_C DFES_FaultTyp.DFC_rbr_inK55AicSCB_C DFES_FaultTyp.DFC_rbr_inK55AicSCG_C DFES_FaultTyp.DFC_rbr_inK55OR_C DFES_FaultTyp.DFC_rbr_inK55SCB_C DFES_FaultTyp.DFC_rbr_inK55SCG_C
      DFES_FaultTyp.DFC_rbr_inK55ShuntSCB_C DFES_FaultTyp.DFC_rbr_inK56OR_C DFES_FaultTyp.DFC_rbr_inK56SCB_C DFES_FaultTyp.DFC_rbr_inK56SCG_C DFES_FaultTyp.DFC_rbr_inK57OR_C DFES_FaultTyp.DFC_rbr_inK57SCB_C
      DFES_FaultTyp.DFC_rbr_inK57SCG_C DFES_FaultTyp.DFC_rbr_inK58OR_C DFES_FaultTyp.DFC_rbr_inK58SCB_C DFES_FaultTyp.DFC_rbr_inK58SCG_C DFES_FaultTyp.DFC_rbr_inK59OR_C DFES_FaultTyp.DFC_rbr_inK59SCB_C
      DFES_FaultTyp.DFC_rbr_inK59SCG_C DFES_FaultTyp.DFC_rbr_inK60OR_C DFES_FaultTyp.DFC_rbr_inK60SCB_C DFES_FaultTyp.DFC_rbr_inK60SCG_C DFES_FaultTyp.DFC_rbr_inK61AicSCB_C DFES_FaultTyp.DFC_rbr_inK61AicSCG_C
      DFES_FaultTyp.DFC_rbr_inK61OR_C DFES_FaultTyp.DFC_rbr_inK61SCB_C DFES_FaultTyp.DFC_rbr_inK61SCG_C DFES_FaultTyp.DFC_rbr_inK61ShuntSCB_C DFES_FaultTyp.DFC_rbr_inK62OR_C DFES_FaultTyp.DFC_rbr_inK62SCB_C
      DFES_FaultTyp.DFC_rbr_inK62SCG_C DFES_FaultTyp.DFC_rbr_inK63AicSCB_C DFES_FaultTyp.DFC_rbr_inK63AicSCG_C DFES_FaultTyp.DFC_rbr_inK63OR_C DFES_FaultTyp.DFC_rbr_inK63SCB_C DFES_FaultTyp.DFC_rbr_inK63SCG_C
      DFES_FaultTyp.DFC_rbr_inK63ShuntSCB_C DFES_FaultTyp.DFC_rbr_inK64AicSCB_C DFES_FaultTyp.DFC_rbr_inK64AicSCG_C DFES_FaultTyp.DFC_rbr_inK64OR_C DFES_FaultTyp.DFC_rbr_inK64SCB_C DFES_FaultTyp.DFC_rbr_inK64SCG_C
      DFES_FaultTyp.DFC_rbr_inK64ShuntSCB_C DFES_FaultTyp.DFC_rbr_inK65AicSCB_C DFES_FaultTyp.DFC_rbr_inK65AicSCG_C DFES_FaultTyp.DFC_rbr_inK65OR_C DFES_FaultTyp.DFC_rbr_inK65SCB_C DFES_FaultTyp.DFC_rbr_inK65SCG_C
      DFES_FaultTyp.DFC_rbr_inK65ShuntSCB_C DFES_FaultTyp.DFC_rbr_inK74OR_C DFES_FaultTyp.DFC_rbr_inK74SCB_C DFES_FaultTyp.DFC_rbr_inK74SCG_C DFES_FaultTyp.DFC_rbr_inK75OR_C DFES_FaultTyp.DFC_rbr_inK75SCB_C
      DFES_FaultTyp.DFC_rbr_inK75SCG_C DFES_FaultTyp.DFC_rbr_inK76OR_C DFES_FaultTyp.DFC_rbr_inK76SCB_C DFES_FaultTyp.DFC_rbr_inK76SCG_C DFES_FaultTyp.DFC_rbr_inK77OR_C DFES_FaultTyp.DFC_rbr_inK77SCB_C
      DFES_FaultTyp.DFC_rbr_inK77SCG_C DFES_FaultTyp.DFC_rbr_inK78OR_C DFES_FaultTyp.DFC_rbr_inK78SCB_C DFES_FaultTyp.DFC_rbr_inK78SCG_C DFES_FaultTyp.DFC_rbr_mo_DvUBAT_FWs_C DFES_FaultTyp.DFC_rbr_mo_OVErr_VPR6_C
      DFES_FaultTyp.DFC_rbr_mo_OVWarn_VPR6_C DFES_FaultTyp.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3_C DFES_FaultTyp.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2_C DFES_FaultTyp.DFC_rbr_mo_OV_UBAT_MON_C DFES_FaultTyp.DFC_rbr_mo_OV_UBRM24_FLEXIN_C DFES_FaultTyp.DFC_rbr_mo_OV_UBRM24_LOADS_C
      DFES_FaultTyp.DFC_rbr_mo_OV_UBRM24_MON_C DFES_FaultTyp.DFC_rbr_mo_OV_VDD5_C DFES_FaultTyp.DFC_rbr_mo_OV_VDD5_IN_C DFES_FaultTyp.DFC_rbr_mo_OV_VPR6_C DFES_FaultTyp.DFC_rbr_mo_OV_VSS3_C DFES_FaultTyp.DFC_rbr_mo_OV_VSS4_C
      DFES_FaultTyp.DFC_rbr_mo_Temp1_HTErr_C DFES_FaultTyp.DFC_rbr_mo_Temp1_HTWarn_C DFES_FaultTyp.DFC_rbr_mo_Temp2_HTErr_C DFES_FaultTyp.DFC_rbr_mo_Temp2_HTWarn_C DFES_FaultTyp.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3_C DFES_FaultTyp.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2_C
      DFES_FaultTyp.DFC_rbr_mo_UV_VDD5_C DFES_FaultTyp.DFC_rbr_mo_UV_VDD5_IN_C DFES_FaultTyp.DFC_rbr_mo_UV_VPR6_C DFES_FaultTyp.DFC_rbr_mo_UV_VSS3_C DFES_FaultTyp.DFC_rbr_mo_UV_VSS4_C DFES_FaultTyp.DFC_rbr_outA01OL_C
      DFES_FaultTyp.DFC_rbr_outA01OT_C DFES_FaultTyp.DFC_rbr_outA01SCB_C DFES_FaultTyp.DFC_rbr_outA01SCG_C DFES_FaultTyp.DFC_rbr_outA02OL_C DFES_FaultTyp.DFC_rbr_outA02OR_C DFES_FaultTyp.DFC_rbr_outA02OT_C
      DFES_FaultTyp.DFC_rbr_outA02SCB_C DFES_FaultTyp.DFC_rbr_outA02SCG_C DFES_FaultTyp.DFC_rbr_outA03OL_C DFES_FaultTyp.DFC_rbr_outA03OT_C DFES_FaultTyp.DFC_rbr_outA03SCB_C DFES_FaultTyp.DFC_rbr_outA03SCG_C
      DFES_FaultTyp.DFC_rbr_outA04OL_C DFES_FaultTyp.DFC_rbr_outA04OT_C DFES_FaultTyp.DFC_rbr_outA04SCB_C DFES_FaultTyp.DFC_rbr_outA04SCG_C DFES_FaultTyp.DFC_rbr_outA05OL_C DFES_FaultTyp.DFC_rbr_outA05OR_C
      DFES_FaultTyp.DFC_rbr_outA05OT_C DFES_FaultTyp.DFC_rbr_outA05SCB_C DFES_FaultTyp.DFC_rbr_outA05SCG_C DFES_FaultTyp.DFC_rbr_outA06OL_C DFES_FaultTyp.DFC_rbr_outA06OR_C DFES_FaultTyp.DFC_rbr_outA06OT_C
      DFES_FaultTyp.DFC_rbr_outA06SCB_C DFES_FaultTyp.DFC_rbr_outA06SCG_C DFES_FaultTyp.DFC_rbr_outA07OL_C DFES_FaultTyp.DFC_rbr_outA07OT_C DFES_FaultTyp.DFC_rbr_outA07SCB_C DFES_FaultTyp.DFC_rbr_outA07SCG_C
      DFES_FaultTyp.DFC_rbr_outA08OL_C DFES_FaultTyp.DFC_rbr_outA08OT_C DFES_FaultTyp.DFC_rbr_outA08SCB_C DFES_FaultTyp.DFC_rbr_outA08SCG_C DFES_FaultTyp.DFC_rbr_outA09OL_C DFES_FaultTyp.DFC_rbr_outA09OR_C
      DFES_FaultTyp.DFC_rbr_outA09OT_C DFES_FaultTyp.DFC_rbr_outA09SCB_C DFES_FaultTyp.DFC_rbr_outA09SCG_C DFES_FaultTyp.DFC_rbr_outA10OL_C DFES_FaultTyp.DFC_rbr_outA10OT_C DFES_FaultTyp.DFC_rbr_outA10SCB_C
      DFES_FaultTyp.DFC_rbr_outA10SCG_C DFES_FaultTyp.DFC_rbr_outA11OL_C DFES_FaultTyp.DFC_rbr_outA11OT_C DFES_FaultTyp.DFC_rbr_outA11SCB_C DFES_FaultTyp.DFC_rbr_outA11SCG_C DFES_FaultTyp.DFC_rbr_outA12OR_C
      DFES_FaultTyp.DFC_rbr_outA12SCB_C DFES_FaultTyp.DFC_rbr_outA12SCG_C DFES_FaultTyp.DFC_rbr_outA16OL_C DFES_FaultTyp.DFC_rbr_outA16OT_C DFES_FaultTyp.DFC_rbr_outA16SCB_C DFES_FaultTyp.DFC_rbr_outA16SCG_C
      DFES_FaultTyp.DFC_rbr_outA17OL_C DFES_FaultTyp.DFC_rbr_outA17OR_C DFES_FaultTyp.DFC_rbr_outA17OT_C DFES_FaultTyp.DFC_rbr_outA17SCB_C DFES_FaultTyp.DFC_rbr_outA17SCG_C DFES_FaultTyp.DFC_rbr_outA18OL_C
      DFES_FaultTyp.DFC_rbr_outA18OT_C DFES_FaultTyp.DFC_rbr_outA18SCB_C DFES_FaultTyp.DFC_rbr_outA18SCG_C DFES_FaultTyp.DFC_rbr_outA19OL_C DFES_FaultTyp.DFC_rbr_outA19OR_C DFES_FaultTyp.DFC_rbr_outA19OT_C
      DFES_FaultTyp.DFC_rbr_outA19SCB_C DFES_FaultTyp.DFC_rbr_outA19SCG_C DFES_FaultTyp.DFC_rbr_outA20OL_C DFES_FaultTyp.DFC_rbr_outA20OR_C DFES_FaultTyp.DFC_rbr_outA20OT_C DFES_FaultTyp.DFC_rbr_outA20SCB_C
      DFES_FaultTyp.DFC_rbr_outA20SCG_C DFES_FaultTyp.DFC_rbr_outA31OL_C DFES_FaultTyp.DFC_rbr_outA31OR_C DFES_FaultTyp.DFC_rbr_outA31OT_C DFES_FaultTyp.DFC_rbr_outA31SCB_C DFES_FaultTyp.DFC_rbr_outA31SCG_C
      DFES_FaultTyp.DFC_rbr_outA32OL_C DFES_FaultTyp.DFC_rbr_outA32OR_C DFES_FaultTyp.DFC_rbr_outA32OT_C DFES_FaultTyp.DFC_rbr_outA32SCB_C DFES_FaultTyp.DFC_rbr_outA32SCG_C DFES_FaultTyp.DFC_rbr_outA33OL_C
      DFES_FaultTyp.DFC_rbr_outA33OR_C DFES_FaultTyp.DFC_rbr_outA33OT_C DFES_FaultTyp.DFC_rbr_outA33SCB_C DFES_FaultTyp.DFC_rbr_outA33SCG_C DFES_FaultTyp.DFC_rbr_outA34OL_C DFES_FaultTyp.DFC_rbr_outA34OR_C
      DFES_FaultTyp.DFC_rbr_outA34OT_C DFES_FaultTyp.DFC_rbr_outA34SCB_C DFES_FaultTyp.DFC_rbr_outA34SCG_C DFES_FaultTyp.DFC_rbr_outA35OL_C DFES_FaultTyp.DFC_rbr_outA35OR_C DFES_FaultTyp.DFC_rbr_outA35OT_C
      DFES_FaultTyp.DFC_rbr_outA35SCB_C DFES_FaultTyp.DFC_rbr_outA35SCG_C DFES_FaultTyp.DFC_rbr_outA46OL_C DFES_FaultTyp.DFC_rbr_outA46OR_C DFES_FaultTyp.DFC_rbr_outA46OT_C DFES_FaultTyp.DFC_rbr_outA46SCB_C
      DFES_FaultTyp.DFC_rbr_outA46SCG_C DFES_FaultTyp.DFC_rbr_outA47OL_C DFES_FaultTyp.DFC_rbr_outA47OR_C DFES_FaultTyp.DFC_rbr_outA47OT_C DFES_FaultTyp.DFC_rbr_outA47SCB_C DFES_FaultTyp.DFC_rbr_outA47SCG_C
      DFES_FaultTyp.DFC_rbr_outA48OL_C DFES_FaultTyp.DFC_rbr_outA48OR_C DFES_FaultTyp.DFC_rbr_outA48OT_C DFES_FaultTyp.DFC_rbr_outA48SCB_C DFES_FaultTyp.DFC_rbr_outA48SCG_C DFES_FaultTyp.DFC_rbr_outA49OL_C
      DFES_FaultTyp.DFC_rbr_outA49OT_C DFES_FaultTyp.DFC_rbr_outA49SCB_C DFES_FaultTyp.DFC_rbr_outA49SCG_C DFES_FaultTyp.DFC_rbr_outA50OL_C DFES_FaultTyp.DFC_rbr_outA50OT_C DFES_FaultTyp.DFC_rbr_outA50SCB_C
      DFES_FaultTyp.DFC_rbr_outA50SCG_C DFES_FaultTyp.DFC_rbr_outA51OL_C DFES_FaultTyp.DFC_rbr_outA51OR_C DFES_FaultTyp.DFC_rbr_outA51OT_C DFES_FaultTyp.DFC_rbr_outA51SCB_C DFES_FaultTyp.DFC_rbr_outA51SCG_C
      DFES_FaultTyp.DFC_rbr_outA52OL_C DFES_FaultTyp.DFC_rbr_outA52OR_C DFES_FaultTyp.DFC_rbr_outA52OT_C DFES_FaultTyp.DFC_rbr_outA52SCB_C DFES_FaultTyp.DFC_rbr_outA52SCG_C DFES_FaultTyp.DFC_rbr_outA53OL_C
      DFES_FaultTyp.DFC_rbr_outA53OR_C DFES_FaultTyp.DFC_rbr_outA53OT_C DFES_FaultTyp.DFC_rbr_outA53SCB_C DFES_FaultTyp.DFC_rbr_outA53SCG_C DFES_FaultTyp.DFC_rbr_outA54OL_C DFES_FaultTyp.DFC_rbr_outA54OR_C
      DFES_FaultTyp.DFC_rbr_outA54OT_C DFES_FaultTyp.DFC_rbr_outA54SCB_C DFES_FaultTyp.DFC_rbr_outA54SCG_C DFES_FaultTyp.DFC_rbr_outA55OL_C DFES_FaultTyp.DFC_rbr_outA55OT_C DFES_FaultTyp.DFC_rbr_outA55SCB_C
      DFES_FaultTyp.DFC_rbr_outA55SCG_C DFES_FaultTyp.DFC_rbr_outA56OL_C DFES_FaultTyp.DFC_rbr_outA56OT_C DFES_FaultTyp.DFC_rbr_outA56SCB_C DFES_FaultTyp.DFC_rbr_outA56SCG_C DFES_FaultTyp.DFC_rbr_outA58OL_C
      DFES_FaultTyp.DFC_rbr_outA58OT_C DFES_FaultTyp.DFC_rbr_outA58SCB_C DFES_FaultTyp.DFC_rbr_outA58SCG_C DFES_FaultTyp.DFC_rbr_outK07OL_C DFES_FaultTyp.DFC_rbr_outK07OR_C DFES_FaultTyp.DFC_rbr_outK07OT_C
      DFES_FaultTyp.DFC_rbr_outK07SCB_C DFES_FaultTyp.DFC_rbr_outK07SCG_C DFES_FaultTyp.DFC_rbr_outK08OL_C DFES_FaultTyp.DFC_rbr_outK08OR_C DFES_FaultTyp.DFC_rbr_outK08OT_C DFES_FaultTyp.DFC_rbr_outK08SCB_C
      DFES_FaultTyp.DFC_rbr_outK08SCG_C DFES_FaultTyp.DFC_rbr_outK09OL_C DFES_FaultTyp.DFC_rbr_outK09OR_C DFES_FaultTyp.DFC_rbr_outK09OT_C DFES_FaultTyp.DFC_rbr_outK09SCB_C DFES_FaultTyp.DFC_rbr_outK09SCG_C
      DFES_FaultTyp.DFC_rbr_outK12OL_C DFES_FaultTyp.DFC_rbr_outK12OT_C DFES_FaultTyp.DFC_rbr_outK12SCB_C DFES_FaultTyp.DFC_rbr_outK12SCG_C DFES_FaultTyp.DFC_rbr_outK13OL_C DFES_FaultTyp.DFC_rbr_outK13OT_C
      DFES_FaultTyp.DFC_rbr_outK13SCB_C DFES_FaultTyp.DFC_rbr_outK13SCG_C DFES_FaultTyp.DFC_rbr_outK14OL_C DFES_FaultTyp.DFC_rbr_outK14OR_C DFES_FaultTyp.DFC_rbr_outK14OT_C DFES_FaultTyp.DFC_rbr_outK14SCB_C
      DFES_FaultTyp.DFC_rbr_outK14SCG_C DFES_FaultTyp.DFC_rbr_outK15OL_C DFES_FaultTyp.DFC_rbr_outK15OR_C DFES_FaultTyp.DFC_rbr_outK15OT_C DFES_FaultTyp.DFC_rbr_outK15SCB_C DFES_FaultTyp.DFC_rbr_outK15SCG_C
      DFES_FaultTyp.DFC_rbr_outK16OL_C DFES_FaultTyp.DFC_rbr_outK16OR_C DFES_FaultTyp.DFC_rbr_outK16OT_C DFES_FaultTyp.DFC_rbr_outK16SCB_C DFES_FaultTyp.DFC_rbr_outK16SCG_C DFES_FaultTyp.DFC_rbr_outK17OL_C
      DFES_FaultTyp.DFC_rbr_outK17OR_C DFES_FaultTyp.DFC_rbr_outK17OT_C DFES_FaultTyp.DFC_rbr_outK17SCB_C DFES_FaultTyp.DFC_rbr_outK17SCG_C DFES_FaultTyp.DFC_rbr_outK25OR_C DFES_FaultTyp.DFC_rbr_outK25SCB_C
      DFES_FaultTyp.DFC_rbr_outK25SCG_C DFES_FaultTyp.DFC_rbr_outK29OL_C DFES_FaultTyp.DFC_rbr_outK29OR_C DFES_FaultTyp.DFC_rbr_outK29OT_C DFES_FaultTyp.DFC_rbr_outK29SCB_C DFES_FaultTyp.DFC_rbr_outK29SCG_C
      DFES_FaultTyp.DFC_rbr_outK51OL_C DFES_FaultTyp.DFC_rbr_outK51OT_C DFES_FaultTyp.DFC_rbr_outK51SCB_C DFES_FaultTyp.DFC_rbr_outK51SCG_C DFES_FaultTyp.DFC_rbr_outK62OR_C DFES_FaultTyp.DFC_rbr_outK62SCB_C
      DFES_FaultTyp.DFC_rbr_outK62SCG_C DFES_FaultTyp.DFC_rbr_outK73OL_C DFES_FaultTyp.DFC_rbr_outK73OR_C DFES_FaultTyp.DFC_rbr_outK73OT_C DFES_FaultTyp.DFC_rbr_outK73SCB_C DFES_FaultTyp.DFC_rbr_outK73SCG_C
      DFES_FaultTyp.DFC_rbr_outK80OL_C DFES_FaultTyp.DFC_rbr_outK80OT_C DFES_FaultTyp.DFC_rbr_outK80SCB_C DFES_FaultTyp.DFC_rbr_outK80SCG_C DFES_FaultTyp.DFC_rbr_outK81OL_C DFES_FaultTyp.DFC_rbr_outK81OT_C
      DFES_FaultTyp.DFC_rbr_outK81SCB_C DFES_FaultTyp.DFC_rbr_outK81SCG_C DFES_FaultTyp.DFC_rbr_outK82OL_C DFES_FaultTyp.DFC_rbr_outK82OT_C DFES_FaultTyp.DFC_rbr_outK82SCB_C DFES_FaultTyp.DFC_rbr_outK82SCG_C
      DFES_FaultTyp.DFC_rbr_outK83OL_C DFES_FaultTyp.DFC_rbr_outK83OT_C DFES_FaultTyp.DFC_rbr_outK83SCB_C DFES_FaultTyp.DFC_rbr_outK83SCG_C DFES_FaultTyp.DFC_rbr_outK84OL_C DFES_FaultTyp.DFC_rbr_outK84OT_C
      DFES_FaultTyp.DFC_rbr_outK84SCB_C DFES_FaultTyp.DFC_rbr_outK84SCG_C DFES_FaultTyp.DFC_rbr_outK85OL_C DFES_FaultTyp.DFC_rbr_outK85OT_C DFES_FaultTyp.DFC_rbr_outK85SCB_C DFES_FaultTyp.DFC_rbr_outK85SCG_C
      DFES_FaultTyp.DFC_rbr_outK86OL_C DFES_FaultTyp.DFC_rbr_outK86OT_C DFES_FaultTyp.DFC_rbr_outK86SCB_C DFES_FaultTyp.DFC_rbr_outK86SCG_C DFES_FaultTyp.DFC_rbr_outK87OL_C DFES_FaultTyp.DFC_rbr_outK87OT_C
      DFES_FaultTyp.DFC_rbr_outK87SCB_C DFES_FaultTyp.DFC_rbr_outK87SCG_C DFES_FaultTyp.DFC_bds_EventUpDownDebFault_C DFES_FaultTyp.DFC_DSMDummy_C DFES_FaultTyp.DFC_rbr_canGetDataNoBuf_C DFES_FaultTyp.DFC_rbr_canGetDataParam_C
      DFES_FaultTyp.DFC_rbr_canGetDataboxNoInit_C DFES_FaultTyp.DFC_rbr_canGetDataboxParam_C DFES_FaultTyp.DFC_rbr_canGetRxBufStatusParam_C DFES_FaultTyp.DFC_rbr_canGetStatusParam_C DFES_FaultTyp.DFC_rbr_canGetTxBufStatusParam_C DFES_FaultTyp.DFC_rbr_canInitParam_C
      DFES_FaultTyp.DFC_rbr_canInitRxDataboxOverlap_C DFES_FaultTyp.DFC_rbr_canInitRxDataboxParam_C DFES_FaultTyp.DFC_rbr_canInitTxDataboxParam_C DFES_FaultTyp.DFC_rbr_canIpduGroupControl_C DFES_FaultTyp.DFC_rbr_canIsDataboxFreeNoInit_C DFES_FaultTyp.DFC_rbr_canIsDataboxFreeParam_C
      DFES_FaultTyp.DFC_rbr_canIsTxEmptyParam_C DFES_FaultTyp.DFC_rbr_canRegBusOffCallbInvState_C DFES_FaultTyp.DFC_rbr_canRegBusOffCallbParam_C DFES_FaultTyp.DFC_rbr_canRegRxBufInvState_C DFES_FaultTyp.DFC_rbr_canRegRxBufOverlap_C DFES_FaultTyp.DFC_rbr_canRegRxBufParam_C
      DFES_FaultTyp.DFC_rbr_canRegRxCallbInvState_C DFES_FaultTyp.DFC_rbr_canRegRxCallbParam_C DFES_FaultTyp.DFC_rbr_canRegRxDataboxInvNumb_C DFES_FaultTyp.DFC_rbr_canRegRxDataboxInvState_C DFES_FaultTyp.DFC_rbr_canRegRxDataboxOverlap_C DFES_FaultTyp.DFC_rbr_canRegRxDataboxParam_C
      DFES_FaultTyp.DFC_rbr_canRegTxBufInvState_C DFES_FaultTyp.DFC_rbr_canRegTxBufOverlap_C DFES_FaultTyp.DFC_rbr_canRegTxBufParam_C DFES_FaultTyp.DFC_rbr_canRegTxDataboxInvNumb_C DFES_FaultTyp.DFC_rbr_canRegTxDataboxInvState_C DFES_FaultTyp.DFC_rbr_canRegTxDataboxOverlap_C
      DFES_FaultTyp.DFC_rbr_canRegTxDataboxParam_C DFES_FaultTyp.DFC_rbr_canResetTxBufParam_C DFES_FaultTyp.DFC_rbr_canSendDataBufOvfl_C DFES_FaultTyp.DFC_rbr_canSendDataParam_C DFES_FaultTyp.DFC_rbr_canSendDataboxNoInit_C DFES_FaultTyp.DFC_rbr_canSendDataboxParam_C
      DFES_FaultTyp.DFC_rbr_canSetTxCycleParam_C DFES_FaultTyp.DFC_rbr_canStartParam_C DFES_FaultTyp.DFC_rbr_canStopParam_C DFES_FaultTyp.DFC_rbr_can_ClearIpduGroup_C DFES_FaultTyp.DFC_rbr_can_ReceiveSignal_C DFES_FaultTyp.DFC_rbr_can_SendSignal_C
      DFES_FaultTyp.DFC_rbr_can_SetIpduGroup_C DFES_FaultTyp.DFC_rbr_dsmDTCJ1939_C DFES_FaultTyp.DFC_rbr_dsmDelDTCJ1939_C DFES_FaultTyp.DFC_rbr_dsmDelErrors_C DFES_FaultTyp.DFC_rbr_dsmGetDFES_C DFES_FaultTyp.DFC_rbr_dsmGetDTCJ1939_C
      DFES_FaultTyp.DFC_rbr_dsmGetErrors_C DFES_FaultTyp.DFC_rbr_dsmGetNumErrors_C DFES_FaultTyp.DFC_rbr_dsmInitQueueOverflow_C DFES_FaultTyp.DFC_rbr_dsmNumDTCJ1939_C DFES_FaultTyp.DFC_rbr_dsmTesterror_C DFES_FaultTyp.DFC_rbr_dsmUpdateDebError_C
      DFES_FaultTyp.DFC_rbr_dsmUpdateError_C DFES_FaultTyp.DFC_rbr_dsmgetDFCStatus_C DFES_FaultTyp.DFC_rbr_dsmtestErrorDFC_C DFES_FaultTyp.DFC_rbr_inAi_C DFES_FaultTyp.DFC_rbr_inAic_C DFES_FaultTyp.DFC_rbr_inAicCfg_C
      DFES_FaultTyp.DFC_rbr_inAicGetStatus_C DFES_FaultTyp.DFC_rbr_inAid_C DFES_FaultTyp.DFC_rbr_inAidCfg_C DFES_FaultTyp.DFC_rbr_inAiv_C DFES_FaultTyp.DFC_rbr_inAivCfg_C DFES_FaultTyp.DFC_rbr_inAivGetStatus_C
      DFES_FaultTyp.DFC_rbr_inDi_C DFES_FaultTyp.DFC_rbr_inFi_C DFES_FaultTyp.DFC_rbr_inFiCfg_C DFES_FaultTyp.DFC_rbr_inFiGetStatus_C DFES_FaultTyp.DFC_rbr_inFi_Buffered_C DFES_FaultTyp.DFC_rbr_inPhase_C
      DFES_FaultTyp.DFC_rbr_inPhaseGetStatus_C DFES_FaultTyp.DFC_rbr_inPhaseResetCounter_C DFES_FaultTyp.DFC_rbr_inRi_C DFES_FaultTyp.DFC_rbr_inRiCfg_C DFES_FaultTyp.DFC_rbr_inRiCfgTemp_C DFES_FaultTyp.DFC_rbr_inRiGetStatus_C
      DFES_FaultTyp.DFC_rbr_inRiGetTemp_C DFES_FaultTyp.DFC_rbr_inSentCopyFDFifo_C DFES_FaultTyp.DFC_rbr_inSentDisable_C DFES_FaultTyp.DFC_rbr_inSentEnable_C DFES_FaultTyp.DFC_rbr_inSentGetErrorStatus_C DFES_FaultTyp.DFC_rbr_inSentGetFD_C
      DFES_FaultTyp.DFC_rbr_inSentGetSD_C DFES_FaultTyp.DFC_rbr_inSentGetSDDatabox_C DFES_FaultTyp.DFC_rbr_inSentGetStatus_C DFES_FaultTyp.DFC_rbr_inSentInitSDDatabox_C DFES_FaultTyp.DFC_rbr_inSentRegisterCopyFDFifo_C DFES_FaultTyp.DFC_rbr_inSentRegisterFDFifo_C
      DFES_FaultTyp.DFC_rbr_inSentRegisterSDDataboxes_C DFES_FaultTyp.DFC_rbr_isobusCanRxBufferOverflow_C DFES_FaultTyp.DFC_rbr_isobusGetCaAddrParam_C DFES_FaultTyp.DFC_rbr_isobusGetDiagnosticParam_C DFES_FaultTyp.DFC_rbr_isobusGetRxDataboxStatusParam_C DFES_FaultTyp.DFC_rbr_isobusGetStatusParam_C
      DFES_FaultTyp.DFC_rbr_isobusInitCommCaMissing_C DFES_FaultTyp.DFC_rbr_isobusInitCommParam_C DFES_FaultTyp.DFC_rbr_isobusInitCommState_C DFES_FaultTyp.DFC_rbr_isobusInitDiagnosticParam_C DFES_FaultTyp.DFC_rbr_isobusInitFailureListParam_C DFES_FaultTyp.DFC_rbr_isobusInitRxDataboxParam_C
      DFES_FaultTyp.DFC_rbr_isobusInitTxDataboxParam_C DFES_FaultTyp.DFC_rbr_isobusRegRxDataboxOverlap_C DFES_FaultTyp.DFC_rbr_isobusRegRxDataboxParam_C DFES_FaultTyp.DFC_rbr_isobusRegRxDataboxState_C DFES_FaultTyp.DFC_rbr_isobusRegTxDataboxOverlap_C DFES_FaultTyp.DFC_rbr_isobusRegTxDataboxParam_C
      DFES_FaultTyp.DFC_rbr_isobusRegTxDataboxState_C DFES_FaultTyp.DFC_rbr_isobusRegisterErrClrCallbackParam_C DFES_FaultTyp.DFC_rbr_isobusRegisterInstancesOverlap_C DFES_FaultTyp.DFC_rbr_isobusRegisterInstancesParam_C DFES_FaultTyp.DFC_rbr_isobusRegisterInstancesState_C DFES_FaultTyp.DFC_rbr_isobusSendDataboxParam_C
      DFES_FaultTyp.DFC_rbr_isobusSendRequestPGNParam_C DFES_FaultTyp.DFC_rbr_isobusSetCaAddrCaUsed_C DFES_FaultTyp.DFC_rbr_isobusSetCaAddrComm_C DFES_FaultTyp.DFC_rbr_isobusSetCaAddrInvCan_C DFES_FaultTyp.DFC_rbr_isobusSetCaAddrParam_C DFES_FaultTyp.DFC_rbr_isobusSetCaInfoParam_C
      DFES_FaultTyp.DFC_rbr_isobusSetCaNameParam_C DFES_FaultTyp.DFC_rbr_isobusSftyCanTxErr_C DFES_FaultTyp.DFC_rbr_lin_ReceiveSignal_C DFES_FaultTyp.DFC_rbr_lin_SendSignal_C DFES_FaultTyp.DFC_rbr_lin_getStatus_C DFES_FaultTyp.DFC_rbr_lin_gotoSleep_C
      DFES_FaultTyp.DFC_rbr_lin_scheduleRequest_C DFES_FaultTyp.DFC_rbr_lin_wakeUp_C DFES_FaultTyp.DFC_rbr_memFlsCfgShr_C DFES_FaultTyp.DFC_rbr_memGetStatus_C DFES_FaultTyp.DFC_rbr_memMarkBlock_C DFES_FaultTyp.DFC_rbr_memReadApi1Error_C
      DFES_FaultTyp.DFC_rbr_memReadApi2Error_C DFES_FaultTyp.DFC_rbr_memReadBlock_C DFES_FaultTyp.DFC_rbr_memReadCalibInputError_C DFES_FaultTyp.DFC_rbr_memReadCalibOuputError_C DFES_FaultTyp.DFC_rbr_memReadSystemError_C DFES_FaultTyp.DFC_rbr_memWriteBlock_C
      DFES_FaultTyp.DFC_rbr_moOV_FirstConstADC_C DFES_FaultTyp.DFC_rbr_moOV_SecondConstADC_C DFES_FaultTyp.DFC_rbr_moUV_FirstConstADC_C DFES_FaultTyp.DFC_rbr_moUV_SecondConstADC_C DFES_FaultTyp.DFC_rbr_mo_INH_C DFES_FaultTyp.DFC_rbr_mo_INHLatch_C
      DFES_FaultTyp.DFC_rbr_mo_adcPDD_fail_C DFES_FaultTyp.DFC_rbr_mo_memoryProtection_err_C DFES_FaultTyp.DFC_rbr_outA02OC_C DFES_FaultTyp.DFC_rbr_outA02Unintended_C DFES_FaultTyp.DFC_rbr_outA03OC_C DFES_FaultTyp.DFC_rbr_outA03Unintended_C
      DFES_FaultTyp.DFC_rbr_outA04OC_C DFES_FaultTyp.DFC_rbr_outA04Unintended_C DFES_FaultTyp.DFC_rbr_outA05OC_C DFES_FaultTyp.DFC_rbr_outA05Unintended_C DFES_FaultTyp.DFC_rbr_outA07OC_C DFES_FaultTyp.DFC_rbr_outA07Unintended_C
      DFES_FaultTyp.DFC_rbr_outA08OC_C DFES_FaultTyp.DFC_rbr_outA08Unintended_C DFES_FaultTyp.DFC_rbr_outA09OC_C DFES_FaultTyp.DFC_rbr_outA09Unintended_C DFES_FaultTyp.DFC_rbr_outA10OC_C DFES_FaultTyp.DFC_rbr_outA10Unintended_C
      DFES_FaultTyp.DFC_rbr_outA17OC_C DFES_FaultTyp.DFC_rbr_outA17Unintended_C DFES_FaultTyp.DFC_rbr_outA18OC_C DFES_FaultTyp.DFC_rbr_outA18Unintended_C DFES_FaultTyp.DFC_rbr_outA19OC_C DFES_FaultTyp.DFC_rbr_outA19Unintended_C
      DFES_FaultTyp.DFC_rbr_outA20OC_C DFES_FaultTyp.DFC_rbr_outA20Unintended_C DFES_FaultTyp.DFC_rbr_outA31OC_C DFES_FaultTyp.DFC_rbr_outA31Unintended_C DFES_FaultTyp.DFC_rbr_outA32OC_C DFES_FaultTyp.DFC_rbr_outA32Unintended_C
      DFES_FaultTyp.DFC_rbr_outA33OC_C DFES_FaultTyp.DFC_rbr_outA33Unintended_C DFES_FaultTyp.DFC_rbr_outA34OC_C DFES_FaultTyp.DFC_rbr_outA34Unintended_C DFES_FaultTyp.DFC_rbr_outA35OC_C DFES_FaultTyp.DFC_rbr_outA35Unintended_C
      DFES_FaultTyp.DFC_rbr_outA46OC_C DFES_FaultTyp.DFC_rbr_outA46Unintended_C DFES_FaultTyp.DFC_rbr_outA47OC_C DFES_FaultTyp.DFC_rbr_outA47Unintended_C DFES_FaultTyp.DFC_rbr_outA48OC_C DFES_FaultTyp.DFC_rbr_outA48Unintended_C
      DFES_FaultTyp.DFC_rbr_outA51OC_C DFES_FaultTyp.DFC_rbr_outA51Unintended_C DFES_FaultTyp.DFC_rbr_outA52OC_C DFES_FaultTyp.DFC_rbr_outA52Unintended_C DFES_FaultTyp.DFC_rbr_outA53OC_C DFES_FaultTyp.DFC_rbr_outA53Unintended_C
      DFES_FaultTyp.DFC_rbr_outA54OC_C DFES_FaultTyp.DFC_rbr_outA54Unintended_C DFES_FaultTyp.DFC_rbr_outAov_C DFES_FaultTyp.DFC_rbr_outAovCfg_C DFES_FaultTyp.DFC_rbr_outAovCfgPI_C DFES_FaultTyp.DFC_rbr_outAovGetStatus_C
      DFES_FaultTyp.DFC_rbr_outAovGetVoltage_C DFES_FaultTyp.DFC_rbr_outAovResetError_C DFES_FaultTyp.DFC_rbr_outDo_C DFES_FaultTyp.DFC_rbr_outDoCfgPwrLs_C DFES_FaultTyp.DFC_rbr_outDoDisable_C DFES_FaultTyp.DFC_rbr_outDoGetCurrent_C
      DFES_FaultTyp.DFC_rbr_outDoGetStatus_C DFES_FaultTyp.DFC_rbr_outDoResetError_C DFES_FaultTyp.DFC_rbr_outK07OC_C DFES_FaultTyp.DFC_rbr_outK07Unintended_C DFES_FaultTyp.DFC_rbr_outK08OC_C DFES_FaultTyp.DFC_rbr_outK08Unintended_C
      DFES_FaultTyp.DFC_rbr_outK09OC_C DFES_FaultTyp.DFC_rbr_outK09Unintended_C DFES_FaultTyp.DFC_rbr_outK12OC_C DFES_FaultTyp.DFC_rbr_outK12Unintended_C DFES_FaultTyp.DFC_rbr_outK13OC_C DFES_FaultTyp.DFC_rbr_outK13Unintended_C
      DFES_FaultTyp.DFC_rbr_outK14OC_C DFES_FaultTyp.DFC_rbr_outK14Unintended_C DFES_FaultTyp.DFC_rbr_outK15OC_C DFES_FaultTyp.DFC_rbr_outK15Unintended_C DFES_FaultTyp.DFC_rbr_outK16OC_C DFES_FaultTyp.DFC_rbr_outK16Unintended_C
      DFES_FaultTyp.DFC_rbr_outK17OC_C DFES_FaultTyp.DFC_rbr_outK17Unintended_C DFES_FaultTyp.DFC_rbr_outK29OC_C DFES_FaultTyp.DFC_rbr_outK29Unintended_C DFES_FaultTyp.DFC_rbr_outK51OC_C DFES_FaultTyp.DFC_rbr_outK51Unintended_C
      DFES_FaultTyp.DFC_rbr_outK73OC_C DFES_FaultTyp.DFC_rbr_outK73Unintended_C DFES_FaultTyp.DFC_rbr_outPo_C DFES_FaultTyp.DFC_rbr_outPoCfg_C DFES_FaultTyp.DFC_rbr_outPoCfgPeriod_C DFES_FaultTyp.DFC_rbr_outPoCfgPwrLs_C
      DFES_FaultTyp.DFC_rbr_outPoDisable_C DFES_FaultTyp.DFC_rbr_outPoGetCurrent_C DFES_FaultTyp.DFC_rbr_outPoGetStatus_C DFES_FaultTyp.DFC_rbr_outPoResetError_C DFES_FaultTyp.DFC_rbr_outPoc_C DFES_FaultTyp.DFC_rbr_outPocCfg_C
      DFES_FaultTyp.DFC_rbr_outPocCfgDither_C DFES_FaultTyp.DFC_rbr_outPocCfgPI_C DFES_FaultTyp.DFC_rbr_outPod_C DFES_FaultTyp.DFC_rbr_outPodCfg_C DFES_FaultTyp.DFC_rbr_outPodCfgPeriod_C DFES_FaultTyp.DFC_rbr_rsmFfiApiCallErr_C
      DFES_FaultTyp.DFC_rbr_safout_C DFES_FaultTyp.DFC_rbr_safoutCfg_C DFES_FaultTyp.DFC_rbr_safoutChnl1_C DFES_FaultTyp.DFC_rbr_safoutChnl10_C DFES_FaultTyp.DFC_rbr_safoutChnl10Dev_C DFES_FaultTyp.DFC_rbr_safoutChnl10OR_C
      DFES_FaultTyp.DFC_rbr_safoutChnl11_C DFES_FaultTyp.DFC_rbr_safoutChnl11Dev_C DFES_FaultTyp.DFC_rbr_safoutChnl11OR_C DFES_FaultTyp.DFC_rbr_safoutChnl12_C DFES_FaultTyp.DFC_rbr_safoutChnl12Dev_C DFES_FaultTyp.DFC_rbr_safoutChnl12OR_C
      DFES_FaultTyp.DFC_rbr_safoutChnl13_C DFES_FaultTyp.DFC_rbr_safoutChnl13Dev_C DFES_FaultTyp.DFC_rbr_safoutChnl13OR_C DFES_FaultTyp.DFC_rbr_safoutChnl14_C DFES_FaultTyp.DFC_rbr_safoutChnl14Dev_C DFES_FaultTyp.DFC_rbr_safoutChnl14OR_C
      DFES_FaultTyp.DFC_rbr_safoutChnl15_C DFES_FaultTyp.DFC_rbr_safoutChnl15Dev_C DFES_FaultTyp.DFC_rbr_safoutChnl15OR_C DFES_FaultTyp.DFC_rbr_safoutChnl16_C DFES_FaultTyp.DFC_rbr_safoutChnl16Dev_C DFES_FaultTyp.DFC_rbr_safoutChnl16OR_C
      DFES_FaultTyp.DFC_rbr_safoutChnl17_C DFES_FaultTyp.DFC_rbr_safoutChnl17Dev_C DFES_FaultTyp.DFC_rbr_safoutChnl17OR_C DFES_FaultTyp.DFC_rbr_safoutChnl18_C DFES_FaultTyp.DFC_rbr_safoutChnl18Dev_C DFES_FaultTyp.DFC_rbr_safoutChnl18OR_C
      DFES_FaultTyp.DFC_rbr_safoutChnl1Dev_C DFES_FaultTyp.DFC_rbr_safoutChnl1OR_C DFES_FaultTyp.DFC_rbr_safoutChnl2_C DFES_FaultTyp.DFC_rbr_safoutChnl2Dev_C DFES_FaultTyp.DFC_rbr_safoutChnl2OR_C DFES_FaultTyp.DFC_rbr_safoutChnl3_C
      DFES_FaultTyp.DFC_rbr_safoutChnl3Dev_C DFES_FaultTyp.DFC_rbr_safoutChnl3OR_C DFES_FaultTyp.DFC_rbr_safoutChnl4_C DFES_FaultTyp.DFC_rbr_safoutChnl4Dev_C DFES_FaultTyp.DFC_rbr_safoutChnl4OR_C DFES_FaultTyp.DFC_rbr_safoutChnl5_C
      DFES_FaultTyp.DFC_rbr_safoutChnl5Dev_C DFES_FaultTyp.DFC_rbr_safoutChnl5OR_C DFES_FaultTyp.DFC_rbr_safoutChnl6_C DFES_FaultTyp.DFC_rbr_safoutChnl6Dev_C DFES_FaultTyp.DFC_rbr_safoutChnl6OR_C DFES_FaultTyp.DFC_rbr_safoutChnl7_C
      DFES_FaultTyp.DFC_rbr_safoutChnl7Dev_C DFES_FaultTyp.DFC_rbr_safoutChnl7OR_C DFES_FaultTyp.DFC_rbr_safoutChnl8_C DFES_FaultTyp.DFC_rbr_safoutChnl8Dev_C DFES_FaultTyp.DFC_rbr_safoutChnl8OR_C DFES_FaultTyp.DFC_rbr_safoutChnl9_C
      DFES_FaultTyp.DFC_rbr_safoutChnl9Dev_C DFES_FaultTyp.DFC_rbr_safoutChnl9OR_C DFES_FaultTyp.DFC_rbr_safoutDevError_C DFES_FaultTyp.DFC_rbr_safoutGetStatus_C DFES_FaultTyp.DFC_rbr_safoutIgnoreError_C DFES_FaultTyp.DFC_rbr_safoutResetError_C
      DFES_FaultTyp.DFC_rbr_safoutUnlock_C DFES_FaultTyp.DFC_rbr_safout_cfgDiag_C DFES_FaultTyp.DFC_rbr_secAccessDenied_RC_C DFES_FaultTyp.DFC_rbr_secAccessDenied_WDBI_C DFES_FaultTyp.DFC_rbr_secEvalRespKey_C DFES_FaultTyp.DFC_rbr_secFlashingFailure_C
      DFES_FaultTyp.DFC_rbr_secGetLevel_C DFES_FaultTyp.DFC_rbr_secGetRnd_C DFES_FaultTyp.DFC_rbr_secGetSeed_C DFES_FaultTyp.DFC_rbr_secInvalidPassword_C DFES_FaultTyp.DFC_rbr_secIsRequestAllowed_C DFES_FaultTyp.DFC_rbr_secResetLevel_C
      DFES_FaultTyp.DFC_rbr_secSaveSecret_C DFES_FaultTyp.DFC_rbr_secSetLevel_C DFES_FaultTyp.DFC_rbr_sysAit_C DFES_FaultTyp.DFC_rbr_sysAiv_C DFES_FaultTyp.DFC_rbr_sysDi_C DFES_FaultTyp.DFC_rbr_sysDo_C
      DFES_FaultTyp.DFC_rbr_sysGetVss_C DFES_FaultTyp.DFC_rbr_sysInit_C DFES_FaultTyp.DFC_rbr_sysOperHrIntegrityErr_C DFES_FaultTyp.DFC_rbr_sysOperHrsSaturated_C DFES_FaultTyp.DFC_rbr_sysSetVss_C DFES_FaultTyp.DFC_rbr_sys_coreload_C
      DFES_FaultTyp.DFC_rbr_sys_taskload_C DFES_FaultTyp.DFC_rbr_mo_OV_VSS1_C DFES_FaultTyp.DFC_rbr_mo_OV_VSS2_C DFES_FaultTyp.DFC_rbr_mo_UV_VSS1_C DFES_FaultTyp.DFC_rbr_mo_UV_VSS2_C DFES_FaultTyp.DFC_CANSM_E_BUS_OFF_NETWORK_0_C
      DFES_FaultTyp.DFC_CANSM_E_BUS_OFF_NETWORK_1_C DFES_FaultTyp.DFC_CANSM_E_BUS_OFF_NETWORK_2_C DFES_FaultTyp.DFC_CANSM_E_BUS_OFF_NETWORK_3_C DFES_FaultTyp.DFC_CANTRCV_E_NO_TRCV_CONTROL_0_C DFES_FaultTyp.DFC_CAN_E_TIMEOUT_C DFES_FaultTyp.DFC_COMM_E_NET_START_IND_CHANNEL_0_C
      DFES_FaultTyp.DFC_COMM_E_NET_START_IND_CHANNEL_1_C DFES_FaultTyp.DFC_COMM_E_NET_START_IND_CHANNEL_2_C DFES_FaultTyp.DFC_COMM_E_NET_START_IND_CHANNEL_3_C DFES_FaultTyp.DFC_COMM_E_NET_START_IND_CHANNEL_4_C DFES_FaultTyp.DFC_COMM_E_NET_START_IND_CHANNEL_5_C DFES_FaultTyp.DFC_LIN_E_TIMEOUT_C
      DFES_FaultTyp.DFC_rba_MultiStackTrace_Threshold_C DFES_FaultTyp.DFC_ETH_E_ACCESS_0_C DFES_FaultTyp.DFC_RBA_IOEXTLIB_KEEPALIVE_DRV_C DFES_FaultTyp.DFC_RBA_IOEXTLIB_KEEPALIVE_INI_C DFES_FaultTyp.DFC_rba_MRly_Diag_Stk_Event_C DFES_FaultTyp.DFC_rba_MemDiagExtd_MemReadSngErr_C
      DFES_FaultTyp.DFC_rba_MemDiag_MemReadErr_C DFES_FaultTyp.DFC_rba_MemDiag_MemWrErr_C DFES_FaultTyp.DFC_rba_SyC_IrrSwOffTrigEngRun_Event_C DFES_FaultTyp.DFC_rba_T15_Diag_ComInVld_Event_C DFES_FaultTyp.DFC_rba_T15_Diag_ComOff_HwOn_Event_C DFES_FaultTyp.DFC_rba_T15_Diag_ComOn_HwOff_Event_C
      DFES_FaultTyp.DFC_MOXEMM_SMU_ALM0_0_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM0_1_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM0_10_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM0_11_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM0_13_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM0_14_C
      DFES_FaultTyp.DFC_MOXEMM_SMU_ALM0_2_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM0_22_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM0_23_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM0_4_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM0_5_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM0_7_C
      DFES_FaultTyp.DFC_MOXEMM_SMU_ALM0_8_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM10_16_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM10_17_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM10_21_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM11_0_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM11_1_C
      DFES_FaultTyp.DFC_MOXEMM_SMU_ALM11_2_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM11_3_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM11_4_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM11_5_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM11_8_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM11_9_C
      DFES_FaultTyp.DFC_MOXEMM_SMU_ALM1_0_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM1_1_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM1_10_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM1_11_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM1_13_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM1_14_C
      DFES_FaultTyp.DFC_MOXEMM_SMU_ALM1_2_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM1_22_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM1_23_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM1_4_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM1_5_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM1_7_C
      DFES_FaultTyp.DFC_MOXEMM_SMU_ALM1_8_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM21_0_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM21_16_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM21_3_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM2_1_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM2_10_C
      DFES_FaultTyp.DFC_MOXEMM_SMU_ALM2_11_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM2_13_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM2_14_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM2_2_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM2_22_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM2_23_C
      DFES_FaultTyp.DFC_MOXEMM_SMU_ALM2_4_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM2_5_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM2_7_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM2_8_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM3_1_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM3_10_C
      DFES_FaultTyp.DFC_MOXEMM_SMU_ALM3_11_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM3_13_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM3_14_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM3_2_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM3_22_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM3_23_C
      DFES_FaultTyp.DFC_MOXEMM_SMU_ALM3_4_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM3_5_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM3_7_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM3_8_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM6_0_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM6_11_C
      DFES_FaultTyp.DFC_MOXEMM_SMU_ALM6_12_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM6_14_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM6_15_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM6_17_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM6_18_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM6_2_C
      DFES_FaultTyp.DFC_MOXEMM_SMU_ALM6_20_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM6_21_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM6_25_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM6_4_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM6_5_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM6_7_C
      DFES_FaultTyp.DFC_MOXEMM_SMU_ALM6_8_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM7_1_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM7_12_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM7_13_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM7_14_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM7_15_C
      DFES_FaultTyp.DFC_MOXEMM_SMU_ALM7_16_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM7_17_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM7_2_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM7_20_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM7_25_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM7_26_C
      DFES_FaultTyp.DFC_MOXEMM_SMU_ALM7_28_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM7_29_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM7_30_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM7_31_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM8_0_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM8_1_C
      DFES_FaultTyp.DFC_MOXEMM_SMU_ALM8_10_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM8_11_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM8_12_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM8_13_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM8_16_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM8_18_C
      DFES_FaultTyp.DFC_MOXEMM_SMU_ALM8_2_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM8_3_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM8_30_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM8_31_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM8_4_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM9_0_C
      DFES_FaultTyp.DFC_MOXEMM_SMU_ALM9_1_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM9_15_C DFES_FaultTyp.DFC_MOXEMM_SMU_ALM9_3_C DFES_FaultTyp.DFC_MoCSOPICO_C DFES_FaultTyp.DFC_MoFVarPostBldSel_C DFES_FaultTyp.DFC_MoSysCtrlReIni_C
      DFES_FaultTyp.DFC_MoXEMMHwLTMCUFW_C DFES_FaultTyp.DFC_MoXEMMHwLTMonBIST_C DFES_FaultTyp.DFC_MoXEMMHwLTRegMonTest_C DFES_FaultTyp.DFC_MoXEMMHwLTStbySMUAlvTest_C DFES_FaultTyp.DFC_MoXEMMHwLTTempSens_C DFES_FaultTyp.DFC_MoXEMMHwLTUCBCfg_C
      DFES_FaultTyp.DFC_OCWDAABEActv_C DFES_FaultTyp.DFC_OCWDACom_C DFES_FaultTyp.DFC_OCWDAErrPin_C DFES_FaultTyp.DFC_SWReset_0_C DFES_FaultTyp.DFC_SWReset_1_C DFES_FaultTyp.DFC_SWReset_2_C
      DFES_FaultTyp.DFC_bds_NoDebFault1_C DFES_MonEvtMSK0_C DFES_MonEvtMSK1_C DFES_MonRepeat_C DFES_numClsDlt_CA DFES_numClsFaultCycl_CA
      DFES_numClsHealCycl_CA DFES_numClsPndDlt_CA DFES_numClsSvcDlt_CA DFES_numClsSVSFaultCycl_CA DFES_numClsSVSHealCycl_CA DFES_numPDTC_C
      DFES_ThresSimCond.n_C DFES_ThresSimCond.r_C DFES_ThresSimCond.t_C DFES_tiDefCntr_C DFES_tiDelEngRun_C DFES_tiDelTstd_C
      DFES_xAsgnFrzFrDid_CA DFES_xClsDltTrg_CA DFES_xClsFaultTrg_CA DFES_xClsFltAWL_CA DFES_xClsFltMIL_CA DFES_xClsFltRSL_CA
      DFES_xClsFltSVS_CA DFES_xClsHealTrg_CA DFES_xClsPndDltTrg_CA DFES_xClsPrio_CA DFES_xClsSvcDltTrg_CA DFES_xClsSVSFaultTrg_CA
      DFES_xClsSVSHealTrg_CA DFES_xEnaHealPend_C DFES_xEnaHistoryPend_C DFES_xEnaTiDelWithFlt_C DFES_xSelDsplStgyMIL_C DFES_xSelDTCTyp_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      DSMAUX_stDCy DSM_TripChgAndClrFinshd
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      DFES_stEepWrReq DFES_stErrLamp DFES_stOutstate DFES_stPrgEvt_msg DSM_stProtdRamVld
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      DFES_ChkLstDltDemExCond_mp DFES_chkSt DFES_cnfSequence DFES_ctDef DFES_ctDel DFES_ctEntry
      DFES_ctFrq DFES_ctManuDef DFES_ctManuOk DFES_ctMIL DFES_ctOBD DFES_ctOBDPend
      DFES_ctOk DFES_ctPDTC DFES_ctSrv DFES_ctSrvDef DFES_entrySt DFES_entryStPdtcStrd
      DFES_EnvBlock DFES_FrzFrVal DFES_idxSequence DFES_ISOFrstCnfDFC DFES_ISOFrstFailDFC DFES_ISORcntCnfDFC
      DFES_ISORcntFailDFC DFES_lenLstAllwdDst_mp DFES_MonEvnt DFES_MonObjt DFES_MonParm DFES_MonPtr
      DFES_numDFC DFES_numDFCAck DFES_numDFCImdt DFES_numEntryAvl DFES_numEnvSize DFES_numExtdFrzFrmSize
      DFES_numFrzFrmSize DFES_OutLamps DFES_OutMILMod DFES_PDTCStore DFES_prioEntryImdt DFES_StateVisibility
      DFES_stChk DFES_stCounters DFES_stCtlSetting DFES_stDataImdt DFES_stDataImdtTrans DFES_stDTCRecUpdt
      DFES_stDTCStorage DFES_stEntry DFES_stErrDia DFES_stInh DFES_stMILDsplStgy DFES_stMILMod
      DFES_stOrdImdt DFES_stPrgEvt DFES_stRepClrAftPwrFail DFES_SvsLampIllumn DFES_tiDefCntr DFES_xAsgnEnvAllDataSize
    /end LOC_MEASUREMENT
    FUNCTION_VERSION "30017.46.0_RC40_LARGE"

/end FUNCTION

/begin FUNCTION

    DFP
    "30000.5.0 Diagnostic Fault Path"

    FUNCTION_VERSION "30000.5.0"

/end FUNCTION

/begin FUNCTION

    DfpCl
    "1.1.0     support of DFP handling"

    FUNCTION_VERSION "1.1.0"

/end FUNCTION

/begin FUNCTION

    DiaActr_ElecHBrdgDiag
    "1.9.0     Diagnostic service for electrical error detection on H-Bridge power stage outputs"

    /begin DEF_CHARACTERISTIC
      DiaActr_ElecHBrdgDiag_DbgSigId_C DiaActr_ElecHBrdgDiag_DbgSigType_C DiaActr_ElecHBrdgDiag_OlEnaSwtOff_C
    /end DEF_CHARACTERISTIC
    /begin LOC_MEASUREMENT
      DiaActr_ElecHBrdgDiag_HBrDiagInfo_mp DiaActr_ElecHBrdgDiag_HlfBrDiagInfo_mp DiaActr_ElecHBrdgDiag_nrDiagErr_mp DiaActr_ElecHBrdgDiag_OLSigErrInfo_mp DiaActr_ElecHBrdgDiag_ReasOLAbort_mp DiaActr_ElecHBrdgDiag_SigErrInfo_mp
      DiaActr_ElecHBrdgDiag_stAddOLDiag_mp DiaActr_ElecHBrdgDiag_stDiagCtrl_mp DiaActr_ElecHBrdgDiag_stDiagDi_mp DiaActr_ElecHBrdgDiag_stOLAbortReq_mp DiaActr_ElecHBrdgDiag_stOLDiagMode_mp DiaActr_ElecHBrdgDiag_stOLDiag_mp
      DiaActr_ElecHBrdgDiag_stSigQly_mp DiaActr_ElecHBrdgDiag_TestPlsReq_mp
    /end LOC_MEASUREMENT
    FUNCTION_VERSION "1.9.0"

/end FUNCTION

/begin FUNCTION

    DiaActr_ElecPsDiag
    "1.5.0     Standardized electrical power stage diagnosis for discrete output signals"

    /begin DEF_CHARACTERISTIC
      DiaActr_ElecPsDiag_DbgSigId_C DiaActr_ElecPsDiag_DbgSigTyp_C DiaActr_ElecPsDiag_SigOutDurgOpenLd_C
    /end DEF_CHARACTERISTIC
    /begin LOC_MEASUREMENT
      DiaActrElecPsDiag_cntTestPlsTsk_mp DiaActrElecPsDiag_nrDiagErr_mp DiaActrElecPsDiag_nrTestPls_mp DiaActrElecPsDiag_stAttribOL_mp DiaActrElecPsDiag_stAttribOT_mp DiaActrElecPsDiag_stAttribSCB_mp
      DiaActrElecPsDiag_stAttribSCG_mp DiaActrElecPsDiag_stDsmDebOpenLoad_mp DiaActrElecPsDiag_stDsmDebOverT_mp DiaActrElecPsDiag_stDsmDebScb_mp DiaActrElecPsDiag_stDsmDebScg_mp DiaActrElecPsDiag_stErrCfgOpenLoad_mp
      DiaActrElecPsDiag_stErrCfgOverT_mp DiaActrElecPsDiag_stErrCfgScb_mp DiaActrElecPsDiag_stErrCfgScg_mp DiaActrElecPsDiag_stPrvTstRslt_mp DiaActrElecPsDiag_stSigCfg_mp DiaActrElecPsDiag_stSigErrInfo_mp
      DiaActrElecPsDiag_stSig_mp DiaActrElecPsDiag_stTestPls_mp DiaActrElecPsDiag_stTmngTestPls_mp DiaActrElecPsDiag_tiTstPls_mp
    /end LOC_MEASUREMENT
    FUNCTION_VERSION "1.5.0"

/end FUNCTION

/begin FUNCTION

    DiaBas_BufAcs
    "30000.8.0 Functions for platform independent access (swapping) to data stored in an MSB buffer"

    FUNCTION_VERSION "30000.8.0"

/end FUNCTION

/begin FUNCTION

    DINH
    "30017.2.0 Diagnostic Inhibit Handler"

    /begin DEF_CHARACTERISTIC
      DINH_FId.DFC_bds_TimeInRowDebFault_CA DINH_FId.DFC_bds_EventInRowDebFault_CA DINH_FId.DFC_DevLibBattUHi_CA DINH_FId.DFC_DevLibBattULo_CA DINH_FId.DFC_bds_TimeUpDownDebFault_CA DINH_FId.DFC_rbr_inA13OR_CA
      DINH_FId.DFC_rbr_inA13SCB_CA DINH_FId.DFC_rbr_inA13SCG_CA DINH_FId.DFC_rbr_inA14OR_CA DINH_FId.DFC_rbr_inA14SCB_CA DINH_FId.DFC_rbr_inA14SCG_CA DINH_FId.DFC_rbr_inA21OR_CA
      DINH_FId.DFC_rbr_inA21SCB_CA DINH_FId.DFC_rbr_inA21SCG_CA DINH_FId.DFC_rbr_inA22OR_CA DINH_FId.DFC_rbr_inA22SCB_CA DINH_FId.DFC_rbr_inA22SCG_CA DINH_FId.DFC_rbr_inA23OR_CA
      DINH_FId.DFC_rbr_inA23SCB_CA DINH_FId.DFC_rbr_inA23SCG_CA DINH_FId.DFC_rbr_inA24OR_CA DINH_FId.DFC_rbr_inA24SCB_CA DINH_FId.DFC_rbr_inA24SCG_CA DINH_FId.DFC_rbr_inA25OR_CA
      DINH_FId.DFC_rbr_inA25SCB_CA DINH_FId.DFC_rbr_inA25SCG_CA DINH_FId.DFC_rbr_inA26OR_CA DINH_FId.DFC_rbr_inA26SCB_CA DINH_FId.DFC_rbr_inA26SCG_CA DINH_FId.DFC_rbr_inA27OR_CA
      DINH_FId.DFC_rbr_inA27SCB_CA DINH_FId.DFC_rbr_inA27SCG_CA DINH_FId.DFC_rbr_inA28OR_CA DINH_FId.DFC_rbr_inA28SCB_CA DINH_FId.DFC_rbr_inA28SCG_CA DINH_FId.DFC_rbr_inA29OR_CA
      DINH_FId.DFC_rbr_inA29SCB_CA DINH_FId.DFC_rbr_inA29SCG_CA DINH_FId.DFC_rbr_inA36AicSCB_CA DINH_FId.DFC_rbr_inA36AicSCG_CA DINH_FId.DFC_rbr_inA36OR_CA DINH_FId.DFC_rbr_inA36SCB_CA
      DINH_FId.DFC_rbr_inA36SCG_CA DINH_FId.DFC_rbr_inA36ShuntSCB_CA DINH_FId.DFC_rbr_inA37AicSCB_CA DINH_FId.DFC_rbr_inA37AicSCG_CA DINH_FId.DFC_rbr_inA37OR_CA DINH_FId.DFC_rbr_inA37SCB_CA
      DINH_FId.DFC_rbr_inA37SCG_CA DINH_FId.DFC_rbr_inA37ShuntSCB_CA DINH_FId.DFC_rbr_inA38AicSCB_CA DINH_FId.DFC_rbr_inA38AicSCG_CA DINH_FId.DFC_rbr_inA38OR_CA DINH_FId.DFC_rbr_inA38SCB_CA
      DINH_FId.DFC_rbr_inA38SCG_CA DINH_FId.DFC_rbr_inA38ShuntSCB_CA DINH_FId.DFC_rbr_inA39AicSCB_CA DINH_FId.DFC_rbr_inA39AicSCG_CA DINH_FId.DFC_rbr_inA39OR_CA DINH_FId.DFC_rbr_inA39SCB_CA
      DINH_FId.DFC_rbr_inA39SCG_CA DINH_FId.DFC_rbr_inA39ShuntSCB_CA DINH_FId.DFC_rbr_inA40OR_CA DINH_FId.DFC_rbr_inA40SCB_CA DINH_FId.DFC_rbr_inA40SCG_CA DINH_FId.DFC_rbr_inA41OR_CA
      DINH_FId.DFC_rbr_inA41SCB_CA DINH_FId.DFC_rbr_inA41SCG_CA DINH_FId.DFC_rbr_inA42OR_CA DINH_FId.DFC_rbr_inA42SCB_CA DINH_FId.DFC_rbr_inA42SCG_CA DINH_FId.DFC_rbr_inA43AicSCB_CA
      DINH_FId.DFC_rbr_inA43AicSCG_CA DINH_FId.DFC_rbr_inA43OR_CA DINH_FId.DFC_rbr_inA43SCB_CA DINH_FId.DFC_rbr_inA43SCG_CA DINH_FId.DFC_rbr_inA43ShuntSCB_CA DINH_FId.DFC_rbr_inA44OL_CA
      DINH_FId.DFC_rbr_inA44SCB_CA DINH_FId.DFC_rbr_inA44SCG_CA DINH_FId.DFC_rbr_inA57OR_CA DINH_FId.DFC_rbr_inA57SCB_CA DINH_FId.DFC_rbr_inA57SCG_CA DINH_FId.DFC_rbr_inA59OL_CA
      DINH_FId.DFC_rbr_inA59SCB_CA DINH_FId.DFC_rbr_inA59SCG_CA DINH_FId.DFC_rbr_inK10OR_CA DINH_FId.DFC_rbr_inK10SCB_CA DINH_FId.DFC_rbr_inK10SCG_CA DINH_FId.DFC_rbr_inK11OR_CA
      DINH_FId.DFC_rbr_inK11SCB_CA DINH_FId.DFC_rbr_inK11SCG_CA DINH_FId.DFC_rbr_inK30AicSCB_CA DINH_FId.DFC_rbr_inK30AicSCG_CA DINH_FId.DFC_rbr_inK30OR_CA DINH_FId.DFC_rbr_inK30SCB_CA
      DINH_FId.DFC_rbr_inK30SCG_CA DINH_FId.DFC_rbr_inK30ShuntSCB_CA DINH_FId.DFC_rbr_inK31OR_CA DINH_FId.DFC_rbr_inK31SCB_CA DINH_FId.DFC_rbr_inK31SCG_CA DINH_FId.DFC_rbr_inK32OR_CA
      DINH_FId.DFC_rbr_inK32SCB_CA DINH_FId.DFC_rbr_inK32SCG_CA DINH_FId.DFC_rbr_inK33OR_CA DINH_FId.DFC_rbr_inK33SCB_CA DINH_FId.DFC_rbr_inK33SCG_CA DINH_FId.DFC_rbr_inK34OR_CA
      DINH_FId.DFC_rbr_inK34SCB_CA DINH_FId.DFC_rbr_inK34SCG_CA DINH_FId.DFC_rbr_inK35OR_CA DINH_FId.DFC_rbr_inK35SCB_CA DINH_FId.DFC_rbr_inK35SCG_CA DINH_FId.DFC_rbr_inK36OR_CA
      DINH_FId.DFC_rbr_inK36SCB_CA DINH_FId.DFC_rbr_inK36SCG_CA DINH_FId.DFC_rbr_inK37AicSCB_CA DINH_FId.DFC_rbr_inK37AicSCG_CA DINH_FId.DFC_rbr_inK37OR_CA DINH_FId.DFC_rbr_inK37SCB_CA
      DINH_FId.DFC_rbr_inK37SCG_CA DINH_FId.DFC_rbr_inK37ShuntSCB_CA DINH_FId.DFC_rbr_inK38AicSCB_CA DINH_FId.DFC_rbr_inK38AicSCG_CA DINH_FId.DFC_rbr_inK38OR_CA DINH_FId.DFC_rbr_inK38SCB_CA
      DINH_FId.DFC_rbr_inK38SCG_CA DINH_FId.DFC_rbr_inK38ShuntSCB_CA DINH_FId.DFC_rbr_inK39AicSCB_CA DINH_FId.DFC_rbr_inK39AicSCG_CA DINH_FId.DFC_rbr_inK39OR_CA DINH_FId.DFC_rbr_inK39SCB_CA
      DINH_FId.DFC_rbr_inK39SCG_CA DINH_FId.DFC_rbr_inK39ShuntSCB_CA DINH_FId.DFC_rbr_inK40AicSCB_CA DINH_FId.DFC_rbr_inK40AicSCG_CA DINH_FId.DFC_rbr_inK40OR_CA DINH_FId.DFC_rbr_inK40SCB_CA
      DINH_FId.DFC_rbr_inK40SCG_CA DINH_FId.DFC_rbr_inK40ShuntSCB_CA DINH_FId.DFC_rbr_inK41AicSCB_CA DINH_FId.DFC_rbr_inK41AicSCG_CA DINH_FId.DFC_rbr_inK41OR_CA DINH_FId.DFC_rbr_inK41SCB_CA
      DINH_FId.DFC_rbr_inK41SCG_CA DINH_FId.DFC_rbr_inK41ShuntSCB_CA DINH_FId.DFC_rbr_inK42AicSCB_CA DINH_FId.DFC_rbr_inK42AicSCG_CA DINH_FId.DFC_rbr_inK42OR_CA DINH_FId.DFC_rbr_inK42SCB_CA
      DINH_FId.DFC_rbr_inK42SCG_CA DINH_FId.DFC_rbr_inK42ShuntSCB_CA DINH_FId.DFC_rbr_inK43OR_CA DINH_FId.DFC_rbr_inK43SCB_CA DINH_FId.DFC_rbr_inK43SCG_CA DINH_FId.DFC_rbr_inK44AicSCB_CA
      DINH_FId.DFC_rbr_inK44AicSCG_CA DINH_FId.DFC_rbr_inK44OR_CA DINH_FId.DFC_rbr_inK44SCB_CA DINH_FId.DFC_rbr_inK44SCG_CA DINH_FId.DFC_rbr_inK44ShuntSCB_CA DINH_FId.DFC_rbr_inK45AicSCB_CA
      DINH_FId.DFC_rbr_inK45AicSCG_CA DINH_FId.DFC_rbr_inK45OR_CA DINH_FId.DFC_rbr_inK45SCB_CA DINH_FId.DFC_rbr_inK45SCG_CA DINH_FId.DFC_rbr_inK45ShuntSCB_CA DINH_FId.DFC_rbr_inK52OR_CA
      DINH_FId.DFC_rbr_inK52SCB_CA DINH_FId.DFC_rbr_inK52SCG_CA DINH_FId.DFC_rbr_inK53OR_CA DINH_FId.DFC_rbr_inK53SCB_CA DINH_FId.DFC_rbr_inK53SCG_CA DINH_FId.DFC_rbr_inK54AicSCB_CA
      DINH_FId.DFC_rbr_inK54AicSCG_CA DINH_FId.DFC_rbr_inK54OR_CA DINH_FId.DFC_rbr_inK54SCB_CA DINH_FId.DFC_rbr_inK54SCG_CA DINH_FId.DFC_rbr_inK54ShuntSCB_CA DINH_FId.DFC_rbr_inK55AicSCB_CA
      DINH_FId.DFC_rbr_inK55AicSCG_CA DINH_FId.DFC_rbr_inK55OR_CA DINH_FId.DFC_rbr_inK55SCB_CA DINH_FId.DFC_rbr_inK55SCG_CA DINH_FId.DFC_rbr_inK55ShuntSCB_CA DINH_FId.DFC_rbr_inK56OR_CA
      DINH_FId.DFC_rbr_inK56SCB_CA DINH_FId.DFC_rbr_inK56SCG_CA DINH_FId.DFC_rbr_inK57OR_CA DINH_FId.DFC_rbr_inK57SCB_CA DINH_FId.DFC_rbr_inK57SCG_CA DINH_FId.DFC_rbr_inK58OR_CA
      DINH_FId.DFC_rbr_inK58SCB_CA DINH_FId.DFC_rbr_inK58SCG_CA DINH_FId.DFC_rbr_inK59OR_CA DINH_FId.DFC_rbr_inK59SCB_CA DINH_FId.DFC_rbr_inK59SCG_CA DINH_FId.DFC_rbr_inK60OR_CA
      DINH_FId.DFC_rbr_inK60SCB_CA DINH_FId.DFC_rbr_inK60SCG_CA DINH_FId.DFC_rbr_inK61AicSCB_CA DINH_FId.DFC_rbr_inK61AicSCG_CA DINH_FId.DFC_rbr_inK61OR_CA DINH_FId.DFC_rbr_inK61SCB_CA
      DINH_FId.DFC_rbr_inK61SCG_CA DINH_FId.DFC_rbr_inK61ShuntSCB_CA DINH_FId.DFC_rbr_inK62OR_CA DINH_FId.DFC_rbr_inK62SCB_CA DINH_FId.DFC_rbr_inK62SCG_CA DINH_FId.DFC_rbr_inK63AicSCB_CA
      DINH_FId.DFC_rbr_inK63AicSCG_CA DINH_FId.DFC_rbr_inK63OR_CA DINH_FId.DFC_rbr_inK63SCB_CA DINH_FId.DFC_rbr_inK63SCG_CA DINH_FId.DFC_rbr_inK63ShuntSCB_CA DINH_FId.DFC_rbr_inK64AicSCB_CA
      DINH_FId.DFC_rbr_inK64AicSCG_CA DINH_FId.DFC_rbr_inK64OR_CA DINH_FId.DFC_rbr_inK64SCB_CA DINH_FId.DFC_rbr_inK64SCG_CA DINH_FId.DFC_rbr_inK64ShuntSCB_CA DINH_FId.DFC_rbr_inK65AicSCB_CA
      DINH_FId.DFC_rbr_inK65AicSCG_CA DINH_FId.DFC_rbr_inK65OR_CA DINH_FId.DFC_rbr_inK65SCB_CA DINH_FId.DFC_rbr_inK65SCG_CA DINH_FId.DFC_rbr_inK65ShuntSCB_CA DINH_FId.DFC_rbr_inK74OR_CA
      DINH_FId.DFC_rbr_inK74SCB_CA DINH_FId.DFC_rbr_inK74SCG_CA DINH_FId.DFC_rbr_inK75OR_CA DINH_FId.DFC_rbr_inK75SCB_CA DINH_FId.DFC_rbr_inK75SCG_CA DINH_FId.DFC_rbr_inK76OR_CA
      DINH_FId.DFC_rbr_inK76SCB_CA DINH_FId.DFC_rbr_inK76SCG_CA DINH_FId.DFC_rbr_inK77OR_CA DINH_FId.DFC_rbr_inK77SCB_CA DINH_FId.DFC_rbr_inK77SCG_CA DINH_FId.DFC_rbr_inK78OR_CA
      DINH_FId.DFC_rbr_inK78SCB_CA DINH_FId.DFC_rbr_inK78SCG_CA DINH_FId.DFC_rbr_mo_DvUBAT_FWs_CA DINH_FId.DFC_rbr_mo_OVErr_VPR6_CA DINH_FId.DFC_rbr_mo_OVWarn_VPR6_CA DINH_FId.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3_CA
      DINH_FId.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2_CA DINH_FId.DFC_rbr_mo_OV_UBAT_MON_CA DINH_FId.DFC_rbr_mo_OV_UBRM24_FLEXIN_CA DINH_FId.DFC_rbr_mo_OV_UBRM24_LOADS_CA DINH_FId.DFC_rbr_mo_OV_UBRM24_MON_CA DINH_FId.DFC_rbr_mo_OV_VDD5_CA
      DINH_FId.DFC_rbr_mo_OV_VDD5_IN_CA DINH_FId.DFC_rbr_mo_OV_VPR6_CA DINH_FId.DFC_rbr_mo_OV_VSS3_CA DINH_FId.DFC_rbr_mo_OV_VSS4_CA DINH_FId.DFC_rbr_mo_Temp1_HTErr_CA DINH_FId.DFC_rbr_mo_Temp1_HTWarn_CA
      DINH_FId.DFC_rbr_mo_Temp2_HTErr_CA DINH_FId.DFC_rbr_mo_Temp2_HTWarn_CA DINH_FId.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3_CA DINH_FId.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2_CA DINH_FId.DFC_rbr_mo_UV_VDD5_CA DINH_FId.DFC_rbr_mo_UV_VDD5_IN_CA
      DINH_FId.DFC_rbr_mo_UV_VPR6_CA DINH_FId.DFC_rbr_mo_UV_VSS3_CA DINH_FId.DFC_rbr_mo_UV_VSS4_CA DINH_FId.DFC_rbr_outA01OL_CA DINH_FId.DFC_rbr_outA01OT_CA DINH_FId.DFC_rbr_outA01SCB_CA
      DINH_FId.DFC_rbr_outA01SCG_CA DINH_FId.DFC_rbr_outA02OL_CA DINH_FId.DFC_rbr_outA02OR_CA DINH_FId.DFC_rbr_outA02OT_CA DINH_FId.DFC_rbr_outA02SCB_CA DINH_FId.DFC_rbr_outA02SCG_CA
      DINH_FId.DFC_rbr_outA03OL_CA DINH_FId.DFC_rbr_outA03OT_CA DINH_FId.DFC_rbr_outA03SCB_CA DINH_FId.DFC_rbr_outA03SCG_CA DINH_FId.DFC_rbr_outA04OL_CA DINH_FId.DFC_rbr_outA04OT_CA
      DINH_FId.DFC_rbr_outA04SCB_CA DINH_FId.DFC_rbr_outA04SCG_CA DINH_FId.DFC_rbr_outA05OL_CA DINH_FId.DFC_rbr_outA05OR_CA DINH_FId.DFC_rbr_outA05OT_CA DINH_FId.DFC_rbr_outA05SCB_CA
      DINH_FId.DFC_rbr_outA05SCG_CA DINH_FId.DFC_rbr_outA06OL_CA DINH_FId.DFC_rbr_outA06OR_CA DINH_FId.DFC_rbr_outA06OT_CA DINH_FId.DFC_rbr_outA06SCB_CA DINH_FId.DFC_rbr_outA06SCG_CA
      DINH_FId.DFC_rbr_outA07OL_CA DINH_FId.DFC_rbr_outA07OT_CA DINH_FId.DFC_rbr_outA07SCB_CA DINH_FId.DFC_rbr_outA07SCG_CA DINH_FId.DFC_rbr_outA08OL_CA DINH_FId.DFC_rbr_outA08OT_CA
      DINH_FId.DFC_rbr_outA08SCB_CA DINH_FId.DFC_rbr_outA08SCG_CA DINH_FId.DFC_rbr_outA09OL_CA DINH_FId.DFC_rbr_outA09OR_CA DINH_FId.DFC_rbr_outA09OT_CA DINH_FId.DFC_rbr_outA09SCB_CA
      DINH_FId.DFC_rbr_outA09SCG_CA DINH_FId.DFC_rbr_outA10OL_CA DINH_FId.DFC_rbr_outA10OT_CA DINH_FId.DFC_rbr_outA10SCB_CA DINH_FId.DFC_rbr_outA10SCG_CA DINH_FId.DFC_rbr_outA11OL_CA
      DINH_FId.DFC_rbr_outA11OT_CA DINH_FId.DFC_rbr_outA11SCB_CA DINH_FId.DFC_rbr_outA11SCG_CA DINH_FId.DFC_rbr_outA12OR_CA DINH_FId.DFC_rbr_outA12SCB_CA DINH_FId.DFC_rbr_outA12SCG_CA
      DINH_FId.DFC_rbr_outA16OL_CA DINH_FId.DFC_rbr_outA16OT_CA DINH_FId.DFC_rbr_outA16SCB_CA DINH_FId.DFC_rbr_outA16SCG_CA DINH_FId.DFC_rbr_outA17OL_CA DINH_FId.DFC_rbr_outA17OR_CA
      DINH_FId.DFC_rbr_outA17OT_CA DINH_FId.DFC_rbr_outA17SCB_CA DINH_FId.DFC_rbr_outA17SCG_CA DINH_FId.DFC_rbr_outA18OL_CA DINH_FId.DFC_rbr_outA18OT_CA DINH_FId.DFC_rbr_outA18SCB_CA
      DINH_FId.DFC_rbr_outA18SCG_CA DINH_FId.DFC_rbr_outA19OL_CA DINH_FId.DFC_rbr_outA19OR_CA DINH_FId.DFC_rbr_outA19OT_CA DINH_FId.DFC_rbr_outA19SCB_CA DINH_FId.DFC_rbr_outA19SCG_CA
      DINH_FId.DFC_rbr_outA20OL_CA DINH_FId.DFC_rbr_outA20OR_CA DINH_FId.DFC_rbr_outA20OT_CA DINH_FId.DFC_rbr_outA20SCB_CA DINH_FId.DFC_rbr_outA20SCG_CA DINH_FId.DFC_rbr_outA31OL_CA
      DINH_FId.DFC_rbr_outA31OR_CA DINH_FId.DFC_rbr_outA31OT_CA DINH_FId.DFC_rbr_outA31SCB_CA DINH_FId.DFC_rbr_outA31SCG_CA DINH_FId.DFC_rbr_outA32OL_CA DINH_FId.DFC_rbr_outA32OR_CA
      DINH_FId.DFC_rbr_outA32OT_CA DINH_FId.DFC_rbr_outA32SCB_CA DINH_FId.DFC_rbr_outA32SCG_CA DINH_FId.DFC_rbr_outA33OL_CA DINH_FId.DFC_rbr_outA33OR_CA DINH_FId.DFC_rbr_outA33OT_CA
      DINH_FId.DFC_rbr_outA33SCB_CA DINH_FId.DFC_rbr_outA33SCG_CA DINH_FId.DFC_rbr_outA34OL_CA DINH_FId.DFC_rbr_outA34OR_CA DINH_FId.DFC_rbr_outA34OT_CA DINH_FId.DFC_rbr_outA34SCB_CA
      DINH_FId.DFC_rbr_outA34SCG_CA DINH_FId.DFC_rbr_outA35OL_CA DINH_FId.DFC_rbr_outA35OR_CA DINH_FId.DFC_rbr_outA35OT_CA DINH_FId.DFC_rbr_outA35SCB_CA DINH_FId.DFC_rbr_outA35SCG_CA
      DINH_FId.DFC_rbr_outA46OL_CA DINH_FId.DFC_rbr_outA46OR_CA DINH_FId.DFC_rbr_outA46OT_CA DINH_FId.DFC_rbr_outA46SCB_CA DINH_FId.DFC_rbr_outA46SCG_CA DINH_FId.DFC_rbr_outA47OL_CA
      DINH_FId.DFC_rbr_outA47OR_CA DINH_FId.DFC_rbr_outA47OT_CA DINH_FId.DFC_rbr_outA47SCB_CA DINH_FId.DFC_rbr_outA47SCG_CA DINH_FId.DFC_rbr_outA48OL_CA DINH_FId.DFC_rbr_outA48OR_CA
      DINH_FId.DFC_rbr_outA48OT_CA DINH_FId.DFC_rbr_outA48SCB_CA DINH_FId.DFC_rbr_outA48SCG_CA DINH_FId.DFC_rbr_outA49OL_CA DINH_FId.DFC_rbr_outA49OT_CA DINH_FId.DFC_rbr_outA49SCB_CA
      DINH_FId.DFC_rbr_outA49SCG_CA DINH_FId.DFC_rbr_outA50OL_CA DINH_FId.DFC_rbr_outA50OT_CA DINH_FId.DFC_rbr_outA50SCB_CA DINH_FId.DFC_rbr_outA50SCG_CA DINH_FId.DFC_rbr_outA51OL_CA
      DINH_FId.DFC_rbr_outA51OR_CA DINH_FId.DFC_rbr_outA51OT_CA DINH_FId.DFC_rbr_outA51SCB_CA DINH_FId.DFC_rbr_outA51SCG_CA DINH_FId.DFC_rbr_outA52OL_CA DINH_FId.DFC_rbr_outA52OR_CA
      DINH_FId.DFC_rbr_outA52OT_CA DINH_FId.DFC_rbr_outA52SCB_CA DINH_FId.DFC_rbr_outA52SCG_CA DINH_FId.DFC_rbr_outA53OL_CA DINH_FId.DFC_rbr_outA53OR_CA DINH_FId.DFC_rbr_outA53OT_CA
      DINH_FId.DFC_rbr_outA53SCB_CA DINH_FId.DFC_rbr_outA53SCG_CA DINH_FId.DFC_rbr_outA54OL_CA DINH_FId.DFC_rbr_outA54OR_CA DINH_FId.DFC_rbr_outA54OT_CA DINH_FId.DFC_rbr_outA54SCB_CA
      DINH_FId.DFC_rbr_outA54SCG_CA DINH_FId.DFC_rbr_outA55OL_CA DINH_FId.DFC_rbr_outA55OT_CA DINH_FId.DFC_rbr_outA55SCB_CA DINH_FId.DFC_rbr_outA55SCG_CA DINH_FId.DFC_rbr_outA56OL_CA
      DINH_FId.DFC_rbr_outA56OT_CA DINH_FId.DFC_rbr_outA56SCB_CA DINH_FId.DFC_rbr_outA56SCG_CA DINH_FId.DFC_rbr_outA58OL_CA DINH_FId.DFC_rbr_outA58OT_CA DINH_FId.DFC_rbr_outA58SCB_CA
      DINH_FId.DFC_rbr_outA58SCG_CA DINH_FId.DFC_rbr_outK07OL_CA DINH_FId.DFC_rbr_outK07OR_CA DINH_FId.DFC_rbr_outK07OT_CA DINH_FId.DFC_rbr_outK07SCB_CA DINH_FId.DFC_rbr_outK07SCG_CA
      DINH_FId.DFC_rbr_outK08OL_CA DINH_FId.DFC_rbr_outK08OR_CA DINH_FId.DFC_rbr_outK08OT_CA DINH_FId.DFC_rbr_outK08SCB_CA DINH_FId.DFC_rbr_outK08SCG_CA DINH_FId.DFC_rbr_outK09OL_CA
      DINH_FId.DFC_rbr_outK09OR_CA DINH_FId.DFC_rbr_outK09OT_CA DINH_FId.DFC_rbr_outK09SCB_CA DINH_FId.DFC_rbr_outK09SCG_CA DINH_FId.DFC_rbr_outK12OL_CA DINH_FId.DFC_rbr_outK12OT_CA
      DINH_FId.DFC_rbr_outK12SCB_CA DINH_FId.DFC_rbr_outK12SCG_CA DINH_FId.DFC_rbr_outK13OL_CA DINH_FId.DFC_rbr_outK13OT_CA DINH_FId.DFC_rbr_outK13SCB_CA DINH_FId.DFC_rbr_outK13SCG_CA
      DINH_FId.DFC_rbr_outK14OL_CA DINH_FId.DFC_rbr_outK14OR_CA DINH_FId.DFC_rbr_outK14OT_CA DINH_FId.DFC_rbr_outK14SCB_CA DINH_FId.DFC_rbr_outK14SCG_CA DINH_FId.DFC_rbr_outK15OL_CA
      DINH_FId.DFC_rbr_outK15OR_CA DINH_FId.DFC_rbr_outK15OT_CA DINH_FId.DFC_rbr_outK15SCB_CA DINH_FId.DFC_rbr_outK15SCG_CA DINH_FId.DFC_rbr_outK16OL_CA DINH_FId.DFC_rbr_outK16OR_CA
      DINH_FId.DFC_rbr_outK16OT_CA DINH_FId.DFC_rbr_outK16SCB_CA DINH_FId.DFC_rbr_outK16SCG_CA DINH_FId.DFC_rbr_outK17OL_CA DINH_FId.DFC_rbr_outK17OR_CA DINH_FId.DFC_rbr_outK17OT_CA
      DINH_FId.DFC_rbr_outK17SCB_CA DINH_FId.DFC_rbr_outK17SCG_CA DINH_FId.DFC_rbr_outK25OR_CA DINH_FId.DFC_rbr_outK25SCB_CA DINH_FId.DFC_rbr_outK25SCG_CA DINH_FId.DFC_rbr_outK29OL_CA
      DINH_FId.DFC_rbr_outK29OR_CA DINH_FId.DFC_rbr_outK29OT_CA DINH_FId.DFC_rbr_outK29SCB_CA DINH_FId.DFC_rbr_outK29SCG_CA DINH_FId.DFC_rbr_outK51OL_CA DINH_FId.DFC_rbr_outK51OT_CA
      DINH_FId.DFC_rbr_outK51SCB_CA DINH_FId.DFC_rbr_outK51SCG_CA DINH_FId.DFC_rbr_outK62OR_CA DINH_FId.DFC_rbr_outK62SCB_CA DINH_FId.DFC_rbr_outK62SCG_CA DINH_FId.DFC_rbr_outK73OL_CA
      DINH_FId.DFC_rbr_outK73OR_CA DINH_FId.DFC_rbr_outK73OT_CA DINH_FId.DFC_rbr_outK73SCB_CA DINH_FId.DFC_rbr_outK73SCG_CA DINH_FId.DFC_rbr_outK80OL_CA DINH_FId.DFC_rbr_outK80OT_CA
      DINH_FId.DFC_rbr_outK80SCB_CA DINH_FId.DFC_rbr_outK80SCG_CA DINH_FId.DFC_rbr_outK81OL_CA DINH_FId.DFC_rbr_outK81OT_CA DINH_FId.DFC_rbr_outK81SCB_CA DINH_FId.DFC_rbr_outK81SCG_CA
      DINH_FId.DFC_rbr_outK82OL_CA DINH_FId.DFC_rbr_outK82OT_CA DINH_FId.DFC_rbr_outK82SCB_CA DINH_FId.DFC_rbr_outK82SCG_CA DINH_FId.DFC_rbr_outK83OL_CA DINH_FId.DFC_rbr_outK83OT_CA
      DINH_FId.DFC_rbr_outK83SCB_CA DINH_FId.DFC_rbr_outK83SCG_CA DINH_FId.DFC_rbr_outK84OL_CA DINH_FId.DFC_rbr_outK84OT_CA DINH_FId.DFC_rbr_outK84SCB_CA DINH_FId.DFC_rbr_outK84SCG_CA
      DINH_FId.DFC_rbr_outK85OL_CA DINH_FId.DFC_rbr_outK85OT_CA DINH_FId.DFC_rbr_outK85SCB_CA DINH_FId.DFC_rbr_outK85SCG_CA DINH_FId.DFC_rbr_outK86OL_CA DINH_FId.DFC_rbr_outK86OT_CA
      DINH_FId.DFC_rbr_outK86SCB_CA DINH_FId.DFC_rbr_outK86SCG_CA DINH_FId.DFC_rbr_outK87OL_CA DINH_FId.DFC_rbr_outK87OT_CA DINH_FId.DFC_rbr_outK87SCB_CA DINH_FId.DFC_rbr_outK87SCG_CA
      DINH_FId.DFC_bds_EventUpDownDebFault_CA DINH_FId.DFC_DSMDummy_CA DINH_FId.DFC_rbr_canGetDataNoBuf_CA DINH_FId.DFC_rbr_canGetDataParam_CA DINH_FId.DFC_rbr_canGetDataboxNoInit_CA DINH_FId.DFC_rbr_canGetDataboxParam_CA
      DINH_FId.DFC_rbr_canGetRxBufStatusParam_CA DINH_FId.DFC_rbr_canGetStatusParam_CA DINH_FId.DFC_rbr_canGetTxBufStatusParam_CA DINH_FId.DFC_rbr_canInitParam_CA DINH_FId.DFC_rbr_canInitRxDataboxOverlap_CA DINH_FId.DFC_rbr_canInitRxDataboxParam_CA
      DINH_FId.DFC_rbr_canInitTxDataboxParam_CA DINH_FId.DFC_rbr_canIpduGroupControl_CA DINH_FId.DFC_rbr_canIsDataboxFreeNoInit_CA DINH_FId.DFC_rbr_canIsDataboxFreeParam_CA DINH_FId.DFC_rbr_canIsTxEmptyParam_CA DINH_FId.DFC_rbr_canRegBusOffCallbInvState_CA
      DINH_FId.DFC_rbr_canRegBusOffCallbParam_CA DINH_FId.DFC_rbr_canRegRxBufInvState_CA DINH_FId.DFC_rbr_canRegRxBufOverlap_CA DINH_FId.DFC_rbr_canRegRxBufParam_CA DINH_FId.DFC_rbr_canRegRxCallbInvState_CA DINH_FId.DFC_rbr_canRegRxCallbParam_CA
      DINH_FId.DFC_rbr_canRegRxDataboxInvNumb_CA DINH_FId.DFC_rbr_canRegRxDataboxInvState_CA DINH_FId.DFC_rbr_canRegRxDataboxOverlap_CA DINH_FId.DFC_rbr_canRegRxDataboxParam_CA DINH_FId.DFC_rbr_canRegTxBufInvState_CA DINH_FId.DFC_rbr_canRegTxBufOverlap_CA
      DINH_FId.DFC_rbr_canRegTxBufParam_CA DINH_FId.DFC_rbr_canRegTxDataboxInvNumb_CA DINH_FId.DFC_rbr_canRegTxDataboxInvState_CA DINH_FId.DFC_rbr_canRegTxDataboxOverlap_CA DINH_FId.DFC_rbr_canRegTxDataboxParam_CA DINH_FId.DFC_rbr_canResetTxBufParam_CA
      DINH_FId.DFC_rbr_canSendDataBufOvfl_CA DINH_FId.DFC_rbr_canSendDataParam_CA DINH_FId.DFC_rbr_canSendDataboxNoInit_CA DINH_FId.DFC_rbr_canSendDataboxParam_CA DINH_FId.DFC_rbr_canSetTxCycleParam_CA DINH_FId.DFC_rbr_canStartParam_CA
      DINH_FId.DFC_rbr_canStopParam_CA DINH_FId.DFC_rbr_can_ClearIpduGroup_CA DINH_FId.DFC_rbr_can_ReceiveSignal_CA DINH_FId.DFC_rbr_can_SendSignal_CA DINH_FId.DFC_rbr_can_SetIpduGroup_CA DINH_FId.DFC_rbr_dsmDTCJ1939_CA
      DINH_FId.DFC_rbr_dsmDelDTCJ1939_CA DINH_FId.DFC_rbr_dsmDelErrors_CA DINH_FId.DFC_rbr_dsmGetDFES_CA DINH_FId.DFC_rbr_dsmGetDTCJ1939_CA DINH_FId.DFC_rbr_dsmGetErrors_CA DINH_FId.DFC_rbr_dsmGetNumErrors_CA
      DINH_FId.DFC_rbr_dsmInitQueueOverflow_CA DINH_FId.DFC_rbr_dsmNumDTCJ1939_CA DINH_FId.DFC_rbr_dsmTesterror_CA DINH_FId.DFC_rbr_dsmUpdateDebError_CA DINH_FId.DFC_rbr_dsmUpdateError_CA DINH_FId.DFC_rbr_dsmgetDFCStatus_CA
      DINH_FId.DFC_rbr_dsmtestErrorDFC_CA DINH_FId.DFC_rbr_inAi_CA DINH_FId.DFC_rbr_inAic_CA DINH_FId.DFC_rbr_inAicCfg_CA DINH_FId.DFC_rbr_inAicGetStatus_CA DINH_FId.DFC_rbr_inAid_CA
      DINH_FId.DFC_rbr_inAidCfg_CA DINH_FId.DFC_rbr_inAiv_CA DINH_FId.DFC_rbr_inAivCfg_CA DINH_FId.DFC_rbr_inAivGetStatus_CA DINH_FId.DFC_rbr_inDi_CA DINH_FId.DFC_rbr_inFi_CA
      DINH_FId.DFC_rbr_inFiCfg_CA DINH_FId.DFC_rbr_inFiGetStatus_CA DINH_FId.DFC_rbr_inFi_Buffered_CA DINH_FId.DFC_rbr_inPhase_CA DINH_FId.DFC_rbr_inPhaseGetStatus_CA DINH_FId.DFC_rbr_inPhaseResetCounter_CA
      DINH_FId.DFC_rbr_inRi_CA DINH_FId.DFC_rbr_inRiCfg_CA DINH_FId.DFC_rbr_inRiCfgTemp_CA DINH_FId.DFC_rbr_inRiGetStatus_CA DINH_FId.DFC_rbr_inRiGetTemp_CA DINH_FId.DFC_rbr_inSentCopyFDFifo_CA
      DINH_FId.DFC_rbr_inSentDisable_CA DINH_FId.DFC_rbr_inSentEnable_CA DINH_FId.DFC_rbr_inSentGetErrorStatus_CA DINH_FId.DFC_rbr_inSentGetFD_CA DINH_FId.DFC_rbr_inSentGetSD_CA DINH_FId.DFC_rbr_inSentGetSDDatabox_CA
      DINH_FId.DFC_rbr_inSentGetStatus_CA DINH_FId.DFC_rbr_inSentInitSDDatabox_CA DINH_FId.DFC_rbr_inSentRegisterCopyFDFifo_CA DINH_FId.DFC_rbr_inSentRegisterFDFifo_CA DINH_FId.DFC_rbr_inSentRegisterSDDataboxes_CA DINH_FId.DFC_rbr_isobusCanRxBufferOverflow_CA
      DINH_FId.DFC_rbr_isobusGetCaAddrParam_CA DINH_FId.DFC_rbr_isobusGetDiagnosticParam_CA DINH_FId.DFC_rbr_isobusGetRxDataboxStatusParam_CA DINH_FId.DFC_rbr_isobusGetStatusParam_CA DINH_FId.DFC_rbr_isobusInitCommCaMissing_CA DINH_FId.DFC_rbr_isobusInitCommParam_CA
      DINH_FId.DFC_rbr_isobusInitCommState_CA DINH_FId.DFC_rbr_isobusInitDiagnosticParam_CA DINH_FId.DFC_rbr_isobusInitFailureListParam_CA DINH_FId.DFC_rbr_isobusInitRxDataboxParam_CA DINH_FId.DFC_rbr_isobusInitTxDataboxParam_CA DINH_FId.DFC_rbr_isobusRegRxDataboxOverlap_CA
      DINH_FId.DFC_rbr_isobusRegRxDataboxParam_CA DINH_FId.DFC_rbr_isobusRegRxDataboxState_CA DINH_FId.DFC_rbr_isobusRegTxDataboxOverlap_CA DINH_FId.DFC_rbr_isobusRegTxDataboxParam_CA DINH_FId.DFC_rbr_isobusRegTxDataboxState_CA DINH_FId.DFC_rbr_isobusRegisterErrClrCallbackParam_CA
      DINH_FId.DFC_rbr_isobusRegisterInstancesOverlap_CA DINH_FId.DFC_rbr_isobusRegisterInstancesParam_CA DINH_FId.DFC_rbr_isobusRegisterInstancesState_CA DINH_FId.DFC_rbr_isobusSendDataboxParam_CA DINH_FId.DFC_rbr_isobusSendRequestPGNParam_CA DINH_FId.DFC_rbr_isobusSetCaAddrCaUsed_CA
      DINH_FId.DFC_rbr_isobusSetCaAddrComm_CA DINH_FId.DFC_rbr_isobusSetCaAddrInvCan_CA DINH_FId.DFC_rbr_isobusSetCaAddrParam_CA DINH_FId.DFC_rbr_isobusSetCaInfoParam_CA DINH_FId.DFC_rbr_isobusSetCaNameParam_CA DINH_FId.DFC_rbr_isobusSftyCanTxErr_CA
      DINH_FId.DFC_rbr_lin_ReceiveSignal_CA DINH_FId.DFC_rbr_lin_SendSignal_CA DINH_FId.DFC_rbr_lin_getStatus_CA DINH_FId.DFC_rbr_lin_gotoSleep_CA DINH_FId.DFC_rbr_lin_scheduleRequest_CA DINH_FId.DFC_rbr_lin_wakeUp_CA
      DINH_FId.DFC_rbr_memFlsCfgShr_CA DINH_FId.DFC_rbr_memGetStatus_CA DINH_FId.DFC_rbr_memMarkBlock_CA DINH_FId.DFC_rbr_memReadApi1Error_CA DINH_FId.DFC_rbr_memReadApi2Error_CA DINH_FId.DFC_rbr_memReadBlock_CA
      DINH_FId.DFC_rbr_memReadCalibInputError_CA DINH_FId.DFC_rbr_memReadCalibOuputError_CA DINH_FId.DFC_rbr_memReadSystemError_CA DINH_FId.DFC_rbr_memWriteBlock_CA DINH_FId.DFC_rbr_moOV_FirstConstADC_CA DINH_FId.DFC_rbr_moOV_SecondConstADC_CA
      DINH_FId.DFC_rbr_moUV_FirstConstADC_CA DINH_FId.DFC_rbr_moUV_SecondConstADC_CA DINH_FId.DFC_rbr_mo_INH_CA DINH_FId.DFC_rbr_mo_INHLatch_CA DINH_FId.DFC_rbr_mo_adcPDD_fail_CA DINH_FId.DFC_rbr_mo_memoryProtection_err_CA
      DINH_FId.DFC_rbr_outA02OC_CA DINH_FId.DFC_rbr_outA02Unintended_CA DINH_FId.DFC_rbr_outA03OC_CA DINH_FId.DFC_rbr_outA03Unintended_CA DINH_FId.DFC_rbr_outA04OC_CA DINH_FId.DFC_rbr_outA04Unintended_CA
      DINH_FId.DFC_rbr_outA05OC_CA DINH_FId.DFC_rbr_outA05Unintended_CA DINH_FId.DFC_rbr_outA07OC_CA DINH_FId.DFC_rbr_outA07Unintended_CA DINH_FId.DFC_rbr_outA08OC_CA DINH_FId.DFC_rbr_outA08Unintended_CA
      DINH_FId.DFC_rbr_outA09OC_CA DINH_FId.DFC_rbr_outA09Unintended_CA DINH_FId.DFC_rbr_outA10OC_CA DINH_FId.DFC_rbr_outA10Unintended_CA DINH_FId.DFC_rbr_outA17OC_CA DINH_FId.DFC_rbr_outA17Unintended_CA
      DINH_FId.DFC_rbr_outA18OC_CA DINH_FId.DFC_rbr_outA18Unintended_CA DINH_FId.DFC_rbr_outA19OC_CA DINH_FId.DFC_rbr_outA19Unintended_CA DINH_FId.DFC_rbr_outA20OC_CA DINH_FId.DFC_rbr_outA20Unintended_CA
      DINH_FId.DFC_rbr_outA31OC_CA DINH_FId.DFC_rbr_outA31Unintended_CA DINH_FId.DFC_rbr_outA32OC_CA DINH_FId.DFC_rbr_outA32Unintended_CA DINH_FId.DFC_rbr_outA33OC_CA DINH_FId.DFC_rbr_outA33Unintended_CA
      DINH_FId.DFC_rbr_outA34OC_CA DINH_FId.DFC_rbr_outA34Unintended_CA DINH_FId.DFC_rbr_outA35OC_CA DINH_FId.DFC_rbr_outA35Unintended_CA DINH_FId.DFC_rbr_outA46OC_CA DINH_FId.DFC_rbr_outA46Unintended_CA
      DINH_FId.DFC_rbr_outA47OC_CA DINH_FId.DFC_rbr_outA47Unintended_CA DINH_FId.DFC_rbr_outA48OC_CA DINH_FId.DFC_rbr_outA48Unintended_CA DINH_FId.DFC_rbr_outA51OC_CA DINH_FId.DFC_rbr_outA51Unintended_CA
      DINH_FId.DFC_rbr_outA52OC_CA DINH_FId.DFC_rbr_outA52Unintended_CA DINH_FId.DFC_rbr_outA53OC_CA DINH_FId.DFC_rbr_outA53Unintended_CA DINH_FId.DFC_rbr_outA54OC_CA DINH_FId.DFC_rbr_outA54Unintended_CA
      DINH_FId.DFC_rbr_outAov_CA DINH_FId.DFC_rbr_outAovCfg_CA DINH_FId.DFC_rbr_outAovCfgPI_CA DINH_FId.DFC_rbr_outAovGetStatus_CA DINH_FId.DFC_rbr_outAovGetVoltage_CA DINH_FId.DFC_rbr_outAovResetError_CA
      DINH_FId.DFC_rbr_outDo_CA DINH_FId.DFC_rbr_outDoCfgPwrLs_CA DINH_FId.DFC_rbr_outDoDisable_CA DINH_FId.DFC_rbr_outDoGetCurrent_CA DINH_FId.DFC_rbr_outDoGetStatus_CA DINH_FId.DFC_rbr_outDoResetError_CA
      DINH_FId.DFC_rbr_outK07OC_CA DINH_FId.DFC_rbr_outK07Unintended_CA DINH_FId.DFC_rbr_outK08OC_CA DINH_FId.DFC_rbr_outK08Unintended_CA DINH_FId.DFC_rbr_outK09OC_CA DINH_FId.DFC_rbr_outK09Unintended_CA
      DINH_FId.DFC_rbr_outK12OC_CA DINH_FId.DFC_rbr_outK12Unintended_CA DINH_FId.DFC_rbr_outK13OC_CA DINH_FId.DFC_rbr_outK13Unintended_CA DINH_FId.DFC_rbr_outK14OC_CA DINH_FId.DFC_rbr_outK14Unintended_CA
      DINH_FId.DFC_rbr_outK15OC_CA DINH_FId.DFC_rbr_outK15Unintended_CA DINH_FId.DFC_rbr_outK16OC_CA DINH_FId.DFC_rbr_outK16Unintended_CA DINH_FId.DFC_rbr_outK17OC_CA DINH_FId.DFC_rbr_outK17Unintended_CA
      DINH_FId.DFC_rbr_outK29OC_CA DINH_FId.DFC_rbr_outK29Unintended_CA DINH_FId.DFC_rbr_outK51OC_CA DINH_FId.DFC_rbr_outK51Unintended_CA DINH_FId.DFC_rbr_outK73OC_CA DINH_FId.DFC_rbr_outK73Unintended_CA
      DINH_FId.DFC_rbr_outPo_CA DINH_FId.DFC_rbr_outPoCfg_CA DINH_FId.DFC_rbr_outPoCfgPeriod_CA DINH_FId.DFC_rbr_outPoCfgPwrLs_CA DINH_FId.DFC_rbr_outPoDisable_CA DINH_FId.DFC_rbr_outPoGetCurrent_CA
      DINH_FId.DFC_rbr_outPoGetStatus_CA DINH_FId.DFC_rbr_outPoResetError_CA DINH_FId.DFC_rbr_outPoc_CA DINH_FId.DFC_rbr_outPocCfg_CA DINH_FId.DFC_rbr_outPocCfgDither_CA DINH_FId.DFC_rbr_outPocCfgPI_CA
      DINH_FId.DFC_rbr_outPod_CA DINH_FId.DFC_rbr_outPodCfg_CA DINH_FId.DFC_rbr_outPodCfgPeriod_CA DINH_FId.DFC_rbr_rsmFfiApiCallErr_CA DINH_FId.DFC_rbr_safout_CA DINH_FId.DFC_rbr_safoutCfg_CA
      DINH_FId.DFC_rbr_safoutChnl1_CA DINH_FId.DFC_rbr_safoutChnl10_CA DINH_FId.DFC_rbr_safoutChnl10Dev_CA DINH_FId.DFC_rbr_safoutChnl10OR_CA DINH_FId.DFC_rbr_safoutChnl11_CA DINH_FId.DFC_rbr_safoutChnl11Dev_CA
      DINH_FId.DFC_rbr_safoutChnl11OR_CA DINH_FId.DFC_rbr_safoutChnl12_CA DINH_FId.DFC_rbr_safoutChnl12Dev_CA DINH_FId.DFC_rbr_safoutChnl12OR_CA DINH_FId.DFC_rbr_safoutChnl13_CA DINH_FId.DFC_rbr_safoutChnl13Dev_CA
      DINH_FId.DFC_rbr_safoutChnl13OR_CA DINH_FId.DFC_rbr_safoutChnl14_CA DINH_FId.DFC_rbr_safoutChnl14Dev_CA DINH_FId.DFC_rbr_safoutChnl14OR_CA DINH_FId.DFC_rbr_safoutChnl15_CA DINH_FId.DFC_rbr_safoutChnl15Dev_CA
      DINH_FId.DFC_rbr_safoutChnl15OR_CA DINH_FId.DFC_rbr_safoutChnl16_CA DINH_FId.DFC_rbr_safoutChnl16Dev_CA DINH_FId.DFC_rbr_safoutChnl16OR_CA DINH_FId.DFC_rbr_safoutChnl17_CA DINH_FId.DFC_rbr_safoutChnl17Dev_CA
      DINH_FId.DFC_rbr_safoutChnl17OR_CA DINH_FId.DFC_rbr_safoutChnl18_CA DINH_FId.DFC_rbr_safoutChnl18Dev_CA DINH_FId.DFC_rbr_safoutChnl18OR_CA DINH_FId.DFC_rbr_safoutChnl1Dev_CA DINH_FId.DFC_rbr_safoutChnl1OR_CA
      DINH_FId.DFC_rbr_safoutChnl2_CA DINH_FId.DFC_rbr_safoutChnl2Dev_CA DINH_FId.DFC_rbr_safoutChnl2OR_CA DINH_FId.DFC_rbr_safoutChnl3_CA DINH_FId.DFC_rbr_safoutChnl3Dev_CA DINH_FId.DFC_rbr_safoutChnl3OR_CA
      DINH_FId.DFC_rbr_safoutChnl4_CA DINH_FId.DFC_rbr_safoutChnl4Dev_CA DINH_FId.DFC_rbr_safoutChnl4OR_CA DINH_FId.DFC_rbr_safoutChnl5_CA DINH_FId.DFC_rbr_safoutChnl5Dev_CA DINH_FId.DFC_rbr_safoutChnl5OR_CA
      DINH_FId.DFC_rbr_safoutChnl6_CA DINH_FId.DFC_rbr_safoutChnl6Dev_CA DINH_FId.DFC_rbr_safoutChnl6OR_CA DINH_FId.DFC_rbr_safoutChnl7_CA DINH_FId.DFC_rbr_safoutChnl7Dev_CA DINH_FId.DFC_rbr_safoutChnl7OR_CA
      DINH_FId.DFC_rbr_safoutChnl8_CA DINH_FId.DFC_rbr_safoutChnl8Dev_CA DINH_FId.DFC_rbr_safoutChnl8OR_CA DINH_FId.DFC_rbr_safoutChnl9_CA DINH_FId.DFC_rbr_safoutChnl9Dev_CA DINH_FId.DFC_rbr_safoutChnl9OR_CA
      DINH_FId.DFC_rbr_safoutDevError_CA DINH_FId.DFC_rbr_safoutGetStatus_CA DINH_FId.DFC_rbr_safoutIgnoreError_CA DINH_FId.DFC_rbr_safoutResetError_CA DINH_FId.DFC_rbr_safoutUnlock_CA DINH_FId.DFC_rbr_safout_cfgDiag_CA
      DINH_FId.DFC_rbr_secAccessDenied_RC_CA DINH_FId.DFC_rbr_secAccessDenied_WDBI_CA DINH_FId.DFC_rbr_secEvalRespKey_CA DINH_FId.DFC_rbr_secFlashingFailure_CA DINH_FId.DFC_rbr_secGetLevel_CA DINH_FId.DFC_rbr_secGetRnd_CA
      DINH_FId.DFC_rbr_secGetSeed_CA DINH_FId.DFC_rbr_secInvalidPassword_CA DINH_FId.DFC_rbr_secIsRequestAllowed_CA DINH_FId.DFC_rbr_secResetLevel_CA DINH_FId.DFC_rbr_secSaveSecret_CA DINH_FId.DFC_rbr_secSetLevel_CA
      DINH_FId.DFC_rbr_sysAit_CA DINH_FId.DFC_rbr_sysAiv_CA DINH_FId.DFC_rbr_sysDi_CA DINH_FId.DFC_rbr_sysDo_CA DINH_FId.DFC_rbr_sysGetVss_CA DINH_FId.DFC_rbr_sysInit_CA
      DINH_FId.DFC_rbr_sysOperHrIntegrityErr_CA DINH_FId.DFC_rbr_sysOperHrsSaturated_CA DINH_FId.DFC_rbr_sysSetVss_CA DINH_FId.DFC_rbr_sys_coreload_CA DINH_FId.DFC_rbr_sys_taskload_CA DINH_FId.DFC_rbr_mo_OV_VSS1_CA
      DINH_FId.DFC_rbr_mo_OV_VSS2_CA DINH_FId.DFC_rbr_mo_UV_VSS1_CA DINH_FId.DFC_rbr_mo_UV_VSS2_CA DINH_FId.DFC_CANSM_E_BUS_OFF_NETWORK_0_CA DINH_FId.DFC_CANSM_E_BUS_OFF_NETWORK_1_CA DINH_FId.DFC_CANSM_E_BUS_OFF_NETWORK_2_CA
      DINH_FId.DFC_CANSM_E_BUS_OFF_NETWORK_3_CA DINH_FId.DFC_CANTRCV_E_NO_TRCV_CONTROL_0_CA DINH_FId.DFC_CAN_E_TIMEOUT_CA DINH_FId.DFC_COMM_E_NET_START_IND_CHANNEL_0_CA DINH_FId.DFC_COMM_E_NET_START_IND_CHANNEL_1_CA DINH_FId.DFC_COMM_E_NET_START_IND_CHANNEL_2_CA
      DINH_FId.DFC_COMM_E_NET_START_IND_CHANNEL_3_CA DINH_FId.DFC_COMM_E_NET_START_IND_CHANNEL_4_CA DINH_FId.DFC_COMM_E_NET_START_IND_CHANNEL_5_CA DINH_FId.DFC_LIN_E_TIMEOUT_CA DINH_FId.DFC_rba_MultiStackTrace_Threshold_CA DINH_FId.DFC_ETH_E_ACCESS_0_CA
      DINH_FId.DFC_RBA_IOEXTLIB_KEEPALIVE_DRV_CA DINH_FId.DFC_RBA_IOEXTLIB_KEEPALIVE_INI_CA DINH_FId.DFC_rba_MRly_Diag_Stk_Event_CA DINH_FId.DFC_rba_MemDiagExtd_MemReadSngErr_CA DINH_FId.DFC_rba_MemDiag_MemReadErr_CA DINH_FId.DFC_rba_MemDiag_MemWrErr_CA
      DINH_FId.DFC_rba_SyC_IrrSwOffTrigEngRun_Event_CA DINH_FId.DFC_rba_T15_Diag_ComInVld_Event_CA DINH_FId.DFC_rba_T15_Diag_ComOff_HwOn_Event_CA DINH_FId.DFC_rba_T15_Diag_ComOn_HwOff_Event_CA DINH_FId.DFC_MOXEMM_SMU_ALM0_0_CA DINH_FId.DFC_MOXEMM_SMU_ALM0_1_CA
      DINH_FId.DFC_MOXEMM_SMU_ALM0_10_CA DINH_FId.DFC_MOXEMM_SMU_ALM0_11_CA DINH_FId.DFC_MOXEMM_SMU_ALM0_13_CA DINH_FId.DFC_MOXEMM_SMU_ALM0_14_CA DINH_FId.DFC_MOXEMM_SMU_ALM0_2_CA DINH_FId.DFC_MOXEMM_SMU_ALM0_22_CA
      DINH_FId.DFC_MOXEMM_SMU_ALM0_23_CA DINH_FId.DFC_MOXEMM_SMU_ALM0_4_CA DINH_FId.DFC_MOXEMM_SMU_ALM0_5_CA DINH_FId.DFC_MOXEMM_SMU_ALM0_7_CA DINH_FId.DFC_MOXEMM_SMU_ALM0_8_CA DINH_FId.DFC_MOXEMM_SMU_ALM10_16_CA
      DINH_FId.DFC_MOXEMM_SMU_ALM10_17_CA DINH_FId.DFC_MOXEMM_SMU_ALM10_21_CA DINH_FId.DFC_MOXEMM_SMU_ALM11_0_CA DINH_FId.DFC_MOXEMM_SMU_ALM11_1_CA DINH_FId.DFC_MOXEMM_SMU_ALM11_2_CA DINH_FId.DFC_MOXEMM_SMU_ALM11_3_CA
      DINH_FId.DFC_MOXEMM_SMU_ALM11_4_CA DINH_FId.DFC_MOXEMM_SMU_ALM11_5_CA DINH_FId.DFC_MOXEMM_SMU_ALM11_8_CA DINH_FId.DFC_MOXEMM_SMU_ALM11_9_CA DINH_FId.DFC_MOXEMM_SMU_ALM1_0_CA DINH_FId.DFC_MOXEMM_SMU_ALM1_1_CA
      DINH_FId.DFC_MOXEMM_SMU_ALM1_10_CA DINH_FId.DFC_MOXEMM_SMU_ALM1_11_CA DINH_FId.DFC_MOXEMM_SMU_ALM1_13_CA DINH_FId.DFC_MOXEMM_SMU_ALM1_14_CA DINH_FId.DFC_MOXEMM_SMU_ALM1_2_CA DINH_FId.DFC_MOXEMM_SMU_ALM1_22_CA
      DINH_FId.DFC_MOXEMM_SMU_ALM1_23_CA DINH_FId.DFC_MOXEMM_SMU_ALM1_4_CA DINH_FId.DFC_MOXEMM_SMU_ALM1_5_CA DINH_FId.DFC_MOXEMM_SMU_ALM1_7_CA DINH_FId.DFC_MOXEMM_SMU_ALM1_8_CA DINH_FId.DFC_MOXEMM_SMU_ALM21_0_CA
      DINH_FId.DFC_MOXEMM_SMU_ALM21_16_CA DINH_FId.DFC_MOXEMM_SMU_ALM21_3_CA DINH_FId.DFC_MOXEMM_SMU_ALM2_1_CA DINH_FId.DFC_MOXEMM_SMU_ALM2_10_CA DINH_FId.DFC_MOXEMM_SMU_ALM2_11_CA DINH_FId.DFC_MOXEMM_SMU_ALM2_13_CA
      DINH_FId.DFC_MOXEMM_SMU_ALM2_14_CA DINH_FId.DFC_MOXEMM_SMU_ALM2_2_CA DINH_FId.DFC_MOXEMM_SMU_ALM2_22_CA DINH_FId.DFC_MOXEMM_SMU_ALM2_23_CA DINH_FId.DFC_MOXEMM_SMU_ALM2_4_CA DINH_FId.DFC_MOXEMM_SMU_ALM2_5_CA
      DINH_FId.DFC_MOXEMM_SMU_ALM2_7_CA DINH_FId.DFC_MOXEMM_SMU_ALM2_8_CA DINH_FId.DFC_MOXEMM_SMU_ALM3_1_CA DINH_FId.DFC_MOXEMM_SMU_ALM3_10_CA DINH_FId.DFC_MOXEMM_SMU_ALM3_11_CA DINH_FId.DFC_MOXEMM_SMU_ALM3_13_CA
      DINH_FId.DFC_MOXEMM_SMU_ALM3_14_CA DINH_FId.DFC_MOXEMM_SMU_ALM3_2_CA DINH_FId.DFC_MOXEMM_SMU_ALM3_22_CA DINH_FId.DFC_MOXEMM_SMU_ALM3_23_CA DINH_FId.DFC_MOXEMM_SMU_ALM3_4_CA DINH_FId.DFC_MOXEMM_SMU_ALM3_5_CA
      DINH_FId.DFC_MOXEMM_SMU_ALM3_7_CA DINH_FId.DFC_MOXEMM_SMU_ALM3_8_CA DINH_FId.DFC_MOXEMM_SMU_ALM6_0_CA DINH_FId.DFC_MOXEMM_SMU_ALM6_11_CA DINH_FId.DFC_MOXEMM_SMU_ALM6_12_CA DINH_FId.DFC_MOXEMM_SMU_ALM6_14_CA
      DINH_FId.DFC_MOXEMM_SMU_ALM6_15_CA DINH_FId.DFC_MOXEMM_SMU_ALM6_17_CA DINH_FId.DFC_MOXEMM_SMU_ALM6_18_CA DINH_FId.DFC_MOXEMM_SMU_ALM6_2_CA DINH_FId.DFC_MOXEMM_SMU_ALM6_20_CA DINH_FId.DFC_MOXEMM_SMU_ALM6_21_CA
      DINH_FId.DFC_MOXEMM_SMU_ALM6_25_CA DINH_FId.DFC_MOXEMM_SMU_ALM6_4_CA DINH_FId.DFC_MOXEMM_SMU_ALM6_5_CA DINH_FId.DFC_MOXEMM_SMU_ALM6_7_CA DINH_FId.DFC_MOXEMM_SMU_ALM6_8_CA DINH_FId.DFC_MOXEMM_SMU_ALM7_1_CA
      DINH_FId.DFC_MOXEMM_SMU_ALM7_12_CA DINH_FId.DFC_MOXEMM_SMU_ALM7_13_CA DINH_FId.DFC_MOXEMM_SMU_ALM7_14_CA DINH_FId.DFC_MOXEMM_SMU_ALM7_15_CA DINH_FId.DFC_MOXEMM_SMU_ALM7_16_CA DINH_FId.DFC_MOXEMM_SMU_ALM7_17_CA
      DINH_FId.DFC_MOXEMM_SMU_ALM7_2_CA DINH_FId.DFC_MOXEMM_SMU_ALM7_20_CA DINH_FId.DFC_MOXEMM_SMU_ALM7_25_CA DINH_FId.DFC_MOXEMM_SMU_ALM7_26_CA DINH_FId.DFC_MOXEMM_SMU_ALM7_28_CA DINH_FId.DFC_MOXEMM_SMU_ALM7_29_CA
      DINH_FId.DFC_MOXEMM_SMU_ALM7_30_CA DINH_FId.DFC_MOXEMM_SMU_ALM7_31_CA DINH_FId.DFC_MOXEMM_SMU_ALM8_0_CA DINH_FId.DFC_MOXEMM_SMU_ALM8_1_CA DINH_FId.DFC_MOXEMM_SMU_ALM8_10_CA DINH_FId.DFC_MOXEMM_SMU_ALM8_11_CA
      DINH_FId.DFC_MOXEMM_SMU_ALM8_12_CA DINH_FId.DFC_MOXEMM_SMU_ALM8_13_CA DINH_FId.DFC_MOXEMM_SMU_ALM8_16_CA DINH_FId.DFC_MOXEMM_SMU_ALM8_18_CA DINH_FId.DFC_MOXEMM_SMU_ALM8_2_CA DINH_FId.DFC_MOXEMM_SMU_ALM8_3_CA
      DINH_FId.DFC_MOXEMM_SMU_ALM8_30_CA DINH_FId.DFC_MOXEMM_SMU_ALM8_31_CA DINH_FId.DFC_MOXEMM_SMU_ALM8_4_CA DINH_FId.DFC_MOXEMM_SMU_ALM9_0_CA DINH_FId.DFC_MOXEMM_SMU_ALM9_1_CA DINH_FId.DFC_MOXEMM_SMU_ALM9_15_CA
      DINH_FId.DFC_MOXEMM_SMU_ALM9_3_CA DINH_FId.DFC_MoCSOPICO_CA DINH_FId.DFC_MoFVarPostBldSel_CA DINH_FId.DFC_MoSysCtrlReIni_CA DINH_FId.DFC_MoXEMMHwLTMCUFW_CA DINH_FId.DFC_MoXEMMHwLTMonBIST_CA
      DINH_FId.DFC_MoXEMMHwLTRegMonTest_CA DINH_FId.DFC_MoXEMMHwLTStbySMUAlvTest_CA DINH_FId.DFC_MoXEMMHwLTTempSens_CA DINH_FId.DFC_MoXEMMHwLTUCBCfg_CA DINH_FId.DFC_OCWDAABEActv_CA DINH_FId.DFC_OCWDACom_CA
      DINH_FId.DFC_OCWDAErrPin_CA DINH_FId.DFC_SWReset_0_CA DINH_FId.DFC_SWReset_1_CA DINH_FId.DFC_SWReset_2_CA DINH_FId.DFC_bds_NoDebFault1_CA DINH_FId.DSQ_DSMInhibitAlways_CA
      DINH_FId.DSQ_ErrLmpActrMIL_CA DINH_FId.DSQ_ErrLmpActrSVS_CA DINH_FId.DSQ_StopLmp_CA DINH_FId.DSQ_T15TurnOfDly_CA DINH_FId.DSQ_WrnLmp_CA DINH_Lim.DFC_bds_TimeInRowDebFault_CA
      DINH_Lim.DFC_bds_EventInRowDebFault_CA DINH_Lim.DFC_DevLibBattUHi_CA DINH_Lim.DFC_DevLibBattULo_CA DINH_Lim.DFC_bds_TimeUpDownDebFault_CA DINH_Lim.DFC_rbr_inA13OR_CA DINH_Lim.DFC_rbr_inA13SCB_CA
      DINH_Lim.DFC_rbr_inA13SCG_CA DINH_Lim.DFC_rbr_inA14OR_CA DINH_Lim.DFC_rbr_inA14SCB_CA DINH_Lim.DFC_rbr_inA14SCG_CA DINH_Lim.DFC_rbr_inA21OR_CA DINH_Lim.DFC_rbr_inA21SCB_CA
      DINH_Lim.DFC_rbr_inA21SCG_CA DINH_Lim.DFC_rbr_inA22OR_CA DINH_Lim.DFC_rbr_inA22SCB_CA DINH_Lim.DFC_rbr_inA22SCG_CA DINH_Lim.DFC_rbr_inA23OR_CA DINH_Lim.DFC_rbr_inA23SCB_CA
      DINH_Lim.DFC_rbr_inA23SCG_CA DINH_Lim.DFC_rbr_inA24OR_CA DINH_Lim.DFC_rbr_inA24SCB_CA DINH_Lim.DFC_rbr_inA24SCG_CA DINH_Lim.DFC_rbr_inA25OR_CA DINH_Lim.DFC_rbr_inA25SCB_CA
      DINH_Lim.DFC_rbr_inA25SCG_CA DINH_Lim.DFC_rbr_inA26OR_CA DINH_Lim.DFC_rbr_inA26SCB_CA DINH_Lim.DFC_rbr_inA26SCG_CA DINH_Lim.DFC_rbr_inA27OR_CA DINH_Lim.DFC_rbr_inA27SCB_CA
      DINH_Lim.DFC_rbr_inA27SCG_CA DINH_Lim.DFC_rbr_inA28OR_CA DINH_Lim.DFC_rbr_inA28SCB_CA DINH_Lim.DFC_rbr_inA28SCG_CA DINH_Lim.DFC_rbr_inA29OR_CA DINH_Lim.DFC_rbr_inA29SCB_CA
      DINH_Lim.DFC_rbr_inA29SCG_CA DINH_Lim.DFC_rbr_inA36AicSCB_CA DINH_Lim.DFC_rbr_inA36AicSCG_CA DINH_Lim.DFC_rbr_inA36OR_CA DINH_Lim.DFC_rbr_inA36SCB_CA DINH_Lim.DFC_rbr_inA36SCG_CA
      DINH_Lim.DFC_rbr_inA36ShuntSCB_CA DINH_Lim.DFC_rbr_inA37AicSCB_CA DINH_Lim.DFC_rbr_inA37AicSCG_CA DINH_Lim.DFC_rbr_inA37OR_CA DINH_Lim.DFC_rbr_inA37SCB_CA DINH_Lim.DFC_rbr_inA37SCG_CA
      DINH_Lim.DFC_rbr_inA37ShuntSCB_CA DINH_Lim.DFC_rbr_inA38AicSCB_CA DINH_Lim.DFC_rbr_inA38AicSCG_CA DINH_Lim.DFC_rbr_inA38OR_CA DINH_Lim.DFC_rbr_inA38SCB_CA DINH_Lim.DFC_rbr_inA38SCG_CA
      DINH_Lim.DFC_rbr_inA38ShuntSCB_CA DINH_Lim.DFC_rbr_inA39AicSCB_CA DINH_Lim.DFC_rbr_inA39AicSCG_CA DINH_Lim.DFC_rbr_inA39OR_CA DINH_Lim.DFC_rbr_inA39SCB_CA DINH_Lim.DFC_rbr_inA39SCG_CA
      DINH_Lim.DFC_rbr_inA39ShuntSCB_CA DINH_Lim.DFC_rbr_inA40OR_CA DINH_Lim.DFC_rbr_inA40SCB_CA DINH_Lim.DFC_rbr_inA40SCG_CA DINH_Lim.DFC_rbr_inA41OR_CA DINH_Lim.DFC_rbr_inA41SCB_CA
      DINH_Lim.DFC_rbr_inA41SCG_CA DINH_Lim.DFC_rbr_inA42OR_CA DINH_Lim.DFC_rbr_inA42SCB_CA DINH_Lim.DFC_rbr_inA42SCG_CA DINH_Lim.DFC_rbr_inA43AicSCB_CA DINH_Lim.DFC_rbr_inA43AicSCG_CA
      DINH_Lim.DFC_rbr_inA43OR_CA DINH_Lim.DFC_rbr_inA43SCB_CA DINH_Lim.DFC_rbr_inA43SCG_CA DINH_Lim.DFC_rbr_inA43ShuntSCB_CA DINH_Lim.DFC_rbr_inA44OL_CA DINH_Lim.DFC_rbr_inA44SCB_CA
      DINH_Lim.DFC_rbr_inA44SCG_CA DINH_Lim.DFC_rbr_inA57OR_CA DINH_Lim.DFC_rbr_inA57SCB_CA DINH_Lim.DFC_rbr_inA57SCG_CA DINH_Lim.DFC_rbr_inA59OL_CA DINH_Lim.DFC_rbr_inA59SCB_CA
      DINH_Lim.DFC_rbr_inA59SCG_CA DINH_Lim.DFC_rbr_inK10OR_CA DINH_Lim.DFC_rbr_inK10SCB_CA DINH_Lim.DFC_rbr_inK10SCG_CA DINH_Lim.DFC_rbr_inK11OR_CA DINH_Lim.DFC_rbr_inK11SCB_CA
      DINH_Lim.DFC_rbr_inK11SCG_CA DINH_Lim.DFC_rbr_inK30AicSCB_CA DINH_Lim.DFC_rbr_inK30AicSCG_CA DINH_Lim.DFC_rbr_inK30OR_CA DINH_Lim.DFC_rbr_inK30SCB_CA DINH_Lim.DFC_rbr_inK30SCG_CA
      DINH_Lim.DFC_rbr_inK30ShuntSCB_CA DINH_Lim.DFC_rbr_inK31OR_CA DINH_Lim.DFC_rbr_inK31SCB_CA DINH_Lim.DFC_rbr_inK31SCG_CA DINH_Lim.DFC_rbr_inK32OR_CA DINH_Lim.DFC_rbr_inK32SCB_CA
      DINH_Lim.DFC_rbr_inK32SCG_CA DINH_Lim.DFC_rbr_inK33OR_CA DINH_Lim.DFC_rbr_inK33SCB_CA DINH_Lim.DFC_rbr_inK33SCG_CA DINH_Lim.DFC_rbr_inK34OR_CA DINH_Lim.DFC_rbr_inK34SCB_CA
      DINH_Lim.DFC_rbr_inK34SCG_CA DINH_Lim.DFC_rbr_inK35OR_CA DINH_Lim.DFC_rbr_inK35SCB_CA DINH_Lim.DFC_rbr_inK35SCG_CA DINH_Lim.DFC_rbr_inK36OR_CA DINH_Lim.DFC_rbr_inK36SCB_CA
      DINH_Lim.DFC_rbr_inK36SCG_CA DINH_Lim.DFC_rbr_inK37AicSCB_CA DINH_Lim.DFC_rbr_inK37AicSCG_CA DINH_Lim.DFC_rbr_inK37OR_CA DINH_Lim.DFC_rbr_inK37SCB_CA DINH_Lim.DFC_rbr_inK37SCG_CA
      DINH_Lim.DFC_rbr_inK37ShuntSCB_CA DINH_Lim.DFC_rbr_inK38AicSCB_CA DINH_Lim.DFC_rbr_inK38AicSCG_CA DINH_Lim.DFC_rbr_inK38OR_CA DINH_Lim.DFC_rbr_inK38SCB_CA DINH_Lim.DFC_rbr_inK38SCG_CA
      DINH_Lim.DFC_rbr_inK38ShuntSCB_CA DINH_Lim.DFC_rbr_inK39AicSCB_CA DINH_Lim.DFC_rbr_inK39AicSCG_CA DINH_Lim.DFC_rbr_inK39OR_CA DINH_Lim.DFC_rbr_inK39SCB_CA DINH_Lim.DFC_rbr_inK39SCG_CA
      DINH_Lim.DFC_rbr_inK39ShuntSCB_CA DINH_Lim.DFC_rbr_inK40AicSCB_CA DINH_Lim.DFC_rbr_inK40AicSCG_CA DINH_Lim.DFC_rbr_inK40OR_CA DINH_Lim.DFC_rbr_inK40SCB_CA DINH_Lim.DFC_rbr_inK40SCG_CA
      DINH_Lim.DFC_rbr_inK40ShuntSCB_CA DINH_Lim.DFC_rbr_inK41AicSCB_CA DINH_Lim.DFC_rbr_inK41AicSCG_CA DINH_Lim.DFC_rbr_inK41OR_CA DINH_Lim.DFC_rbr_inK41SCB_CA DINH_Lim.DFC_rbr_inK41SCG_CA
      DINH_Lim.DFC_rbr_inK41ShuntSCB_CA DINH_Lim.DFC_rbr_inK42AicSCB_CA DINH_Lim.DFC_rbr_inK42AicSCG_CA DINH_Lim.DFC_rbr_inK42OR_CA DINH_Lim.DFC_rbr_inK42SCB_CA DINH_Lim.DFC_rbr_inK42SCG_CA
      DINH_Lim.DFC_rbr_inK42ShuntSCB_CA DINH_Lim.DFC_rbr_inK43OR_CA DINH_Lim.DFC_rbr_inK43SCB_CA DINH_Lim.DFC_rbr_inK43SCG_CA DINH_Lim.DFC_rbr_inK44AicSCB_CA DINH_Lim.DFC_rbr_inK44AicSCG_CA
      DINH_Lim.DFC_rbr_inK44OR_CA DINH_Lim.DFC_rbr_inK44SCB_CA DINH_Lim.DFC_rbr_inK44SCG_CA DINH_Lim.DFC_rbr_inK44ShuntSCB_CA DINH_Lim.DFC_rbr_inK45AicSCB_CA DINH_Lim.DFC_rbr_inK45AicSCG_CA
      DINH_Lim.DFC_rbr_inK45OR_CA DINH_Lim.DFC_rbr_inK45SCB_CA DINH_Lim.DFC_rbr_inK45SCG_CA DINH_Lim.DFC_rbr_inK45ShuntSCB_CA DINH_Lim.DFC_rbr_inK52OR_CA DINH_Lim.DFC_rbr_inK52SCB_CA
      DINH_Lim.DFC_rbr_inK52SCG_CA DINH_Lim.DFC_rbr_inK53OR_CA DINH_Lim.DFC_rbr_inK53SCB_CA DINH_Lim.DFC_rbr_inK53SCG_CA DINH_Lim.DFC_rbr_inK54AicSCB_CA DINH_Lim.DFC_rbr_inK54AicSCG_CA
      DINH_Lim.DFC_rbr_inK54OR_CA DINH_Lim.DFC_rbr_inK54SCB_CA DINH_Lim.DFC_rbr_inK54SCG_CA DINH_Lim.DFC_rbr_inK54ShuntSCB_CA DINH_Lim.DFC_rbr_inK55AicSCB_CA DINH_Lim.DFC_rbr_inK55AicSCG_CA
      DINH_Lim.DFC_rbr_inK55OR_CA DINH_Lim.DFC_rbr_inK55SCB_CA DINH_Lim.DFC_rbr_inK55SCG_CA DINH_Lim.DFC_rbr_inK55ShuntSCB_CA DINH_Lim.DFC_rbr_inK56OR_CA DINH_Lim.DFC_rbr_inK56SCB_CA
      DINH_Lim.DFC_rbr_inK56SCG_CA DINH_Lim.DFC_rbr_inK57OR_CA DINH_Lim.DFC_rbr_inK57SCB_CA DINH_Lim.DFC_rbr_inK57SCG_CA DINH_Lim.DFC_rbr_inK58OR_CA DINH_Lim.DFC_rbr_inK58SCB_CA
      DINH_Lim.DFC_rbr_inK58SCG_CA DINH_Lim.DFC_rbr_inK59OR_CA DINH_Lim.DFC_rbr_inK59SCB_CA DINH_Lim.DFC_rbr_inK59SCG_CA DINH_Lim.DFC_rbr_inK60OR_CA DINH_Lim.DFC_rbr_inK60SCB_CA
      DINH_Lim.DFC_rbr_inK60SCG_CA DINH_Lim.DFC_rbr_inK61AicSCB_CA DINH_Lim.DFC_rbr_inK61AicSCG_CA DINH_Lim.DFC_rbr_inK61OR_CA DINH_Lim.DFC_rbr_inK61SCB_CA DINH_Lim.DFC_rbr_inK61SCG_CA
      DINH_Lim.DFC_rbr_inK61ShuntSCB_CA DINH_Lim.DFC_rbr_inK62OR_CA DINH_Lim.DFC_rbr_inK62SCB_CA DINH_Lim.DFC_rbr_inK62SCG_CA DINH_Lim.DFC_rbr_inK63AicSCB_CA DINH_Lim.DFC_rbr_inK63AicSCG_CA
      DINH_Lim.DFC_rbr_inK63OR_CA DINH_Lim.DFC_rbr_inK63SCB_CA DINH_Lim.DFC_rbr_inK63SCG_CA DINH_Lim.DFC_rbr_inK63ShuntSCB_CA DINH_Lim.DFC_rbr_inK64AicSCB_CA DINH_Lim.DFC_rbr_inK64AicSCG_CA
      DINH_Lim.DFC_rbr_inK64OR_CA DINH_Lim.DFC_rbr_inK64SCB_CA DINH_Lim.DFC_rbr_inK64SCG_CA DINH_Lim.DFC_rbr_inK64ShuntSCB_CA DINH_Lim.DFC_rbr_inK65AicSCB_CA DINH_Lim.DFC_rbr_inK65AicSCG_CA
      DINH_Lim.DFC_rbr_inK65OR_CA DINH_Lim.DFC_rbr_inK65SCB_CA DINH_Lim.DFC_rbr_inK65SCG_CA DINH_Lim.DFC_rbr_inK65ShuntSCB_CA DINH_Lim.DFC_rbr_inK74OR_CA DINH_Lim.DFC_rbr_inK74SCB_CA
      DINH_Lim.DFC_rbr_inK74SCG_CA DINH_Lim.DFC_rbr_inK75OR_CA DINH_Lim.DFC_rbr_inK75SCB_CA DINH_Lim.DFC_rbr_inK75SCG_CA DINH_Lim.DFC_rbr_inK76OR_CA DINH_Lim.DFC_rbr_inK76SCB_CA
      DINH_Lim.DFC_rbr_inK76SCG_CA DINH_Lim.DFC_rbr_inK77OR_CA DINH_Lim.DFC_rbr_inK77SCB_CA DINH_Lim.DFC_rbr_inK77SCG_CA DINH_Lim.DFC_rbr_inK78OR_CA DINH_Lim.DFC_rbr_inK78SCB_CA
      DINH_Lim.DFC_rbr_inK78SCG_CA DINH_Lim.DFC_rbr_mo_DvUBAT_FWs_CA DINH_Lim.DFC_rbr_mo_OVErr_VPR6_CA DINH_Lim.DFC_rbr_mo_OVWarn_VPR6_CA DINH_Lim.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3_CA DINH_Lim.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2_CA
      DINH_Lim.DFC_rbr_mo_OV_UBAT_MON_CA DINH_Lim.DFC_rbr_mo_OV_UBRM24_FLEXIN_CA DINH_Lim.DFC_rbr_mo_OV_UBRM24_LOADS_CA DINH_Lim.DFC_rbr_mo_OV_UBRM24_MON_CA DINH_Lim.DFC_rbr_mo_OV_VDD5_CA DINH_Lim.DFC_rbr_mo_OV_VDD5_IN_CA
      DINH_Lim.DFC_rbr_mo_OV_VPR6_CA DINH_Lim.DFC_rbr_mo_OV_VSS3_CA DINH_Lim.DFC_rbr_mo_OV_VSS4_CA DINH_Lim.DFC_rbr_mo_Temp1_HTErr_CA DINH_Lim.DFC_rbr_mo_Temp1_HTWarn_CA DINH_Lim.DFC_rbr_mo_Temp2_HTErr_CA
      DINH_Lim.DFC_rbr_mo_Temp2_HTWarn_CA DINH_Lim.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3_CA DINH_Lim.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2_CA DINH_Lim.DFC_rbr_mo_UV_VDD5_CA DINH_Lim.DFC_rbr_mo_UV_VDD5_IN_CA DINH_Lim.DFC_rbr_mo_UV_VPR6_CA
      DINH_Lim.DFC_rbr_mo_UV_VSS3_CA DINH_Lim.DFC_rbr_mo_UV_VSS4_CA DINH_Lim.DFC_rbr_outA01OL_CA DINH_Lim.DFC_rbr_outA01OT_CA DINH_Lim.DFC_rbr_outA01SCB_CA DINH_Lim.DFC_rbr_outA01SCG_CA
      DINH_Lim.DFC_rbr_outA02OL_CA DINH_Lim.DFC_rbr_outA02OR_CA DINH_Lim.DFC_rbr_outA02OT_CA DINH_Lim.DFC_rbr_outA02SCB_CA DINH_Lim.DFC_rbr_outA02SCG_CA DINH_Lim.DFC_rbr_outA03OL_CA
      DINH_Lim.DFC_rbr_outA03OT_CA DINH_Lim.DFC_rbr_outA03SCB_CA DINH_Lim.DFC_rbr_outA03SCG_CA DINH_Lim.DFC_rbr_outA04OL_CA DINH_Lim.DFC_rbr_outA04OT_CA DINH_Lim.DFC_rbr_outA04SCB_CA
      DINH_Lim.DFC_rbr_outA04SCG_CA DINH_Lim.DFC_rbr_outA05OL_CA DINH_Lim.DFC_rbr_outA05OR_CA DINH_Lim.DFC_rbr_outA05OT_CA DINH_Lim.DFC_rbr_outA05SCB_CA DINH_Lim.DFC_rbr_outA05SCG_CA
      DINH_Lim.DFC_rbr_outA06OL_CA DINH_Lim.DFC_rbr_outA06OR_CA DINH_Lim.DFC_rbr_outA06OT_CA DINH_Lim.DFC_rbr_outA06SCB_CA DINH_Lim.DFC_rbr_outA06SCG_CA DINH_Lim.DFC_rbr_outA07OL_CA
      DINH_Lim.DFC_rbr_outA07OT_CA DINH_Lim.DFC_rbr_outA07SCB_CA DINH_Lim.DFC_rbr_outA07SCG_CA DINH_Lim.DFC_rbr_outA08OL_CA DINH_Lim.DFC_rbr_outA08OT_CA DINH_Lim.DFC_rbr_outA08SCB_CA
      DINH_Lim.DFC_rbr_outA08SCG_CA DINH_Lim.DFC_rbr_outA09OL_CA DINH_Lim.DFC_rbr_outA09OR_CA DINH_Lim.DFC_rbr_outA09OT_CA DINH_Lim.DFC_rbr_outA09SCB_CA DINH_Lim.DFC_rbr_outA09SCG_CA
      DINH_Lim.DFC_rbr_outA10OL_CA DINH_Lim.DFC_rbr_outA10OT_CA DINH_Lim.DFC_rbr_outA10SCB_CA DINH_Lim.DFC_rbr_outA10SCG_CA DINH_Lim.DFC_rbr_outA11OL_CA DINH_Lim.DFC_rbr_outA11OT_CA
      DINH_Lim.DFC_rbr_outA11SCB_CA DINH_Lim.DFC_rbr_outA11SCG_CA DINH_Lim.DFC_rbr_outA12OR_CA DINH_Lim.DFC_rbr_outA12SCB_CA DINH_Lim.DFC_rbr_outA12SCG_CA DINH_Lim.DFC_rbr_outA16OL_CA
      DINH_Lim.DFC_rbr_outA16OT_CA DINH_Lim.DFC_rbr_outA16SCB_CA DINH_Lim.DFC_rbr_outA16SCG_CA DINH_Lim.DFC_rbr_outA17OL_CA DINH_Lim.DFC_rbr_outA17OR_CA DINH_Lim.DFC_rbr_outA17OT_CA
      DINH_Lim.DFC_rbr_outA17SCB_CA DINH_Lim.DFC_rbr_outA17SCG_CA DINH_Lim.DFC_rbr_outA18OL_CA DINH_Lim.DFC_rbr_outA18OT_CA DINH_Lim.DFC_rbr_outA18SCB_CA DINH_Lim.DFC_rbr_outA18SCG_CA
      DINH_Lim.DFC_rbr_outA19OL_CA DINH_Lim.DFC_rbr_outA19OR_CA DINH_Lim.DFC_rbr_outA19OT_CA DINH_Lim.DFC_rbr_outA19SCB_CA DINH_Lim.DFC_rbr_outA19SCG_CA DINH_Lim.DFC_rbr_outA20OL_CA
      DINH_Lim.DFC_rbr_outA20OR_CA DINH_Lim.DFC_rbr_outA20OT_CA DINH_Lim.DFC_rbr_outA20SCB_CA DINH_Lim.DFC_rbr_outA20SCG_CA DINH_Lim.DFC_rbr_outA31OL_CA DINH_Lim.DFC_rbr_outA31OR_CA
      DINH_Lim.DFC_rbr_outA31OT_CA DINH_Lim.DFC_rbr_outA31SCB_CA DINH_Lim.DFC_rbr_outA31SCG_CA DINH_Lim.DFC_rbr_outA32OL_CA DINH_Lim.DFC_rbr_outA32OR_CA DINH_Lim.DFC_rbr_outA32OT_CA
      DINH_Lim.DFC_rbr_outA32SCB_CA DINH_Lim.DFC_rbr_outA32SCG_CA DINH_Lim.DFC_rbr_outA33OL_CA DINH_Lim.DFC_rbr_outA33OR_CA DINH_Lim.DFC_rbr_outA33OT_CA DINH_Lim.DFC_rbr_outA33SCB_CA
      DINH_Lim.DFC_rbr_outA33SCG_CA DINH_Lim.DFC_rbr_outA34OL_CA DINH_Lim.DFC_rbr_outA34OR_CA DINH_Lim.DFC_rbr_outA34OT_CA DINH_Lim.DFC_rbr_outA34SCB_CA DINH_Lim.DFC_rbr_outA34SCG_CA
      DINH_Lim.DFC_rbr_outA35OL_CA DINH_Lim.DFC_rbr_outA35OR_CA DINH_Lim.DFC_rbr_outA35OT_CA DINH_Lim.DFC_rbr_outA35SCB_CA DINH_Lim.DFC_rbr_outA35SCG_CA DINH_Lim.DFC_rbr_outA46OL_CA
      DINH_Lim.DFC_rbr_outA46OR_CA DINH_Lim.DFC_rbr_outA46OT_CA DINH_Lim.DFC_rbr_outA46SCB_CA DINH_Lim.DFC_rbr_outA46SCG_CA DINH_Lim.DFC_rbr_outA47OL_CA DINH_Lim.DFC_rbr_outA47OR_CA
      DINH_Lim.DFC_rbr_outA47OT_CA DINH_Lim.DFC_rbr_outA47SCB_CA DINH_Lim.DFC_rbr_outA47SCG_CA DINH_Lim.DFC_rbr_outA48OL_CA DINH_Lim.DFC_rbr_outA48OR_CA DINH_Lim.DFC_rbr_outA48OT_CA
      DINH_Lim.DFC_rbr_outA48SCB_CA DINH_Lim.DFC_rbr_outA48SCG_CA DINH_Lim.DFC_rbr_outA49OL_CA DINH_Lim.DFC_rbr_outA49OT_CA DINH_Lim.DFC_rbr_outA49SCB_CA DINH_Lim.DFC_rbr_outA49SCG_CA
      DINH_Lim.DFC_rbr_outA50OL_CA DINH_Lim.DFC_rbr_outA50OT_CA DINH_Lim.DFC_rbr_outA50SCB_CA DINH_Lim.DFC_rbr_outA50SCG_CA DINH_Lim.DFC_rbr_outA51OL_CA DINH_Lim.DFC_rbr_outA51OR_CA
      DINH_Lim.DFC_rbr_outA51OT_CA DINH_Lim.DFC_rbr_outA51SCB_CA DINH_Lim.DFC_rbr_outA51SCG_CA DINH_Lim.DFC_rbr_outA52OL_CA DINH_Lim.DFC_rbr_outA52OR_CA DINH_Lim.DFC_rbr_outA52OT_CA
      DINH_Lim.DFC_rbr_outA52SCB_CA DINH_Lim.DFC_rbr_outA52SCG_CA DINH_Lim.DFC_rbr_outA53OL_CA DINH_Lim.DFC_rbr_outA53OR_CA DINH_Lim.DFC_rbr_outA53OT_CA DINH_Lim.DFC_rbr_outA53SCB_CA
      DINH_Lim.DFC_rbr_outA53SCG_CA DINH_Lim.DFC_rbr_outA54OL_CA DINH_Lim.DFC_rbr_outA54OR_CA DINH_Lim.DFC_rbr_outA54OT_CA DINH_Lim.DFC_rbr_outA54SCB_CA DINH_Lim.DFC_rbr_outA54SCG_CA
      DINH_Lim.DFC_rbr_outA55OL_CA DINH_Lim.DFC_rbr_outA55OT_CA DINH_Lim.DFC_rbr_outA55SCB_CA DINH_Lim.DFC_rbr_outA55SCG_CA DINH_Lim.DFC_rbr_outA56OL_CA DINH_Lim.DFC_rbr_outA56OT_CA
      DINH_Lim.DFC_rbr_outA56SCB_CA DINH_Lim.DFC_rbr_outA56SCG_CA DINH_Lim.DFC_rbr_outA58OL_CA DINH_Lim.DFC_rbr_outA58OT_CA DINH_Lim.DFC_rbr_outA58SCB_CA DINH_Lim.DFC_rbr_outA58SCG_CA
      DINH_Lim.DFC_rbr_outK07OL_CA DINH_Lim.DFC_rbr_outK07OR_CA DINH_Lim.DFC_rbr_outK07OT_CA DINH_Lim.DFC_rbr_outK07SCB_CA DINH_Lim.DFC_rbr_outK07SCG_CA DINH_Lim.DFC_rbr_outK08OL_CA
      DINH_Lim.DFC_rbr_outK08OR_CA DINH_Lim.DFC_rbr_outK08OT_CA DINH_Lim.DFC_rbr_outK08SCB_CA DINH_Lim.DFC_rbr_outK08SCG_CA DINH_Lim.DFC_rbr_outK09OL_CA DINH_Lim.DFC_rbr_outK09OR_CA
      DINH_Lim.DFC_rbr_outK09OT_CA DINH_Lim.DFC_rbr_outK09SCB_CA DINH_Lim.DFC_rbr_outK09SCG_CA DINH_Lim.DFC_rbr_outK12OL_CA DINH_Lim.DFC_rbr_outK12OT_CA DINH_Lim.DFC_rbr_outK12SCB_CA
      DINH_Lim.DFC_rbr_outK12SCG_CA DINH_Lim.DFC_rbr_outK13OL_CA DINH_Lim.DFC_rbr_outK13OT_CA DINH_Lim.DFC_rbr_outK13SCB_CA DINH_Lim.DFC_rbr_outK13SCG_CA DINH_Lim.DFC_rbr_outK14OL_CA
      DINH_Lim.DFC_rbr_outK14OR_CA DINH_Lim.DFC_rbr_outK14OT_CA DINH_Lim.DFC_rbr_outK14SCB_CA DINH_Lim.DFC_rbr_outK14SCG_CA DINH_Lim.DFC_rbr_outK15OL_CA DINH_Lim.DFC_rbr_outK15OR_CA
      DINH_Lim.DFC_rbr_outK15OT_CA DINH_Lim.DFC_rbr_outK15SCB_CA DINH_Lim.DFC_rbr_outK15SCG_CA DINH_Lim.DFC_rbr_outK16OL_CA DINH_Lim.DFC_rbr_outK16OR_CA DINH_Lim.DFC_rbr_outK16OT_CA
      DINH_Lim.DFC_rbr_outK16SCB_CA DINH_Lim.DFC_rbr_outK16SCG_CA DINH_Lim.DFC_rbr_outK17OL_CA DINH_Lim.DFC_rbr_outK17OR_CA DINH_Lim.DFC_rbr_outK17OT_CA DINH_Lim.DFC_rbr_outK17SCB_CA
      DINH_Lim.DFC_rbr_outK17SCG_CA DINH_Lim.DFC_rbr_outK25OR_CA DINH_Lim.DFC_rbr_outK25SCB_CA DINH_Lim.DFC_rbr_outK25SCG_CA DINH_Lim.DFC_rbr_outK29OL_CA DINH_Lim.DFC_rbr_outK29OR_CA
      DINH_Lim.DFC_rbr_outK29OT_CA DINH_Lim.DFC_rbr_outK29SCB_CA DINH_Lim.DFC_rbr_outK29SCG_CA DINH_Lim.DFC_rbr_outK51OL_CA DINH_Lim.DFC_rbr_outK51OT_CA DINH_Lim.DFC_rbr_outK51SCB_CA
      DINH_Lim.DFC_rbr_outK51SCG_CA DINH_Lim.DFC_rbr_outK62OR_CA DINH_Lim.DFC_rbr_outK62SCB_CA DINH_Lim.DFC_rbr_outK62SCG_CA DINH_Lim.DFC_rbr_outK73OL_CA DINH_Lim.DFC_rbr_outK73OR_CA
      DINH_Lim.DFC_rbr_outK73OT_CA DINH_Lim.DFC_rbr_outK73SCB_CA DINH_Lim.DFC_rbr_outK73SCG_CA DINH_Lim.DFC_rbr_outK80OL_CA DINH_Lim.DFC_rbr_outK80OT_CA DINH_Lim.DFC_rbr_outK80SCB_CA
      DINH_Lim.DFC_rbr_outK80SCG_CA DINH_Lim.DFC_rbr_outK81OL_CA DINH_Lim.DFC_rbr_outK81OT_CA DINH_Lim.DFC_rbr_outK81SCB_CA DINH_Lim.DFC_rbr_outK81SCG_CA DINH_Lim.DFC_rbr_outK82OL_CA
      DINH_Lim.DFC_rbr_outK82OT_CA DINH_Lim.DFC_rbr_outK82SCB_CA DINH_Lim.DFC_rbr_outK82SCG_CA DINH_Lim.DFC_rbr_outK83OL_CA DINH_Lim.DFC_rbr_outK83OT_CA DINH_Lim.DFC_rbr_outK83SCB_CA
      DINH_Lim.DFC_rbr_outK83SCG_CA DINH_Lim.DFC_rbr_outK84OL_CA DINH_Lim.DFC_rbr_outK84OT_CA DINH_Lim.DFC_rbr_outK84SCB_CA DINH_Lim.DFC_rbr_outK84SCG_CA DINH_Lim.DFC_rbr_outK85OL_CA
      DINH_Lim.DFC_rbr_outK85OT_CA DINH_Lim.DFC_rbr_outK85SCB_CA DINH_Lim.DFC_rbr_outK85SCG_CA DINH_Lim.DFC_rbr_outK86OL_CA DINH_Lim.DFC_rbr_outK86OT_CA DINH_Lim.DFC_rbr_outK86SCB_CA
      DINH_Lim.DFC_rbr_outK86SCG_CA DINH_Lim.DFC_rbr_outK87OL_CA DINH_Lim.DFC_rbr_outK87OT_CA DINH_Lim.DFC_rbr_outK87SCB_CA DINH_Lim.DFC_rbr_outK87SCG_CA DINH_Lim.DFC_bds_EventUpDownDebFault_CA
      DINH_Lim.DFC_DSMDummy_CA DINH_Lim.DFC_rbr_canGetDataNoBuf_CA DINH_Lim.DFC_rbr_canGetDataParam_CA DINH_Lim.DFC_rbr_canGetDataboxNoInit_CA DINH_Lim.DFC_rbr_canGetDataboxParam_CA DINH_Lim.DFC_rbr_canGetRxBufStatusParam_CA
      DINH_Lim.DFC_rbr_canGetStatusParam_CA DINH_Lim.DFC_rbr_canGetTxBufStatusParam_CA DINH_Lim.DFC_rbr_canInitParam_CA DINH_Lim.DFC_rbr_canInitRxDataboxOverlap_CA DINH_Lim.DFC_rbr_canInitRxDataboxParam_CA DINH_Lim.DFC_rbr_canInitTxDataboxParam_CA
      DINH_Lim.DFC_rbr_canIpduGroupControl_CA DINH_Lim.DFC_rbr_canIsDataboxFreeNoInit_CA DINH_Lim.DFC_rbr_canIsDataboxFreeParam_CA DINH_Lim.DFC_rbr_canIsTxEmptyParam_CA DINH_Lim.DFC_rbr_canRegBusOffCallbInvState_CA DINH_Lim.DFC_rbr_canRegBusOffCallbParam_CA
      DINH_Lim.DFC_rbr_canRegRxBufInvState_CA DINH_Lim.DFC_rbr_canRegRxBufOverlap_CA DINH_Lim.DFC_rbr_canRegRxBufParam_CA DINH_Lim.DFC_rbr_canRegRxCallbInvState_CA DINH_Lim.DFC_rbr_canRegRxCallbParam_CA DINH_Lim.DFC_rbr_canRegRxDataboxInvNumb_CA
      DINH_Lim.DFC_rbr_canRegRxDataboxInvState_CA DINH_Lim.DFC_rbr_canRegRxDataboxOverlap_CA DINH_Lim.DFC_rbr_canRegRxDataboxParam_CA DINH_Lim.DFC_rbr_canRegTxBufInvState_CA DINH_Lim.DFC_rbr_canRegTxBufOverlap_CA DINH_Lim.DFC_rbr_canRegTxBufParam_CA
      DINH_Lim.DFC_rbr_canRegTxDataboxInvNumb_CA DINH_Lim.DFC_rbr_canRegTxDataboxInvState_CA DINH_Lim.DFC_rbr_canRegTxDataboxOverlap_CA DINH_Lim.DFC_rbr_canRegTxDataboxParam_CA DINH_Lim.DFC_rbr_canResetTxBufParam_CA DINH_Lim.DFC_rbr_canSendDataBufOvfl_CA
      DINH_Lim.DFC_rbr_canSendDataParam_CA DINH_Lim.DFC_rbr_canSendDataboxNoInit_CA DINH_Lim.DFC_rbr_canSendDataboxParam_CA DINH_Lim.DFC_rbr_canSetTxCycleParam_CA DINH_Lim.DFC_rbr_canStartParam_CA DINH_Lim.DFC_rbr_canStopParam_CA
      DINH_Lim.DFC_rbr_can_ClearIpduGroup_CA DINH_Lim.DFC_rbr_can_ReceiveSignal_CA DINH_Lim.DFC_rbr_can_SendSignal_CA DINH_Lim.DFC_rbr_can_SetIpduGroup_CA DINH_Lim.DFC_rbr_dsmDTCJ1939_CA DINH_Lim.DFC_rbr_dsmDelDTCJ1939_CA
      DINH_Lim.DFC_rbr_dsmDelErrors_CA DINH_Lim.DFC_rbr_dsmGetDFES_CA DINH_Lim.DFC_rbr_dsmGetDTCJ1939_CA DINH_Lim.DFC_rbr_dsmGetErrors_CA DINH_Lim.DFC_rbr_dsmGetNumErrors_CA DINH_Lim.DFC_rbr_dsmInitQueueOverflow_CA
      DINH_Lim.DFC_rbr_dsmNumDTCJ1939_CA DINH_Lim.DFC_rbr_dsmTesterror_CA DINH_Lim.DFC_rbr_dsmUpdateDebError_CA DINH_Lim.DFC_rbr_dsmUpdateError_CA DINH_Lim.DFC_rbr_dsmgetDFCStatus_CA DINH_Lim.DFC_rbr_dsmtestErrorDFC_CA
      DINH_Lim.DFC_rbr_inAi_CA DINH_Lim.DFC_rbr_inAic_CA DINH_Lim.DFC_rbr_inAicCfg_CA DINH_Lim.DFC_rbr_inAicGetStatus_CA DINH_Lim.DFC_rbr_inAid_CA DINH_Lim.DFC_rbr_inAidCfg_CA
      DINH_Lim.DFC_rbr_inAiv_CA DINH_Lim.DFC_rbr_inAivCfg_CA DINH_Lim.DFC_rbr_inAivGetStatus_CA DINH_Lim.DFC_rbr_inDi_CA DINH_Lim.DFC_rbr_inFi_CA DINH_Lim.DFC_rbr_inFiCfg_CA
      DINH_Lim.DFC_rbr_inFiGetStatus_CA DINH_Lim.DFC_rbr_inFi_Buffered_CA DINH_Lim.DFC_rbr_inPhase_CA DINH_Lim.DFC_rbr_inPhaseGetStatus_CA DINH_Lim.DFC_rbr_inPhaseResetCounter_CA DINH_Lim.DFC_rbr_inRi_CA
      DINH_Lim.DFC_rbr_inRiCfg_CA DINH_Lim.DFC_rbr_inRiCfgTemp_CA DINH_Lim.DFC_rbr_inRiGetStatus_CA DINH_Lim.DFC_rbr_inRiGetTemp_CA DINH_Lim.DFC_rbr_inSentCopyFDFifo_CA DINH_Lim.DFC_rbr_inSentDisable_CA
      DINH_Lim.DFC_rbr_inSentEnable_CA DINH_Lim.DFC_rbr_inSentGetErrorStatus_CA DINH_Lim.DFC_rbr_inSentGetFD_CA DINH_Lim.DFC_rbr_inSentGetSD_CA DINH_Lim.DFC_rbr_inSentGetSDDatabox_CA DINH_Lim.DFC_rbr_inSentGetStatus_CA
      DINH_Lim.DFC_rbr_inSentInitSDDatabox_CA DINH_Lim.DFC_rbr_inSentRegisterCopyFDFifo_CA DINH_Lim.DFC_rbr_inSentRegisterFDFifo_CA DINH_Lim.DFC_rbr_inSentRegisterSDDataboxes_CA DINH_Lim.DFC_rbr_isobusCanRxBufferOverflow_CA DINH_Lim.DFC_rbr_isobusGetCaAddrParam_CA
      DINH_Lim.DFC_rbr_isobusGetDiagnosticParam_CA DINH_Lim.DFC_rbr_isobusGetRxDataboxStatusParam_CA DINH_Lim.DFC_rbr_isobusGetStatusParam_CA DINH_Lim.DFC_rbr_isobusInitCommCaMissing_CA DINH_Lim.DFC_rbr_isobusInitCommParam_CA DINH_Lim.DFC_rbr_isobusInitCommState_CA
      DINH_Lim.DFC_rbr_isobusInitDiagnosticParam_CA DINH_Lim.DFC_rbr_isobusInitFailureListParam_CA DINH_Lim.DFC_rbr_isobusInitRxDataboxParam_CA DINH_Lim.DFC_rbr_isobusInitTxDataboxParam_CA DINH_Lim.DFC_rbr_isobusRegRxDataboxOverlap_CA DINH_Lim.DFC_rbr_isobusRegRxDataboxParam_CA
      DINH_Lim.DFC_rbr_isobusRegRxDataboxState_CA DINH_Lim.DFC_rbr_isobusRegTxDataboxOverlap_CA DINH_Lim.DFC_rbr_isobusRegTxDataboxParam_CA DINH_Lim.DFC_rbr_isobusRegTxDataboxState_CA DINH_Lim.DFC_rbr_isobusRegisterErrClrCallbackParam_CA DINH_Lim.DFC_rbr_isobusRegisterInstancesOverlap_CA
      DINH_Lim.DFC_rbr_isobusRegisterInstancesParam_CA DINH_Lim.DFC_rbr_isobusRegisterInstancesState_CA DINH_Lim.DFC_rbr_isobusSendDataboxParam_CA DINH_Lim.DFC_rbr_isobusSendRequestPGNParam_CA DINH_Lim.DFC_rbr_isobusSetCaAddrCaUsed_CA DINH_Lim.DFC_rbr_isobusSetCaAddrComm_CA
      DINH_Lim.DFC_rbr_isobusSetCaAddrInvCan_CA DINH_Lim.DFC_rbr_isobusSetCaAddrParam_CA DINH_Lim.DFC_rbr_isobusSetCaInfoParam_CA DINH_Lim.DFC_rbr_isobusSetCaNameParam_CA DINH_Lim.DFC_rbr_isobusSftyCanTxErr_CA DINH_Lim.DFC_rbr_lin_ReceiveSignal_CA
      DINH_Lim.DFC_rbr_lin_SendSignal_CA DINH_Lim.DFC_rbr_lin_getStatus_CA DINH_Lim.DFC_rbr_lin_gotoSleep_CA DINH_Lim.DFC_rbr_lin_scheduleRequest_CA DINH_Lim.DFC_rbr_lin_wakeUp_CA DINH_Lim.DFC_rbr_memFlsCfgShr_CA
      DINH_Lim.DFC_rbr_memGetStatus_CA DINH_Lim.DFC_rbr_memMarkBlock_CA DINH_Lim.DFC_rbr_memReadApi1Error_CA DINH_Lim.DFC_rbr_memReadApi2Error_CA DINH_Lim.DFC_rbr_memReadBlock_CA DINH_Lim.DFC_rbr_memReadCalibInputError_CA
      DINH_Lim.DFC_rbr_memReadCalibOuputError_CA DINH_Lim.DFC_rbr_memReadSystemError_CA DINH_Lim.DFC_rbr_memWriteBlock_CA DINH_Lim.DFC_rbr_moOV_FirstConstADC_CA DINH_Lim.DFC_rbr_moOV_SecondConstADC_CA DINH_Lim.DFC_rbr_moUV_FirstConstADC_CA
      DINH_Lim.DFC_rbr_moUV_SecondConstADC_CA DINH_Lim.DFC_rbr_mo_INH_CA DINH_Lim.DFC_rbr_mo_INHLatch_CA DINH_Lim.DFC_rbr_mo_adcPDD_fail_CA DINH_Lim.DFC_rbr_mo_memoryProtection_err_CA DINH_Lim.DFC_rbr_outA02OC_CA
      DINH_Lim.DFC_rbr_outA02Unintended_CA DINH_Lim.DFC_rbr_outA03OC_CA DINH_Lim.DFC_rbr_outA03Unintended_CA DINH_Lim.DFC_rbr_outA04OC_CA DINH_Lim.DFC_rbr_outA04Unintended_CA DINH_Lim.DFC_rbr_outA05OC_CA
      DINH_Lim.DFC_rbr_outA05Unintended_CA DINH_Lim.DFC_rbr_outA07OC_CA DINH_Lim.DFC_rbr_outA07Unintended_CA DINH_Lim.DFC_rbr_outA08OC_CA DINH_Lim.DFC_rbr_outA08Unintended_CA DINH_Lim.DFC_rbr_outA09OC_CA
      DINH_Lim.DFC_rbr_outA09Unintended_CA DINH_Lim.DFC_rbr_outA10OC_CA DINH_Lim.DFC_rbr_outA10Unintended_CA DINH_Lim.DFC_rbr_outA17OC_CA DINH_Lim.DFC_rbr_outA17Unintended_CA DINH_Lim.DFC_rbr_outA18OC_CA
      DINH_Lim.DFC_rbr_outA18Unintended_CA DINH_Lim.DFC_rbr_outA19OC_CA DINH_Lim.DFC_rbr_outA19Unintended_CA DINH_Lim.DFC_rbr_outA20OC_CA DINH_Lim.DFC_rbr_outA20Unintended_CA DINH_Lim.DFC_rbr_outA31OC_CA
      DINH_Lim.DFC_rbr_outA31Unintended_CA DINH_Lim.DFC_rbr_outA32OC_CA DINH_Lim.DFC_rbr_outA32Unintended_CA DINH_Lim.DFC_rbr_outA33OC_CA DINH_Lim.DFC_rbr_outA33Unintended_CA DINH_Lim.DFC_rbr_outA34OC_CA
      DINH_Lim.DFC_rbr_outA34Unintended_CA DINH_Lim.DFC_rbr_outA35OC_CA DINH_Lim.DFC_rbr_outA35Unintended_CA DINH_Lim.DFC_rbr_outA46OC_CA DINH_Lim.DFC_rbr_outA46Unintended_CA DINH_Lim.DFC_rbr_outA47OC_CA
      DINH_Lim.DFC_rbr_outA47Unintended_CA DINH_Lim.DFC_rbr_outA48OC_CA DINH_Lim.DFC_rbr_outA48Unintended_CA DINH_Lim.DFC_rbr_outA51OC_CA DINH_Lim.DFC_rbr_outA51Unintended_CA DINH_Lim.DFC_rbr_outA52OC_CA
      DINH_Lim.DFC_rbr_outA52Unintended_CA DINH_Lim.DFC_rbr_outA53OC_CA DINH_Lim.DFC_rbr_outA53Unintended_CA DINH_Lim.DFC_rbr_outA54OC_CA DINH_Lim.DFC_rbr_outA54Unintended_CA DINH_Lim.DFC_rbr_outAov_CA
      DINH_Lim.DFC_rbr_outAovCfg_CA DINH_Lim.DFC_rbr_outAovCfgPI_CA DINH_Lim.DFC_rbr_outAovGetStatus_CA DINH_Lim.DFC_rbr_outAovGetVoltage_CA DINH_Lim.DFC_rbr_outAovResetError_CA DINH_Lim.DFC_rbr_outDo_CA
      DINH_Lim.DFC_rbr_outDoCfgPwrLs_CA DINH_Lim.DFC_rbr_outDoDisable_CA DINH_Lim.DFC_rbr_outDoGetCurrent_CA DINH_Lim.DFC_rbr_outDoGetStatus_CA DINH_Lim.DFC_rbr_outDoResetError_CA DINH_Lim.DFC_rbr_outK07OC_CA
      DINH_Lim.DFC_rbr_outK07Unintended_CA DINH_Lim.DFC_rbr_outK08OC_CA DINH_Lim.DFC_rbr_outK08Unintended_CA DINH_Lim.DFC_rbr_outK09OC_CA DINH_Lim.DFC_rbr_outK09Unintended_CA DINH_Lim.DFC_rbr_outK12OC_CA
      DINH_Lim.DFC_rbr_outK12Unintended_CA DINH_Lim.DFC_rbr_outK13OC_CA DINH_Lim.DFC_rbr_outK13Unintended_CA DINH_Lim.DFC_rbr_outK14OC_CA DINH_Lim.DFC_rbr_outK14Unintended_CA DINH_Lim.DFC_rbr_outK15OC_CA
      DINH_Lim.DFC_rbr_outK15Unintended_CA DINH_Lim.DFC_rbr_outK16OC_CA DINH_Lim.DFC_rbr_outK16Unintended_CA DINH_Lim.DFC_rbr_outK17OC_CA DINH_Lim.DFC_rbr_outK17Unintended_CA DINH_Lim.DFC_rbr_outK29OC_CA
      DINH_Lim.DFC_rbr_outK29Unintended_CA DINH_Lim.DFC_rbr_outK51OC_CA DINH_Lim.DFC_rbr_outK51Unintended_CA DINH_Lim.DFC_rbr_outK73OC_CA DINH_Lim.DFC_rbr_outK73Unintended_CA DINH_Lim.DFC_rbr_outPo_CA
      DINH_Lim.DFC_rbr_outPoCfg_CA DINH_Lim.DFC_rbr_outPoCfgPeriod_CA DINH_Lim.DFC_rbr_outPoCfgPwrLs_CA DINH_Lim.DFC_rbr_outPoDisable_CA DINH_Lim.DFC_rbr_outPoGetCurrent_CA DINH_Lim.DFC_rbr_outPoGetStatus_CA
      DINH_Lim.DFC_rbr_outPoResetError_CA DINH_Lim.DFC_rbr_outPoc_CA DINH_Lim.DFC_rbr_outPocCfg_CA DINH_Lim.DFC_rbr_outPocCfgDither_CA DINH_Lim.DFC_rbr_outPocCfgPI_CA DINH_Lim.DFC_rbr_outPod_CA
      DINH_Lim.DFC_rbr_outPodCfg_CA DINH_Lim.DFC_rbr_outPodCfgPeriod_CA DINH_Lim.DFC_rbr_rsmFfiApiCallErr_CA DINH_Lim.DFC_rbr_safout_CA DINH_Lim.DFC_rbr_safoutCfg_CA DINH_Lim.DFC_rbr_safoutChnl1_CA
      DINH_Lim.DFC_rbr_safoutChnl10_CA DINH_Lim.DFC_rbr_safoutChnl10Dev_CA DINH_Lim.DFC_rbr_safoutChnl10OR_CA DINH_Lim.DFC_rbr_safoutChnl11_CA DINH_Lim.DFC_rbr_safoutChnl11Dev_CA DINH_Lim.DFC_rbr_safoutChnl11OR_CA
      DINH_Lim.DFC_rbr_safoutChnl12_CA DINH_Lim.DFC_rbr_safoutChnl12Dev_CA DINH_Lim.DFC_rbr_safoutChnl12OR_CA DINH_Lim.DFC_rbr_safoutChnl13_CA DINH_Lim.DFC_rbr_safoutChnl13Dev_CA DINH_Lim.DFC_rbr_safoutChnl13OR_CA
      DINH_Lim.DFC_rbr_safoutChnl14_CA DINH_Lim.DFC_rbr_safoutChnl14Dev_CA DINH_Lim.DFC_rbr_safoutChnl14OR_CA DINH_Lim.DFC_rbr_safoutChnl15_CA DINH_Lim.DFC_rbr_safoutChnl15Dev_CA DINH_Lim.DFC_rbr_safoutChnl15OR_CA
      DINH_Lim.DFC_rbr_safoutChnl16_CA DINH_Lim.DFC_rbr_safoutChnl16Dev_CA DINH_Lim.DFC_rbr_safoutChnl16OR_CA DINH_Lim.DFC_rbr_safoutChnl17_CA DINH_Lim.DFC_rbr_safoutChnl17Dev_CA DINH_Lim.DFC_rbr_safoutChnl17OR_CA
      DINH_Lim.DFC_rbr_safoutChnl18_CA DINH_Lim.DFC_rbr_safoutChnl18Dev_CA DINH_Lim.DFC_rbr_safoutChnl18OR_CA DINH_Lim.DFC_rbr_safoutChnl1Dev_CA DINH_Lim.DFC_rbr_safoutChnl1OR_CA DINH_Lim.DFC_rbr_safoutChnl2_CA
      DINH_Lim.DFC_rbr_safoutChnl2Dev_CA DINH_Lim.DFC_rbr_safoutChnl2OR_CA DINH_Lim.DFC_rbr_safoutChnl3_CA DINH_Lim.DFC_rbr_safoutChnl3Dev_CA DINH_Lim.DFC_rbr_safoutChnl3OR_CA DINH_Lim.DFC_rbr_safoutChnl4_CA
      DINH_Lim.DFC_rbr_safoutChnl4Dev_CA DINH_Lim.DFC_rbr_safoutChnl4OR_CA DINH_Lim.DFC_rbr_safoutChnl5_CA DINH_Lim.DFC_rbr_safoutChnl5Dev_CA DINH_Lim.DFC_rbr_safoutChnl5OR_CA DINH_Lim.DFC_rbr_safoutChnl6_CA
      DINH_Lim.DFC_rbr_safoutChnl6Dev_CA DINH_Lim.DFC_rbr_safoutChnl6OR_CA DINH_Lim.DFC_rbr_safoutChnl7_CA DINH_Lim.DFC_rbr_safoutChnl7Dev_CA DINH_Lim.DFC_rbr_safoutChnl7OR_CA DINH_Lim.DFC_rbr_safoutChnl8_CA
      DINH_Lim.DFC_rbr_safoutChnl8Dev_CA DINH_Lim.DFC_rbr_safoutChnl8OR_CA DINH_Lim.DFC_rbr_safoutChnl9_CA DINH_Lim.DFC_rbr_safoutChnl9Dev_CA DINH_Lim.DFC_rbr_safoutChnl9OR_CA DINH_Lim.DFC_rbr_safoutDevError_CA
      DINH_Lim.DFC_rbr_safoutGetStatus_CA DINH_Lim.DFC_rbr_safoutIgnoreError_CA DINH_Lim.DFC_rbr_safoutResetError_CA DINH_Lim.DFC_rbr_safoutUnlock_CA DINH_Lim.DFC_rbr_safout_cfgDiag_CA DINH_Lim.DFC_rbr_secAccessDenied_RC_CA
      DINH_Lim.DFC_rbr_secAccessDenied_WDBI_CA DINH_Lim.DFC_rbr_secEvalRespKey_CA DINH_Lim.DFC_rbr_secFlashingFailure_CA DINH_Lim.DFC_rbr_secGetLevel_CA DINH_Lim.DFC_rbr_secGetRnd_CA DINH_Lim.DFC_rbr_secGetSeed_CA
      DINH_Lim.DFC_rbr_secInvalidPassword_CA DINH_Lim.DFC_rbr_secIsRequestAllowed_CA DINH_Lim.DFC_rbr_secResetLevel_CA DINH_Lim.DFC_rbr_secSaveSecret_CA DINH_Lim.DFC_rbr_secSetLevel_CA DINH_Lim.DFC_rbr_sysAit_CA
      DINH_Lim.DFC_rbr_sysAiv_CA DINH_Lim.DFC_rbr_sysDi_CA DINH_Lim.DFC_rbr_sysDo_CA DINH_Lim.DFC_rbr_sysGetVss_CA DINH_Lim.DFC_rbr_sysInit_CA DINH_Lim.DFC_rbr_sysOperHrIntegrityErr_CA
      DINH_Lim.DFC_rbr_sysOperHrsSaturated_CA DINH_Lim.DFC_rbr_sysSetVss_CA DINH_Lim.DFC_rbr_sys_coreload_CA DINH_Lim.DFC_rbr_sys_taskload_CA DINH_Lim.DFC_rbr_mo_OV_VSS1_CA DINH_Lim.DFC_rbr_mo_OV_VSS2_CA
      DINH_Lim.DFC_rbr_mo_UV_VSS1_CA DINH_Lim.DFC_rbr_mo_UV_VSS2_CA DINH_Lim.DFC_CANSM_E_BUS_OFF_NETWORK_0_CA DINH_Lim.DFC_CANSM_E_BUS_OFF_NETWORK_1_CA DINH_Lim.DFC_CANSM_E_BUS_OFF_NETWORK_2_CA DINH_Lim.DFC_CANSM_E_BUS_OFF_NETWORK_3_CA
      DINH_Lim.DFC_CANTRCV_E_NO_TRCV_CONTROL_0_CA DINH_Lim.DFC_CAN_E_TIMEOUT_CA DINH_Lim.DFC_COMM_E_NET_START_IND_CHANNEL_0_CA DINH_Lim.DFC_COMM_E_NET_START_IND_CHANNEL_1_CA DINH_Lim.DFC_COMM_E_NET_START_IND_CHANNEL_2_CA DINH_Lim.DFC_COMM_E_NET_START_IND_CHANNEL_3_CA
      DINH_Lim.DFC_COMM_E_NET_START_IND_CHANNEL_4_CA DINH_Lim.DFC_COMM_E_NET_START_IND_CHANNEL_5_CA DINH_Lim.DFC_LIN_E_TIMEOUT_CA DINH_Lim.DFC_rba_MultiStackTrace_Threshold_CA DINH_Lim.DFC_ETH_E_ACCESS_0_CA DINH_Lim.DFC_RBA_IOEXTLIB_KEEPALIVE_DRV_CA
      DINH_Lim.DFC_RBA_IOEXTLIB_KEEPALIVE_INI_CA DINH_Lim.DFC_rba_MRly_Diag_Stk_Event_CA DINH_Lim.DFC_rba_MemDiagExtd_MemReadSngErr_CA DINH_Lim.DFC_rba_MemDiag_MemReadErr_CA DINH_Lim.DFC_rba_MemDiag_MemWrErr_CA DINH_Lim.DFC_rba_SyC_IrrSwOffTrigEngRun_Event_CA
      DINH_Lim.DFC_rba_T15_Diag_ComInVld_Event_CA DINH_Lim.DFC_rba_T15_Diag_ComOff_HwOn_Event_CA DINH_Lim.DFC_rba_T15_Diag_ComOn_HwOff_Event_CA DINH_Lim.DFC_MOXEMM_SMU_ALM0_0_CA DINH_Lim.DFC_MOXEMM_SMU_ALM0_1_CA DINH_Lim.DFC_MOXEMM_SMU_ALM0_10_CA
      DINH_Lim.DFC_MOXEMM_SMU_ALM0_11_CA DINH_Lim.DFC_MOXEMM_SMU_ALM0_13_CA DINH_Lim.DFC_MOXEMM_SMU_ALM0_14_CA DINH_Lim.DFC_MOXEMM_SMU_ALM0_2_CA DINH_Lim.DFC_MOXEMM_SMU_ALM0_22_CA DINH_Lim.DFC_MOXEMM_SMU_ALM0_23_CA
      DINH_Lim.DFC_MOXEMM_SMU_ALM0_4_CA DINH_Lim.DFC_MOXEMM_SMU_ALM0_5_CA DINH_Lim.DFC_MOXEMM_SMU_ALM0_7_CA DINH_Lim.DFC_MOXEMM_SMU_ALM0_8_CA DINH_Lim.DFC_MOXEMM_SMU_ALM10_16_CA DINH_Lim.DFC_MOXEMM_SMU_ALM10_17_CA
      DINH_Lim.DFC_MOXEMM_SMU_ALM10_21_CA DINH_Lim.DFC_MOXEMM_SMU_ALM11_0_CA DINH_Lim.DFC_MOXEMM_SMU_ALM11_1_CA DINH_Lim.DFC_MOXEMM_SMU_ALM11_2_CA DINH_Lim.DFC_MOXEMM_SMU_ALM11_3_CA DINH_Lim.DFC_MOXEMM_SMU_ALM11_4_CA
      DINH_Lim.DFC_MOXEMM_SMU_ALM11_5_CA DINH_Lim.DFC_MOXEMM_SMU_ALM11_8_CA DINH_Lim.DFC_MOXEMM_SMU_ALM11_9_CA DINH_Lim.DFC_MOXEMM_SMU_ALM1_0_CA DINH_Lim.DFC_MOXEMM_SMU_ALM1_1_CA DINH_Lim.DFC_MOXEMM_SMU_ALM1_10_CA
      DINH_Lim.DFC_MOXEMM_SMU_ALM1_11_CA DINH_Lim.DFC_MOXEMM_SMU_ALM1_13_CA DINH_Lim.DFC_MOXEMM_SMU_ALM1_14_CA DINH_Lim.DFC_MOXEMM_SMU_ALM1_2_CA DINH_Lim.DFC_MOXEMM_SMU_ALM1_22_CA DINH_Lim.DFC_MOXEMM_SMU_ALM1_23_CA
      DINH_Lim.DFC_MOXEMM_SMU_ALM1_4_CA DINH_Lim.DFC_MOXEMM_SMU_ALM1_5_CA DINH_Lim.DFC_MOXEMM_SMU_ALM1_7_CA DINH_Lim.DFC_MOXEMM_SMU_ALM1_8_CA DINH_Lim.DFC_MOXEMM_SMU_ALM21_0_CA DINH_Lim.DFC_MOXEMM_SMU_ALM21_16_CA
      DINH_Lim.DFC_MOXEMM_SMU_ALM21_3_CA DINH_Lim.DFC_MOXEMM_SMU_ALM2_1_CA DINH_Lim.DFC_MOXEMM_SMU_ALM2_10_CA DINH_Lim.DFC_MOXEMM_SMU_ALM2_11_CA DINH_Lim.DFC_MOXEMM_SMU_ALM2_13_CA DINH_Lim.DFC_MOXEMM_SMU_ALM2_14_CA
      DINH_Lim.DFC_MOXEMM_SMU_ALM2_2_CA DINH_Lim.DFC_MOXEMM_SMU_ALM2_22_CA DINH_Lim.DFC_MOXEMM_SMU_ALM2_23_CA DINH_Lim.DFC_MOXEMM_SMU_ALM2_4_CA DINH_Lim.DFC_MOXEMM_SMU_ALM2_5_CA DINH_Lim.DFC_MOXEMM_SMU_ALM2_7_CA
      DINH_Lim.DFC_MOXEMM_SMU_ALM2_8_CA DINH_Lim.DFC_MOXEMM_SMU_ALM3_1_CA DINH_Lim.DFC_MOXEMM_SMU_ALM3_10_CA DINH_Lim.DFC_MOXEMM_SMU_ALM3_11_CA DINH_Lim.DFC_MOXEMM_SMU_ALM3_13_CA DINH_Lim.DFC_MOXEMM_SMU_ALM3_14_CA
      DINH_Lim.DFC_MOXEMM_SMU_ALM3_2_CA DINH_Lim.DFC_MOXEMM_SMU_ALM3_22_CA DINH_Lim.DFC_MOXEMM_SMU_ALM3_23_CA DINH_Lim.DFC_MOXEMM_SMU_ALM3_4_CA DINH_Lim.DFC_MOXEMM_SMU_ALM3_5_CA DINH_Lim.DFC_MOXEMM_SMU_ALM3_7_CA
      DINH_Lim.DFC_MOXEMM_SMU_ALM3_8_CA DINH_Lim.DFC_MOXEMM_SMU_ALM6_0_CA DINH_Lim.DFC_MOXEMM_SMU_ALM6_11_CA DINH_Lim.DFC_MOXEMM_SMU_ALM6_12_CA DINH_Lim.DFC_MOXEMM_SMU_ALM6_14_CA DINH_Lim.DFC_MOXEMM_SMU_ALM6_15_CA
      DINH_Lim.DFC_MOXEMM_SMU_ALM6_17_CA DINH_Lim.DFC_MOXEMM_SMU_ALM6_18_CA DINH_Lim.DFC_MOXEMM_SMU_ALM6_2_CA DINH_Lim.DFC_MOXEMM_SMU_ALM6_20_CA DINH_Lim.DFC_MOXEMM_SMU_ALM6_21_CA DINH_Lim.DFC_MOXEMM_SMU_ALM6_25_CA
      DINH_Lim.DFC_MOXEMM_SMU_ALM6_4_CA DINH_Lim.DFC_MOXEMM_SMU_ALM6_5_CA DINH_Lim.DFC_MOXEMM_SMU_ALM6_7_CA DINH_Lim.DFC_MOXEMM_SMU_ALM6_8_CA DINH_Lim.DFC_MOXEMM_SMU_ALM7_1_CA DINH_Lim.DFC_MOXEMM_SMU_ALM7_12_CA
      DINH_Lim.DFC_MOXEMM_SMU_ALM7_13_CA DINH_Lim.DFC_MOXEMM_SMU_ALM7_14_CA DINH_Lim.DFC_MOXEMM_SMU_ALM7_15_CA DINH_Lim.DFC_MOXEMM_SMU_ALM7_16_CA DINH_Lim.DFC_MOXEMM_SMU_ALM7_17_CA DINH_Lim.DFC_MOXEMM_SMU_ALM7_2_CA
      DINH_Lim.DFC_MOXEMM_SMU_ALM7_20_CA DINH_Lim.DFC_MOXEMM_SMU_ALM7_25_CA DINH_Lim.DFC_MOXEMM_SMU_ALM7_26_CA DINH_Lim.DFC_MOXEMM_SMU_ALM7_28_CA DINH_Lim.DFC_MOXEMM_SMU_ALM7_29_CA DINH_Lim.DFC_MOXEMM_SMU_ALM7_30_CA
      DINH_Lim.DFC_MOXEMM_SMU_ALM7_31_CA DINH_Lim.DFC_MOXEMM_SMU_ALM8_0_CA DINH_Lim.DFC_MOXEMM_SMU_ALM8_1_CA DINH_Lim.DFC_MOXEMM_SMU_ALM8_10_CA DINH_Lim.DFC_MOXEMM_SMU_ALM8_11_CA DINH_Lim.DFC_MOXEMM_SMU_ALM8_12_CA
      DINH_Lim.DFC_MOXEMM_SMU_ALM8_13_CA DINH_Lim.DFC_MOXEMM_SMU_ALM8_16_CA DINH_Lim.DFC_MOXEMM_SMU_ALM8_18_CA DINH_Lim.DFC_MOXEMM_SMU_ALM8_2_CA DINH_Lim.DFC_MOXEMM_SMU_ALM8_3_CA DINH_Lim.DFC_MOXEMM_SMU_ALM8_30_CA
      DINH_Lim.DFC_MOXEMM_SMU_ALM8_31_CA DINH_Lim.DFC_MOXEMM_SMU_ALM8_4_CA DINH_Lim.DFC_MOXEMM_SMU_ALM9_0_CA DINH_Lim.DFC_MOXEMM_SMU_ALM9_1_CA DINH_Lim.DFC_MOXEMM_SMU_ALM9_15_CA DINH_Lim.DFC_MOXEMM_SMU_ALM9_3_CA
      DINH_Lim.DFC_MoCSOPICO_CA DINH_Lim.DFC_MoFVarPostBldSel_CA DINH_Lim.DFC_MoSysCtrlReIni_CA DINH_Lim.DFC_MoXEMMHwLTMCUFW_CA DINH_Lim.DFC_MoXEMMHwLTMonBIST_CA DINH_Lim.DFC_MoXEMMHwLTRegMonTest_CA
      DINH_Lim.DFC_MoXEMMHwLTStbySMUAlvTest_CA DINH_Lim.DFC_MoXEMMHwLTTempSens_CA DINH_Lim.DFC_MoXEMMHwLTUCBCfg_CA DINH_Lim.DFC_OCWDAABEActv_CA DINH_Lim.DFC_OCWDACom_CA DINH_Lim.DFC_OCWDAErrPin_CA
      DINH_Lim.DFC_SWReset_0_CA DINH_Lim.DFC_SWReset_1_CA DINH_Lim.DFC_SWReset_2_CA DINH_Lim.DFC_bds_NoDebFault1_CA DINH_Lim.DSQ_DSMInhibitAlways_CA DINH_Lim.DSQ_ErrLmpActrMIL_CA
      DINH_Lim.DSQ_ErrLmpActrSVS_CA DINH_Lim.DSQ_StopLmp_CA DINH_Lim.DSQ_T15TurnOfDly_CA DINH_Lim.DSQ_WrnLmp_CA DINH_tiUpdObsv_C DINH_xFIDObsv_C
    /end DEF_CHARACTERISTIC
    /begin LOC_MEASUREMENT
      DINH_ctMonCorr DINH_DSQSrv7Vis DINH_FIdSrv7Vis DINH_nrActvInhReas.FId_InhibitAlways DINH_nrActvInhReas.FId_ComCILAddCond0 DINH_nrActvInhReas.FId_ComCILAddCond1
      DINH_nrActvInhReas.FId_ComCILAddCond2 DINH_nrActvInhReas.FId_ComCILAddCond3 DINH_nrActvInhReas.FId_ComNEngNPL DINH_nrActvInhReas.FId_DELibEnvP DINH_nrActvInhReas.FId_DELibEnvT DINH_nrActvInhReas.FId_DELibPRelPfilDs
      DINH_nrActvInhReas.FId_DIUMPRGenDenom1 DINH_nrActvInhReas.FId_DIUMPRGenDenom1PDTC DINH_nrActvInhReas.FId_DIUMPRGenDenom2 DINH_nrActvInhReas.FId_DIUMPRGenDenom3 DINH_nrActvInhReas.FId_DIUMPRIgn DINH_nrActvInhReas.FId_DSMWarmUpCycle
      DINH_nrActvInhReas.FId_I15031_srv9_VT_Freeze DINH_nrActvInhReas.FId_InhibitNever DINH_nrActvInhReas.FId_MILLmpPwrStg DINH_nrActvInhReas.FId_SVSLmpPwrStg DINH_nrActvInhReas.FId_StopLmpPwrStg DINH_nrActvInhReas.FId_WrnLmpPwrStg
      DINH_nrActvInhReas.Function_Id_1 DINH_nrActvInhReas.Function_Id_2 DINH_nrActvInhReas.Function_Id_3 DINH_stClctFId_mp DINH_stFId.FId_Unused DINH_stFId.FId_InhibitAlways
      DINH_stFId.FId_ComCILAddCond0 DINH_stFId.FId_ComCILAddCond1 DINH_stFId.FId_ComCILAddCond2 DINH_stFId.FId_ComCILAddCond3 DINH_stFId.FId_ComNEngNPL DINH_stFId.FId_DELibEnvP
      DINH_stFId.FId_DELibEnvT DINH_stFId.FId_DELibPRelPfilDs DINH_stFId.FId_DIUMPRGenDenom1 DINH_stFId.FId_DIUMPRGenDenom1PDTC DINH_stFId.FId_DIUMPRGenDenom2 DINH_stFId.FId_DIUMPRGenDenom3
      DINH_stFId.FId_DIUMPRIgn DINH_stFId.FId_DSMWarmUpCycle DINH_stFId.FId_I15031_srv9_VT_Freeze DINH_stFId.FId_InhibitNever DINH_stFId.FId_MILLmpPwrStg DINH_stFId.FId_SVSLmpPwrStg
      DINH_stFId.FId_StopLmpPwrStg DINH_stFId.FId_WrnLmpPwrStg DINH_stFId.Function_Id_1 DINH_stFId.Function_Id_2 DINH_stFId.Function_Id_3 DINH_stMod7VisyCmpl
      DINH_xFIDObsvInh_mp DINH_xFIDObsvRls_mp
    /end LOC_MEASUREMENT
    FUNCTION_VERSION "30017.2.0"

/end FUNCTION

/begin FUNCTION

    DIUMPR
    "30017.14.0Diagnostic In Use Monitor Performance Ratio"

    /begin DEF_CHARACTERISTIC
      DIUMPR_Check_CA DIUMPR_ctGen.l500MDInc_C DIUMPR_ctGen.l500MD_C DIUMPR_ctGen.pEnvMin_C DIUMPR_ctGen.rAPPMax_C DIUMPR_ctGen.tEnvMin_C
      DIUMPR_ctGen.tiActrMin_C DIUMPR_ctGen.tiFuEngOpMin_C DIUMPR_ctGen.tiIdlMin_C DIUMPR_ctGen.tiIgnMin_C DIUMPR_ctGen.tiOpMin_C DIUMPR_ctGen.tiSigContActv_C
      DIUMPR_ctGen.tiSigContSnglActv_C DIUMPR_ctGen.tiVehSpdMin_C DIUMPR_ctGen.vVehIdlMax_C DIUMPR_ctGen.vVehMin_C DIUMPR_ctGen.tiIgnCycMin_C DIUMPR_FID_CA
      DIUMPR_Group_CA DIUMPR_numSigActv_CA DIUMPR_stSigActv_CA DIUMPR_valSigActvMax_CA DIUMPR_valSigActvMin_CA
    /end DEF_CHARACTERISTIC
    /begin LOC_MEASUREMENT
      DIUMPR_ctDenom DIUMPR_ctGenDenom DIUMPR_ctIgn DIUMPR_ctNum DIUMPR_numIndGrp DIUMPR_rValRatMin
      DIUMPR_state DIUMPR_stEnaDenom DIUMPR_stEnaPDTC DIUMPR_stFIdGenDenom_mp DIUMPR_stProtdRamVld DIUMPR_tiCont.SigActv_0
      DIUMPR_tiCont.SigActv_1 DIUMPR_tiCont.SigActv_2 DIUMPR_tiCont.SigActv_3 DIUMPR_tiCont.SigActv_4 DIUMPR_tiCont.SigActv_5 DIUMPR_tiCont.SigActv_6
      DIUMPR_tiCont.SigActv_7 DIUMPR_tiCont.SigActv_8 DIUMPR_tiCont.SigActv_9 DIUMPR_tiCont.SigActv_10 DIUMPR_tiCont.SigActv_11 DIUMPR_tiCont.SigActv_12
      DIUMPR_tiCont.SigActv_13 DIUMPR_tiCont.SigActv_14 DIUMPR_tiCont.SigActv_15 DIUMPR_tiCont.SigActv_16 DIUMPR_tiCont.SigActv_17 DIUMPR_tiCont.SigActv_18
      DIUMPR_tiCont.SigActv_19 DIUMPR_tiCont.SigActv_20 DIUMPR_tiCont.SigActv_21 DIUMPR_tiCont.SigActv_22 DIUMPR_tiCont.SigActv_23 DIUMPR_tiCont.SigActv_24
      DIUMPR_tiCont.SigActv_25 DIUMPR_tiCont.SigActv_26 DIUMPR_tiCont.SigActv_27 DIUMPR_tiCont.SigActv_28 DIUMPR_tiCont.SigActv_29 DIUMPR_tiCont.SigActv_30
      DIUMPR_tiCont.SigActv_31 DIUMPR_tiCont.SigActv_32 DIUMPR_tiCont.SigActv_33 DIUMPR_tiCont.SigActv_34 DIUMPR_tiCont.SigActv_35 DIUMPR_tiCont.SigActv_36
      DIUMPR_tiCont.SigActv_37 DIUMPR_tiCont.SigActv_38 DIUMPR_tiCont.SigActv_39 DIUMPR_tiEngOpCum DIUMPR_tiEngOpCumPDTC DIUMPR_tiIdl
      DIUMPR_tiIdlPDTC DIUMPR_tiSigActv DIUMPR_tiVehSpdCum DIUMPR_tiVehSpdCumPDTC
    /end LOC_MEASUREMENT
    FUNCTION_VERSION "30017.14.0"

/end FUNCTION

/begin FUNCTION

    DPS_Tmp
    "100.1.0   standard powerstage diagnosis"

    /begin DEF_CHARACTERISTIC
      DPSWATCHINDEX THP TVP
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      B_PmdInit_msg
    /end IN_MEASUREMENT
    /begin LOC_MEASUREMENT
      dps_error dps_errStat dps_errStat_sum_rec dps_errStat_sum_ver dps_index dps_recoveryTime
      dps_state dps_verifyTime
    /end LOC_MEASUREMENT
    FUNCTION_VERSION "100.1.0"

/end FUNCTION

/begin FUNCTION

    DSCHED_Cal
    "1.1.0     Diagnostic Scheduler Calibration"

    /begin DEF_CHARACTERISTIC
      DSCHED_BsPrio.FId_InhibitAlways_C DSCHED_FacPhys.FId_InhibitAlways_C DSCHED_JmpActvPrio.FId_InhibitAlways_C DSCHED_LimPrio.FId_InhibitAlways_C DSCHED_RmpIniPrio.FId_InhibitAlways_C DSCHED_RmpSlpActv.FId_InhibitAlways_C
      DSCHED_RmpSlpPas.FId_InhibitAlways_C DSCHED_RmpUpLim.FId_InhibitAlways_C DSCHED_valOfsPrioOpMode_C
    /end DEF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      DSCHED_DynPrio.FId_Unused DSCHED_DynPrio.FId_InhibitAlways DSCHED_PhysPrio.FId_Unused DSCHED_PhysPrio.FId_InhibitAlways DSCHED_RmpPrio.FId_Unused DSCHED_RmpPrio.FId_InhibitAlways
    /end OUT_MEASUREMENT
    FUNCTION_VERSION "1.1.0"

/end FUNCTION

/begin FUNCTION

    DSCHED_Eval
    "30000.8.0 Diagnostic Scheduler Evaluation"

    /begin DEF_CHARACTERISTIC
      DSCHED_DrvModeMsk.FId_InhibitAlways_C DSCHED_OpModeMsk.FId_InhibitAlways_C DSCHED_stMode_C DSCHED_valDflOpMode_C
    /end DEF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      DSCHED_St.FId_Unused DSCHED_St.FId_InhibitAlways DSCHED_WhyExcl.FId_Unused DSCHED_WhyExcl.FId_InhibitAlways
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      DSCHED_stDrvMode DSCHED_stOpMode
    /end LOC_MEASUREMENT
    FUNCTION_VERSION "30000.8.0"

/end FUNCTION

/begin FUNCTION

    DSM2AUTOSAR
    "30017.18.0_RC40_MLAUTOSAR Layer to DSM"

    /begin IN_MEASUREMENT
      DFES_stErrLamp DFES_stOutstate
    /end IN_MEASUREMENT
    /begin LOC_MEASUREMENT
      Dem_BswErrorBufferWriteCounter Dem_BswErrorBufferWriteIndex Dem_PTOSt Dem_stInit
    /end LOC_MEASUREMENT
    FUNCTION_VERSION "30017.18.0_RC40_ML"

/end FUNCTION

/begin FUNCTION

    DSMAppl_FadeOut
    "30100.0.0"

    /begin DEF_CHARACTERISTIC
      DSMAppl_nEngLim2_C DSMAppl_nEngLim_C DSMAppl_tiDelAftRun_C DSMAppl_tiDelBatt_C DSMAppl_tiDelBusOff_C DSMAppl_tiDelECUInit_C
      DSMAppl_tiDelEngStrt_C DSMAppl_uBatt_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      BattU_u CoEng_st Epm_nEng T15_st
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      DSM_stFadeOut
    /end OUT_MEASUREMENT
    FUNCTION_VERSION "30100.0.0"

/end FUNCTION

/begin FUNCTION

    DSMAux
    "30017.21.0DSM Auxiliary"

    /begin DEF_CHARACTERISTIC
      DSMAUX_dtWUCMin_C DSMAUX_nEngDCSMin_C DSMAUX_tWUCMin_C DSMAUX_vVehDCSMin_C DSMAUX_xClearMode_C DSMAUX_xClearTrg_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Epm_nEng SyC_stSub
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      DSMAUX_ctObdDCy_msg DSMAUX_ctWUC DSMAUX_ctWUC_msg DSMAUX_DTRG.DTRG_Time200ms DSMAUX_DTRG.DTRG_SimilarCondHLC DSMAUX_DTRG.DTRG_DrivingCycleFLC
      DSMAUX_DTRG.DTRG_AlwaysTrue DSMAUX_DTRG.DTRG_WarmUpCycleTime DSMAUX_DTRG.DTRG_WarmUpCycle DSMAUX_DTRG.DTRG_DrivingCycleSpeed DSMAUX_DTRG.DTRG_DrivingCycleHLC DSMAUX_DTRG.DTRG_NoTrigger
      DSMAUX_DTRG.DTRG_Distance100m DSMAUX_DTRG.DTRG_TimeFLCOFFROAD DSMAUX_stDCy DSMAUX_stDCy_msg DSMAUX_stDsmClrActv DSM_TripChgAndClrFinshd
      DSM_TripChgFinshd
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      DSMAUX_ctObdDCy DSMAUX_stClrProc DSMAUX_stClrTaskFin DSMAUX_stStrtEnd DSMAUX_stTranGlbJob DSMAUX_stTranGlbRun
      DSMAUX_stTranReq DSMAUX_tClntStrt DSM_stPostDrive DSM_stReInit
    /end LOC_MEASUREMENT
    FUNCTION_VERSION "30017.21.0"

/end FUNCTION

/begin FUNCTION

    DSMDur
    "30017.12.0DSM Duration Counters"

    /begin DEF_CHARACTERISTIC
      DSMDur_valEvntQntDist_C DSMDur_valEvntQntTi_C DSMDur_xEnaGlb_CA DSMDur_xRstGlb_CA DSMDur_xSelEvntGlb_CA
    /end DEF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      DSMDur_ctGlb DSMDur_ctPID21h DSMDur_ctPID31h DSMDur_stGlb
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      DSMDur_lRef DSMDur_lRef10m DSMDur_stPID21h DSMDur_stWUCLst DSMDur_tiRef
    /end LOC_MEASUREMENT
    FUNCTION_VERSION "30017.12.0"

/end FUNCTION

/begin FUNCTION

    DSMRdy
    "30017.13.1DSM Readiness"

    /begin DEF_CHARACTERISTIC
      DSMRdy_Grp.Misf_CA DSMRdy_Grp.FlSys_CA DSMRdy_Grp.ComprCmpnt_CA DSMRdy_Grp.HCCat_CA DSMRdy_Grp.NOxCat_CA DSMRdy_Grp.BP_CA
      DSMRdy_Grp.EGSens_CA DSMRdy_Grp.PMFlt_CA DSMRdy_Grp.EGR_CA DSMRdy_X.PID1ForceLowMsk_C DSMRdy_X.PID1ForceHighMsk_C DSMRdy_X.PID41ForceLowMsk_C
      DSMRdy_X.PID41ForceHighMsk_C
    /end DEF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      DSMRdy_Why.RdyMisf_mp DSMRdy_Why.RdyFlSys_mp DSMRdy_Why.RdyComprCmpnt_mp DSMRdy_Why.RdyHCCat_mp DSMRdy_Why.RdyNOxCat_mp DSMRdy_Why.RdyResv_mp
      DSMRdy_Why.RdyBP_mp DSMRdy_Why.RdyAC_mp DSMRdy_Why.RdyEGSens_mp DSMRdy_Why.RdyPMFlt_mp DSMRdy_Why.RdyEGR_mp DSMRdy_Why.CyclCmplMisf_mp
      DSMRdy_Why.CyclCmplFlSys_mp DSMRdy_Why.CyclCmplComprCmpnt_mp DSMRdy_Why.CyclCmplHCCat_mp DSMRdy_Why.CyclCmplNOxCat_mp DSMRdy_Why.CyclCmplResv_mp DSMRdy_Why.CyclCmplBP_mp
      DSMRdy_Why.CyclCmplAC_mp DSMRdy_Why.CyclCmplEGSens_mp DSMRdy_Why.CyclCmplPMFlt_mp DSMRdy_Why.CyclCmplEGR_mp DSMRdy_Why.LockMisf_mp DSMRdy_Why.LockFlSys_mp
      DSMRdy_Why.LockComprCmpnt_mp DSMRdy_Why.LockHCCat_mp DSMRdy_Why.LockNOxCat_mp DSMRdy_Why.LockResv_mp DSMRdy_Why.LockBP_mp DSMRdy_Why.LockAC_mp
      DSMRdy_Why.LockEGSens_mp DSMRdy_Why.LockPMFlt_mp DSMRdy_Why.LockEGR_mp DSMRdy_xPId1
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      DSMRdy_stGrpRdy DSMRdy_stGrpRdyDFES DSMRdy_stGrpRdyScan DSMRdy_stGrpSup
    /end LOC_MEASUREMENT
    FUNCTION_VERSION "30017.13.1"

/end FUNCTION

/begin FUNCTION

    DSM_Conf
    "30100.0.0_RC40_LARGEDSM Kernel configuration"

    /begin IN_MEASUREMENT
      APP_r CEngDsT_t CoEng_bObdTmrInctg CoEng_tiNormalOBD CoEOM_stDSCHEDDem CoEOM_stOpModeActTSync
      CoEOM_stOpModePos CoEOM_stTransActv DSM_stFadeOut EnvP_p EnvT_t Epm_nEng
      GlbDa_lTotDst PthSet_stOvrRunCoord VehV_v
    /end IN_MEASUREMENT
    /begin LOC_MEASUREMENT
      DSM_CoEngtiNormalOBD DSM_CoEOMstOpModeActTSync DSM_CoEOMstOpModePos DSM_CoEOMstTransActv DSM_DisblMode_mp DSM_ECUId_mp
      DSM_GlbDalTotDst DSM_nEng DSM_PDTCDisbl_mp DSM_pEnv DSM_PthSetstOvrRunCoord DSM_rAPP
      DSM_stStrEnd DSM_stWiggle_mp DSM_tEngDS DSM_tEnv DSM_vVeh
    /end LOC_MEASUREMENT
    FUNCTION_VERSION "30100.0.0_RC40_LARGE"

/end FUNCTION

/begin FUNCTION

    DSM_DTRCompu
    "1.25.0    DSM DTR computation methods"

    FUNCTION_VERSION "1.25.0"

/end FUNCTION

/begin FUNCTION

    DSQ
    "30017.1.0 Diagnostic Signal Quality"

    FUNCTION_VERSION "30017.1.0"

/end FUNCTION

/begin FUNCTION

    DTR
    "30000.8.0 Diagnostic Test Results for Service 0x06"

    /begin DEF_CHARACTERISTIC
      DTR_OBDMID.DTR_Dummy_C DTR_Suprt.DTR_Dummy_C DTR_TID.DTR_Dummy_C
    /end DEF_CHARACTERISTIC
    /begin LOC_MEASUREMENT
      DTR_valLoLim.DTR_Dummy DTR_valTst.DTR_Dummy DTR_valUpLim.DTR_Dummy
    /end LOC_MEASUREMENT
    FUNCTION_VERSION "30000.8.0"

/end FUNCTION

/begin FUNCTION

    EngECU_Eng
    "387.5.0   process for calculating engine CAN messages"

    /begin DEF_CHARACTERISTIC
      ACCI_mEstimCAN_C ACCI_rSlpRoad_C ACCI_stMVeh_C ACCI_stRSlpRoad_C Brk_r_C Brk_stBrkBstWarn_C
      Brk_stExt_C CoESS_stRcpt_C Com_APP_rUnFlt_C Com_BOOST_Bauteil_Temp_C Com_BOOST_elektr_Fehler_C Com_BOOST_Fehler_CAN_Comm_C
      Com_BOOST_IstStrom_Aufnahme_C Com_BOOST_Ist_Spannung_C Com_BOOST_mech_Fehler_C Com_BOOST_QBit_Bauteil_Temp_C Com_BOOST_QBit_Ist_Strom_C Com_BOOST_Regelabweichung_C
      Com_BOOST_StromSens_KS_Masse_C Com_BOOST_StromSens_KS_Plus_C Com_BOOST_Tempsens_KS_Masse_C Com_BOOST_Tempsens_KS_Plus_C Com_BOOST_Tempsens_OpenLoad_C Com_BOOST_Uberspannung_48V_C
      Com_BOOST_Ubertemperatur_C Com_BOOST_Ueberspannung_12V_C Com_BOOST_Unterspannung_12V_C Com_BOOST_Unterspannung_48V_C Com_BOOST_Verpolung_48V_C Com_BOOST_ZyklusBit_EEPROM_C
      Com_BOOST_ZyklusBit_kont_C Com_dataEngCod0_C Com_dataEngCod1_C Com_dataEngCod2_C Com_dataEngCod3_C Com_dCANVer_C
      Com_dOilTOut_C Com_drAPPPrefilg_C Com_MO_Drehzahl_VM_C Com_MO_Fehlerstatus_Antrieb_FDR_C Com_MO_Mom_Begr_Schalt_C Com_MO_Mom_Begr_Schalt_Min_C
      Com_MO_Primaerachse_Anforderung_C Com_nEngDes_C Com_nEngMin_C Com_nEng_C Com_numCDA_C Com_numGearPos_C
      Com_pCACDs_C Com_pEnv_C Com_pwrPTC_C Com_rIncrRmn_C Com_rNOvrd_C Com_rWaPmpHeat_C
      Com_stAftRunTyp_C Com_stAirCIntv_C Com_stAPPGradSign_C Com_stAPPLowIdl_C Com_stBrkTOut_C Com_stCarTyp_C
      Com_stCDA_C Com_stClthEngNegAvl_C Com_stClthOut_C Com_stCylShOff_C Com_stDFESEntry_C Com_stEngTQBit_C
      Com_stEngTxt_C Com_stEng_C Com_stFanMuxCode_C Com_stFlConsOvrFlw_C Com_stGbxIntvLeadActv_C Com_stGearAdvPrs_C
      Com_stGearPos_C Com_stIntrLck_C Com_stKD_C Com_stMKBMux_C Com_stOilTQBit_C Com_stPFltRgnActv_C
      Com_stScrWarn_C Com_stSwsVWGearActDspl_C Com_stSysErr_C Com_stSysLmp_C Com_stTransptModeActv_C Com_stTRQ_C
      Com_stWaHtStg_C Com_swtSCRDsplEna_C Com_tEngTEng07_C Com_tEngTEng09_C Com_tIntkAirT_C Com_trqClthEngDesFlt_C
      Com_trqClthEngDes_C Com_trqClthEngLimDyn_C Com_trqClthEngLimStat_C Com_trqClthEngNegAvl_C Com_trqClthEng_C Com_trqLos_C
      CoVeh_bRollrModeActv_C CoVOM_bSailEna_C DrvPrgSwt_numCurrCAN_C DrvPrgSwt_stEffModReqd_C DrvPrgSwt_st_C EngDem_stErr_C
      ErrLmp_stMIL_b6_C FanCtl_stHotLmp_C FanCtl_stOk_C Fan_r1Ps_C Fan_r2Ps_C FlSys_volFlConsDspl_C
      HLSDem_nMaxDspl_C HLSDem_nSetPLo_C HLSDem_stNMaxWarnDspl_C LLim_stMaxActvLvlECU_C NEngInd_nOpt_C NMHigh_xSNI_C
      Oil_bPresWarn_C PFltRgn_stTxtMsg_C PhyMod_moiEng_C PhyMod_trqDynEng_C PspCtl_stFlPmpAct_C SCRCtl_stAcoustic_C
      SCRCtl_stDsplStgy_C SCRCtl_stWarnText_C SLmpCtl_rOilLvl_C SLmpCtl_stOil_C SLmpCtl_volOil_C SSEUI_stDemNoStopCanMeas_C
      SSEUI_stStrtDesCanMeas_C StrtCtl_stStrtStopDspl_C StrtCtl_stT75_C Strt_st_C StSys_stStrtDisengaFrm_C StSys_stStrtRlsFrm_C
      SWaPmp_tiHtgPmp_C SwSVW_bBrkStopReqSupp_C SwsVW_bRstrtActv_C SwsVW_bStopActv_C SwSVW_bStopReqEnaIdc_C SwsVW_bVlvGbxClgPrs_C
      SwsVW_bVlvGbxClg_C SwSVW_noSetDrvModStrtStopSwt_C SwsVW_numGearActDspl_C SwsVW_numGearDesDspl_C SwSVW_stLmpOutStrtStopSwt_C SwSVW_stStopInhIdcCordStrtStop_C
      SwSVW_stStrtReqIdcCordStrtStop_C SwSVW_stStrtStopCharStrtStopSwt_C SwsVW_stStrtStopDrv_C SwsVW_stStrtStopSys_C SwsVW_stVlvHeat_C SwsVW_stWtPmpEng_C
      WaPmp_stInfoSysExt_C
    /end DEF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      ACCI_mEstimCAN ACCI_rSlpRoad ACCI_stMVeh ACCI_stRSlpRoad Brk_r Brk_stBrkBstWarn
      Brk_stExt CoESS_stRcpt Com_APP_rUnFlt Com_BOOST_Bauteil_Temp Com_BOOST_elektr_Fehler Com_BOOST_Fehler_CAN_Comm
      Com_BOOST_IstStrom_Aufnahme Com_BOOST_Ist_Spannung Com_BOOST_mech_Fehler Com_BOOST_QBit_Bauteil_Temp Com_BOOST_QBit_Ist_Strom Com_BOOST_Regelabweichung
      Com_BOOST_StromSens_KS_Masse Com_BOOST_StromSens_KS_Plus Com_BOOST_Tempsens_KS_Masse Com_BOOST_Tempsens_KS_Plus Com_BOOST_Tempsens_OpenLoad Com_BOOST_Uberspannung_48V
      Com_BOOST_Ubertemperatur Com_BOOST_Ueberspannung_12V Com_BOOST_Unterspannung_12V Com_BOOST_Unterspannung_48V Com_BOOST_Verpolung_48V Com_BOOST_ZyklusBit_EEPROM
      Com_BOOST_ZyklusBit_kont Com_ctENG11MsgCnt Com_ctENG12V6MsgCnt Com_ctENG20MsgCnt Com_ctENG28MsgCnt Com_dataEngCod0
      Com_dataEngCod1 Com_dataEngCod2 Com_dataEngCod3 Com_dCANVer Com_dOilTOut Com_drAPPPrefilg
      Com_ENG11Chksum Com_ENG12V6Chksum Com_ENG20Chksum Com_ENG28Chksum Com_flgSwsVWGearActDspl Com_flgtrqClthEngNegAvl
      Com_MO_Drehzahl_VM Com_MO_Fehlerstatus_Antrieb_FDR Com_MO_IstMoment_VKM Com_MO_Mom_Begr_Schalt Com_MO_Mom_Begr_Schalt_Min Com_MO_Primaerachse_Anforderung
      Com_nEng Com_nEngDes Com_nEngMin Com_numCDA Com_numGearPos Com_pCACDs
      Com_pEnv Com_pwrPTC Com_rIncrRmn Com_rNOvrd Com_rWaPmpHeat Com_stAftRunTyp
      Com_stAirCIntv Com_stAPPGradSign Com_stAPPLowIdl Com_stBrkTOut Com_stCarTyp Com_stCDA
      Com_stClthOut Com_stCylShOff Com_stDFESEntry Com_stEng Com_stEngTQBit Com_stEngTxt
      Com_stFlConsOvrFlw Com_stGbxIntvLeadActv Com_stGearAdvPrs Com_stGearPos Com_stIntrLck Com_stKD
      Com_stOilTQBit Com_stPFltRgnActv Com_stSCRWarn Com_stSysErr Com_stSysLmp Com_stTransptModeActv
      Com_stTRQ Com_stWaHtStg Com_swtSCRDsplEna Com_tEngTEng07 Com_tEngTEng09 Com_tIntkAirT
      Com_trqClthEng Com_trqClthEngDes Com_trqClthEngDesFlt Com_trqClthEngLimDyn Com_trqClthEngLimStat Com_trqClthEngNegAvl
      Com_trqLos CoVeh_bRollrModeActv CoVOM_bSailEna DrvPrgSwt_numCurrCAN DrvPrgSwt_st DrvPrgSwt_stEffModReqd
      EngDem_stErr ErrLmp_stMIL_b6 FanCtl_stHotLmp FanCtl_stOk Fan_r1Ps Fan_r2Ps
      FlSys_volFlConsDspl HLSDem_nMaxDspl HLSDem_nSetPLo HLSDem_stNMaxWarnDspl LLim_stMaxActvLvlECU NEngInd_nOpt
      NMHigh_xSNI Oil_bPresWarn PFltRgn_stTxtMsg PhyMod_moiEng PhyMod_trqDynEng PspCtl_stFlPmpAct
      SCRCtl_stAcoustic SCRCtl_stDsplStgy SCRCtl_stWarnText SLmpCtl_rOilLvl SLmpCtl_stOil SLmpCtl_volOil
      SSEUI_stDemNoStopCanMeas SSEUI_stStrtDesCanMeas StrtCtl_stStrtStopDspl StrtCtl_stT75 Strt_st StSys_stStrtDisengaFrm
      StSys_stStrtRlsFrm SWaPmp_tiHtgPmp SwSVW_bBrkStopReqSupp SwsVW_bRstrtActv SwsVW_bStopActv SwSVW_bStopReqEnaIdc
      SwsVW_bVlvGbxClg SwsVW_bVlvGbxClgPrs SwSVW_noSetDrvModStrtStopSwt SwsVW_numGearActDspl SwsVW_numGearDesDspl SwSVW_stLmpOutStrtStopSwt
      SwSVW_stStopInhIdcCordStrtStop SwSVW_stStrtReqIdcCordStrtStop SwSVW_stStrtStopCharStrtStopSwt SwsVW_stStrtStopDrv SwsVW_stStrtStopSys SwsVW_stVlvHeat
      SwsVW_stWtPmpEng WaPmp_stInfoSysExt
    /end OUT_MEASUREMENT
    FUNCTION_VERSION "387.5.0"

/end FUNCTION

/begin FUNCTION

    ErrLmp_DD
    "30017.10.0Device Driver for the Error Lamps"

    /begin DEF_CHARACTERISTIC
      ErrLmpMIL_ATS.LimitTypeMsk_C ErrLmpMIL_ATS.CnvNorm_C ErrLmpMIL_ATS.LowLim_C ErrLmpMIL_ATS.UpLim_C ErrLmpMIL_ATS.CnvFac_C ErrLmpMIL_ATS.CnvOfs_C
      ErrLmpMIL_ATS.DfltVal_C ErrLmpSVS_ATS.LimitTypeMsk_C ErrLmpSVS_ATS.CnvNorm_C ErrLmpSVS_ATS.LowLim_C ErrLmpSVS_ATS.UpLim_C ErrLmpSVS_ATS.CnvFac_C
      ErrLmpSVS_ATS.CnvOfs_C ErrLmpSVS_ATS.DfltVal_C ErrLmp_MIL.nThres_C ErrLmp_MIL.tiMax_C ErrLmp_MIL.tiTst_C ErrLmp_MIL.tiDel_C
      ErrLmp_MIL.tiBln_C ErrLmp_MIL.stEna_C ErrLmp_MIL.tiFastBlink_C ErrLmp_Rdy.st_C ErrLmp_Rdy.ti_C ErrLmp_Rdy.tiBlnOn_C
      ErrLmp_Rdy.tiBlnOff_C ErrLmp_stPsMILDisbl_C ErrLmp_stPsSVSDisbl_C ErrLmp_SVS.nThres_C ErrLmp_SVS.tiMax_C ErrLmp_SVS.tiTst_C
      ErrLmp_SVS.tiDel_C ErrLmp_SVS.tiBln_C ErrLmp_SVS.stEna_C ErrLmp_SVS.tiFastBlink_C ErrLmp_swtSVSEqGlwLmp_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Com_stMILBlinkReq Com_stMILReq Com_stSVSReq DevLib_stPwrStgEnaCond DFES_stErrLamp Epm_nEng
      SyC_stSub T15_st
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      ErrLmp_stMIL ErrLmp_stMILDigOut ErrLmp_stMILReq ErrLmp_stOrdGlwLmp ErrLmp_stSVS ErrLmp_stSVSDigOut
      ErrLmp_stSVSReq
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      DSM_stMILReqd ErrLmp_stExtReqRdy ErrLmp_stMILDigOut_mp ErrLmp_stMilReqBlink ErrLmp_stMilReqContns ErrLmp_stMilReqOnDem
      ErrLmp_stMilReqSho ErrLmp_stSVSDigOut_mp
    /end LOC_MEASUREMENT
    FUNCTION_VERSION "30017.10.0"

/end FUNCTION

/begin FUNCTION

    ErrLmp_DD_TstState
    "30017.7.0 Error Lamp state machine"

    /begin IN_MEASUREMENT
      ErrLmp_stSVSReq
    /end IN_MEASUREMENT
    FUNCTION_VERSION "30017.7.0"

/end FUNCTION

/begin FUNCTION

    ESC_Stack
    "30000.15.0Functional component to provide sampling time for both time and angle synchronous rasters"

    /begin LOC_MEASUREMENT
      ESC_stStackErr
    /end LOC_MEASUREMENT
    FUNCTION_VERSION "30000.15.0"

/end FUNCTION

/begin FUNCTION

    ETC_Std
    "30000.17.0Engine Test Coordinator"

    /begin DEF_CHARACTERISTIC
      Etc_MaxReqTO_C
    /end DEF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      Etc_ctCurRunTst
    /end OUT_MEASUREMENT
    FUNCTION_VERSION "30000.17.0"

/end FUNCTION

/begin FUNCTION

    Eth
    "3.11.0"

    FUNCTION_VERSION "3.11.0"

/end FUNCTION

/begin FUNCTION

    GConf_Sy
    "RC40_LARGE_3"

    FUNCTION_VERSION "RC40_LARGE_3"

/end FUNCTION

/begin FUNCTION

    I15031Extd_srv1
    "30000.16.0Request current powertrain diagnostic data extended"

    FUNCTION_VERSION "30000.16.0"

/end FUNCTION

/begin FUNCTION

    I15031Extd_srv2
    "30000.12.0Request powertrain freeze frame data extended"

    FUNCTION_VERSION "30000.12.0"

/end FUNCTION

/begin FUNCTION

    I15031Extd_srv37
    "30000.7.0 Request of emission-relevant Diagnostic Trouble Codes from currentcompleted driving cycles extended"

    FUNCTION_VERSION "30000.7.0"

/end FUNCTION

/begin FUNCTION

    I15031Extd_srv4
    "30000.7.0 Clear and reset emission-related diagnostic information extended"

    /begin DEF_CHARACTERISTIC
      I15031_nMaxSrv4_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Epm_nEng
    /end IN_MEASUREMENT
    FUNCTION_VERSION "30000.7.0"

/end FUNCTION

/begin FUNCTION

    I15031Extd_srv9
    "30000.30.0Request vehicle informations extended"

    /begin DEF_CHARACTERISTIC
      I15031_srv9PIDTable.PID0_C I15031_srv9PIDTable.PID2_C I15031_srv9PIDTable.PID4_C I15031_srv9PIDTable.PID6_C I15031_srv9PIDTable.PID8_C I15031_srv9PIDTable.PIDA_C
      I15031_srv9PIDTable.PIDB_C I15031_srv9PIDTable.PIDF_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      T15_st
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      I15031_ITIDSuppSrv9 I15031_srv9_stCVNRecalc I15031_srv9_ValidCVN
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      i15031_srv9_CVN_Calc_ui
    /end LOC_MEASUREMENT
    FUNCTION_VERSION "30000.30.0"

/end FUNCTION

/begin FUNCTION

    I15031_srv1
    "30000.42.0Request current powertrain diagnostic data"

    /begin DEF_CHARACTERISTIC
      I15031_PID13_C I15031_PID1C_C I15031_PID1D_C I15031_PID4FA_C I15031_PID4FB_C I15031_PID4FC_C
      I15031_PID4FD_C I15031_PID50A_C I15031_PID5F_C I15031_PID65A_C I15031_PID66A_C I15031_PID67A_C
      I15031_PID68A_C I15031_PID69A_C I15031_PID6AA_C I15031_PID6BA_C I15031_PID6CA_C I15031_PID6DA_C
      I15031_PID6EA_C I15031_PID6FA_C I15031_PID70A_C I15031_PID71A_C I15031_PID72A_C I15031_PID73A_C
      I15031_PID74A_C I15031_PID75A_C I15031_PID76A_C I15031_PID77A_C I15031_PID78A_C I15031_PID79A_C
      I15031_PID7AA_C I15031_PID7BA_C I15031_PID7CA_C I15031_PID7FA_C I15031_PID81A_C I15031_PID82A_C
      I15031_PID83A_C I15031_PID85A_C I15031_PID86A_C I15031_PID87A_C I15031_PID89A_C I15031_PID8AA_C
      I15031_PID8BA_C I15031_PID8CA_C I15031_PID8FA_C I15031_PID92A_C I15031_PID93A_C I15031_PID94A_C
      I15031_PID97A_C I15031_PID98A_C I15031_PID99A_C I15031_PID9AA_C I15031_PID9BA_C I15031_PID9CA_C
      I15031_PID9FA_C I15031_PIDA1A_C I15031_PIDA3A_C I15031_PIDA4A_C I15031_PIDA5A_C I15031_PIDA7A_C
      I15031_PIDA8A_C I15031_PIDA9A_C I15031_PIDACA_C I15031_stRfrshCal_C
    /end DEF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      I15031_FILLSIG1 I15031_FILLSIG2 I15031_FILLSIG4 I15031_PID13 I15031_PID1C I15031_PID1D
      I15031_PID4FA I15031_PID4FB I15031_PID4FC I15031_PID4FD I15031_PID50A I15031_PID50B
      I15031_PID50C I15031_PID50D I15031_PID5F I15031_PID65A I15031_PID66A I15031_PID67A
      I15031_PID68A I15031_PID69A I15031_PID6AA I15031_PID6BA I15031_PID6CA I15031_PID6DA
      I15031_PID6EA I15031_PID6FA I15031_PID70A I15031_PID71A I15031_PID72A I15031_PID73A
      I15031_PID74A I15031_PID75A I15031_PID76A I15031_PID77A I15031_PID78A I15031_PID79A
      I15031_PID7AA I15031_PID7BA I15031_PID7CA I15031_PID7FA I15031_PID81A I15031_PID82A
      I15031_PID83A I15031_PID85A I15031_PID86A I15031_PID87A I15031_PID89A I15031_PID8AA
      I15031_PID8BA I15031_PID8CA I15031_PID8FA I15031_PID92A I15031_PID93A I15031_PID94A
      I15031_PID97A I15031_PID98A I15031_PID99A I15031_PID9AA I15031_PID9BA I15031_PID9CA
      I15031_PID9FA I15031_PIDA1A I15031_PIDA3A I15031_PIDA4A I15031_PIDA5A I15031_PIDA7A
      I15031_PIDA8A I15031_PIDA9A I15031_PIDACA I15031_PIDSuppSrv1 I15031_Srv12_Ext_DisablPIDSupp
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      I15031_PIDSuppSrv2
    /end LOC_MEASUREMENT
    FUNCTION_VERSION "30000.42.0"

/end FUNCTION

/begin FUNCTION

    I15031_srv2
    "30000.6.0 Request powertrain freeze frame data"

    FUNCTION_VERSION "30000.6.0"

/end FUNCTION

/begin FUNCTION

    I15031_srv37
    "30000.9.0 Request of emission-relevant DTC's from current/completed driving cycle(s)"

    FUNCTION_VERSION "30000.9.0"

/end FUNCTION

/begin FUNCTION

    I15031_srv4
    "30000.10.0Clear and reset emission-related diagnostic information"

    FUNCTION_VERSION "30000.10.0"

/end FUNCTION

/begin FUNCTION

    I15031_srv6
    "30000.10.0Request on-board monitoring test results for specific monitored systems"

    FUNCTION_VERSION "30000.10.0"

/end FUNCTION

/begin FUNCTION

    I15031_Srv8
    "3.0.0     Request control of on-board system, test or component"

    FUNCTION_VERSION "3.0.0"

/end FUNCTION

/begin FUNCTION

    I15031_srv9
    "30000.32.0Request vehicle informations"

    FUNCTION_VERSION "30000.32.0"

/end FUNCTION

/begin FUNCTION

    I15031_srv9_VT
    "30000.13.0Infrastructure Component for handling OBD MY2019 Vehicle Tracking Infotypes based on the SAE J1979-DA Specification"

    /begin DEF_CHARACTERISTIC
      I15031_srv9_VT_SupprRecent_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      DFES_stPrgEvt_msg
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      I15301_srv9_vt_stStorgFlsgPers_msg
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      i15031_srv9_vt_ASWFrzStatus
    /end LOC_MEASUREMENT
    FUNCTION_VERSION "30000.13.0"

/end FUNCTION

/begin FUNCTION

    I15031_Std
    "30000.26.0Base subservices for emission relevant diagnosis"

    /begin IN_MEASUREMENT
      I15031_PIDSuppSrv1 T15_st
    /end IN_MEASUREMENT
    FUNCTION_VERSION "30000.26.0"

/end FUNCTION

/begin FUNCTION

    MEDC_Compu_Core_CELPrj
    "30059.0.0 Computation Methods for core, which are migrated from DS classis"

    FUNCTION_VERSION "30059.0.0"

/end FUNCTION

/begin FUNCTION

    MEDC_Compu_Custom
    "1.0.0_RC40_LARGEdeprectared: have to be migrated to CEL_Compu"

    FUNCTION_VERSION "1.0.0_RC40_LARGE"

/end FUNCTION

/begin FUNCTION

    MEDC_Compu_Custom_CELPrj
    "30059.0.0 Customer specific computation formulas from Clearcase"

    FUNCTION_VERSION "30059.0.0"

/end FUNCTION

/begin FUNCTION

    MEDC_Compu_DS_CELPrj
    "30059.0.0 computation methods of DS from Clearcase"

    FUNCTION_VERSION "30059.0.0"

/end FUNCTION

/begin FUNCTION

    MEDC_Compu_DS_GS_CELPrj
    "30059.0.0 computation methods, common used by DS and GS from Clearcase"

    FUNCTION_VERSION "30059.0.0"

/end FUNCTION

/begin FUNCTION

    MEDC_FixConst_Core_CELPrj
    "30059.0.0 central system constants of the core from Clearcase"

    FUNCTION_VERSION "30059.0.0"

/end FUNCTION

/begin FUNCTION

    MEDC_FixConst_Custom
    "1.2.0_RC40_LARGEdeprectared: have to be migrated to CEL_Const"

    FUNCTION_VERSION "1.2.0_RC40_LARGE"

/end FUNCTION

/begin FUNCTION

    MEDC_FixConst_Custom_CELPrj
    "30059.0.0 Customer specific central system constants from Clearcase"

    FUNCTION_VERSION "30059.0.0"

/end FUNCTION

/begin FUNCTION

    MEDC_FixConst_DS_CELPrj
    "30059.0.0 DS central system constants from Clearcase"

    FUNCTION_VERSION "30059.0.0"

/end FUNCTION

/begin FUNCTION

    MEDC_FixConst_DS_GS_CELPrj
    "30059.0.0 central systemkonstants, common used by DS and GS from Clearcase"

    FUNCTION_VERSION "30059.0.0"

/end FUNCTION

/begin FUNCTION

    MEDC_MoCompu_CELPrj
    "1.4.0     Computation formulas for monitoring"

    FUNCTION_VERSION "1.4.0"

/end FUNCTION

/begin FUNCTION

    MEDC_Models_DS_CELPrj
    "30059.0.0 models DS from Clearcase"

    FUNCTION_VERSION "30059.0.0"

/end FUNCTION

/begin FUNCTION

    MEDC_Models_DS_GS_CELPrj
    "30059.0.0 common models GS and DS from Clearcase"

    FUNCTION_VERSION "30059.0.0"

/end FUNCTION

/begin FUNCTION

    MEDC_SimpleModels
    "30001.0.0 Simple models for diesel gasoline systems"

    FUNCTION_VERSION "30001.0.0"

/end FUNCTION

/begin FUNCTION

    MoCCom_Co
    "81.26.0   Microcontroller Monitoring: Query-response-communication between MM and FC"

    /begin IN_MEASUREMENT
      MoCCPU_PartResp MoCGTM_PtlResp MoCHwLogicTest_PtlResp MoCIWDH_PtlResp MoCPFC_PtlResp MoCSOP_stActvMsg
      MoCSOP_stComActv MoCSOP_stComActvCpl
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      MoCCom_bPFCNew MoCCom_bSwShrNew MoCCom_cntrWDAErrThd MoCCom_cntrWDAErrThdMsg MoCCom_ctErrFC MoCCom_ctErrMM
      MoCCom_ctErrMMMsg MoCCom_Query MoCCom_stQueryNew MoCCom_SwShrPtlResp
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      MoCCom_cntrInCorrRespTime MoCCom_cntrSyncMonModl MoCCom_cntrWDAErrThdCpl MoCCom_ctBusErr MoCCom_ctBusErrCpl MoCCom_ctErrFCCpl
      MoCCom_ctErrMMOld MoCCom_ctErrOSTimeout MoCCom_Response MoCCom_Response_mp MoCCom_stBusErr MoCCom_stCheckState
      MoCCom_stCheckStateCpl MoCCom_stComActvOld MoCCom_stComActvOldCpl MoCCom_stComState MoCCom_stErrEna MoCCom_stErrEnaCpl
      MoCCom_stWdgThdErr MoCCom_stWdgTiWinErr
    /end LOC_MEASUREMENT
    FUNCTION_VERSION "81.26.0"

/end FUNCTION

/begin FUNCTION

    MoCCPU_Co
    "80.6.0"

    /begin DEF_CHARACTERISTIC
      MoCCPU_stLockStepTstActv_CW
    /end DEF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      MoCCPU_PartResp
    /end OUT_MEASUREMENT
    FUNCTION_VERSION "80.6.0"

/end FUNCTION

/begin FUNCTION

    MoCEMM_Co
    "1.24.0"

    /begin IN_MEASUREMENT
      MoCSOP_stComActv
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      MoCEMM_stEmmAlrms MoCEMM_stEmmAlrmsMsg MoCEMM_stEmmAlrmsNv MoCEMM_stEmmErrorPin
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      MoCEMM_idxNumCurrErr MoCEMM_stEmmAlrmsCpl MoCEMM_stEmmErrorPinCpl MoCEMM_stEmmGPIO MoCEMM_stPwrOnRstHdl MoCEMM_stPwrOnRstHdlCpl
      MoCEMM_stPwrOnRstReq MoCEMM_stPwrOnRstReqCpl MoCEMM_structCurrReq.MoCEMM_cntrInfo MoCEMM_structCurrReq.MoCEMM_blkInfo MoCEMM_structCurrReq.MoCEMM_cntrInfoCpl MoCEMM_structFlash.MoCEMM_cntrInfo
      MoCEMM_structFlash.MoCEMM_blkInfo MoCEMM_structFlash.MoCEMM_cntrInfoCpl MoCEMM_stSWErrorPinReqAry MoCEMM_stSWErrorPinReqAryCpl MoCEMM_wdgTout
    /end LOC_MEASUREMENT
    FUNCTION_VERSION "1.24.0"

/end FUNCTION

/begin FUNCTION

    MoCGTM_Co
    "1.16.0"

    /begin DEF_CHARACTERISTIC
      MoCGTM_cntrCMPErrbitHealMax_C MoCGTM_cntrDebErrMax_C MoCGTM_stChksTstActv_CW MoCGTM_stSWResetDem_CW MoCGTM_stTestActv_CW
    /end DEF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      MoCGTM_bbOut1 MoCGTM_flgCmpErr MoCGTM_PtlResp
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      MoCGTM_aryCMPErrBit MoCGTM_aryCMPErrBitCpl MoCGTM_bbOut1Cpl MoCGTM_cmpErrAryIdx MoCGTM_cmpErrAryIdxCpl MoCGTM_cntrBadcase
      MoCGTM_cntrCMPErrbit MoCGTM_cntrCMPErrbitCpl MoCGTM_cntrCMPErrbitHeal MoCGTM_cntrCMPErrbitHealCpl MoCGTM_cntrDebErr MoCGTM_cntrDebErrCpl
      MoCGTM_cntrDebErrMax MoCGTM_cntrMCS1 MoCGTM_cntrMCS1Old MoCGTM_cntrMCS1OldCpl MoCGTM_cntrMCS2 MoCGTM_cntrMCS2Old
      MoCGTM_cntrMCS2OldCpl MoCGTM_cntrMsmCMPErrBit MoCGTM_cntrRouteSigErr MoCGTM_cntrRouteSigErrCpl MoCGTM_currChksVal MoCGTM_currChksValCpl
      MoCGTM_currMCSModlAryIdx MoCGTM_McsData_ptr1Cpl MoCGTM_McsData_ptr2Cpl MoCGTM_numMCS1Ch MoCGTM_numMCS1Modl MoCGTM_numMCS2Ch
      MoCGTM_numMCS2Modl MoCGTM_PtlRespCpl MoCGTM_stBadcaseTrig MoCGTM_stErr MoCGTM_stErrChks MoCGTM_stErrCpl
      MoCGTM_tiCurrMCSVal MoCGTM_tiCurrTskcall MoCGTM_tiExeMCS1_MP MoCGTM_tiExeMCS2_MP MoCGTM_tiFallEdgeBadcase_MP MoCGTM_tiFallEdgeMCS1_MP
      MoCGTM_tiFallEdgeMCS2_MP MoCGTM_tiMCSTIMRead MoCGTM_tiPrevMCS1Trig_MP MoCGTM_tiPrevMCS2Trig_MP MoCGTM_tiPrevTskcall MoCGTM_tiRisngEdgeMCS1_MP
      MoCGTM_tiRisngEdgeMCS2_MP MoCGTM_tiTskCalldst_MP
    /end LOC_MEASUREMENT
    FUNCTION_VERSION "1.16.0"

/end FUNCTION

/begin FUNCTION

    MoCHwLogicTest_Co
    "1.4.0"

    /begin DEF_CHARACTERISTIC
      MoCHwLogicTest_stTestActv_CW MoCHwLogicTest_swtDisblErrReactn_CW MoCHwLogicTest_swtDisblFwChk_CA
    /end DEF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      MoCHwLogicTest_PtlResp
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      MoCHwLogicTest_flgAlvTestChk MoCHwLogicTest_flgFwChk MoCHwLogicTest_flgMONBISTChk MoCHwLogicTest_flgSFFDChk MoCHwLogicTest_flgTempChk MoCHwLogicTest_flgUCBErrChk
      MoCHwLogicTest_stErr
    /end LOC_MEASUREMENT
    FUNCTION_VERSION "1.4.0"

/end FUNCTION

/begin FUNCTION

    MoCIWDH_Co
    "2.1.0"

    /begin DEF_CHARACTERISTIC
      MoCIWDH_stPtlRespTstActv_CW
    /end DEF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      MoCIWDH_PtlResp
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      MoCIWDH_bbLoc1 MoCIWDH_bbLoc1Cpl MoCIWDH_cntChksAry MoCIWDH_cntrRollgAry MoCIWDH_cntrRollgAryCpl MoCIWDH_flgConcatValErr
      MoCIWDH_numChksAry MoCIWDH_numConcatValAry MoCIWDH_PtlRespCpl MoCIWDH_stErrAry
    /end LOC_MEASUREMENT
    FUNCTION_VERSION "2.1.0"

/end FUNCTION

/begin FUNCTION

    MoCMemStrtUp_Co
    "1.0.0"

    /begin DEF_CHARACTERISTIC
      MoCMemStrtUp_chkRamTest_C MoCMemStrtUp_chkRomTest_C
    /end DEF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      MoCMemStrtUp_adrEccErr
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      MoCMemStrtUp_chkRamTest MoCMemStrtUp_chkRomTest MoCMemStrtUp_tiRamChk MoCMemStrtUp_tiRomChk MoCMemStrtUp_toutWdg
    /end LOC_MEASUREMENT
    FUNCTION_VERSION "1.0.0"

/end FUNCTION

/begin FUNCTION

    MoCMem_Co
    "80.24.1"

    /begin DEF_CHARACTERISTIC
      MoCMem_ctDebErrChkRAM_C MoCMem_ctDebErrChkROM_C MoCMem_ctDebHealChkRAMCpl_C MoCMem_ctDebHealChkRAM_C MoCMem_ctDebHealChkROMCpl_C MoCMem_ctDebHealChkROM_C
      MoCMem_noMEMChkRstCpl_CW MoCMem_noMEMChkRst_CW MoCMem_numRamChk_C MoCMem_numRomChk_CA MoCMem_RamTst_CW MoCMem_RomTst_CW
      MoCMem_stSwtAutRamChkConf_C MoCMem_stSwtAutRomChkConf_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      MoExe_ctCyc
    /end IN_MEASUREMENT
    /begin LOC_MEASUREMENT
      MoCMem_adChkSumBlk MoCMem_adChkSumBlkCpl MoCMem_ctDebErrChkROM MoCMem_ctDebErrChkROMCpl MoCMem_ctDebHealChkROM MoCMem_ctDebHealChkROMCpl
      MoCMem_ctLrnROM MoCMem_ctLrnROMCpl MoCMem_idxCSAry MoCMem_idxCSAryCpl MoCMem_nrRomChk MoCMem_nrRomChkCpl
      MoCMem_nrRomChkSize MoCMem_numChkSumCurrent MoCMem_numChkSumCurrentCpl MoCMem_RomCurrentPtr MoCMem_RomCurrentPtrCpl MoCMem_stDataCycChkBlk
      MoCMem_stDataCycChkBlkCpl MoCMem_stDisChk MoCMem_tiROMAccus MoCMem_tiROMAccusCpl MoCMem_tiROMus MoCMem_tiROMusCpl
      MoCMem_tiROMusOld MoCMem_tiROMusOldCpl
    /end LOC_MEASUREMENT
    FUNCTION_VERSION "80.24.1"

/end FUNCTION

/begin FUNCTION

    MoCPFC_Co
    "14.4.0"

    /begin DEF_CHARACTERISTIC
      MoCPFC_stPtlRespTestActv_CW
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      MoCCom_bPFCNew MoCCom_Query
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      MoCPFC_Checksum MoCPFC_PtlResp
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      MoCPFC_Checkword MoCPFC_Counter
    /end LOC_MEASUREMENT
    FUNCTION_VERSION "14.4.0"

/end FUNCTION

/begin FUNCTION

    MoCSCC_Co
    "1.24.0"

    /begin DEF_CHARACTERISTIC
      MoCSCC_cntrDebMax_C MoCSCC_stSCCTstActv_CW MoCSCC_swtDisblEmmChk_CA MoCSCC_swtLfastWrkarndActv_CW
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      MoCSOP_stComActv
    /end IN_MEASUREMENT
    /begin LOC_MEASUREMENT
      MoCSCC_stLfastWrkarndActv_MP MoCSCC_stMstInstFnd
    /end LOC_MEASUREMENT
    FUNCTION_VERSION "1.24.0"

/end FUNCTION

/begin FUNCTION

    MoCSOP_Co
    "81.29.0   Microcontroller Monitoring: Shut-off path test"

    /begin DEF_CHARACTERISTIC
      MoCSOP_cntrDebCtrlLinesActvThd_C MoCSOP_ctDebSOPTst_C MoCSOP_ctDebSycDrv_C MoCSOP_ctRst_C MoCSOP_nEngMaxOVLthDisbl_C MoCSOP_stCANErrReac_CW
      MoCSOP_stCtrlLineErrReactn_C MoCSOP_stErrReactn_CA MoCSOP_stMMErrReac_CW MoCSOP_stOVErrReactn_C MoCSOP_stSWResetDem_CW MoCSOP_stTestActv_CW
      MoCSOP_swtAlwysPsTest_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Epm_nEng MoGlbl_vblStructCpl.Mo_stCplChk MoGlbl_vblStructCpl.Mo_stMoCCpl Mo_stMoF Mo_stMoFCpl T15_st
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      MoCSOP_aryCtrlLinesDia[0].MoCSOP_stCurrState MoCSOP_aryCtrlLinesDia[0].MoCSOP_cntrDebDia MoCSOP_aryCtrlLinesDia[1].MoCSOP_stCurrState MoCSOP_aryCtrlLinesDia[1].MoCSOP_cntrDebDia MoCSOP_aryFeedbackLinesDia[0].MoCSOP_stCurrState MoCSOP_aryFeedbackLinesDia[0].MoCSOP_cntrDebDia
      MoCSOP_aryFeedbackLinesDia[1].MoCSOP_stCurrState MoCSOP_aryFeedbackLinesDia[1].MoCSOP_cntrDebDia MoCSOP_aryFeedbackLinesDia[2].MoCSOP_stCurrState MoCSOP_aryFeedbackLinesDia[2].MoCSOP_cntrDebDia MoCSOP_aryFeedbackLinesDia[3].MoCSOP_stCurrState MoCSOP_aryFeedbackLinesDia[3].MoCSOP_cntrDebDia
      MoCSOP_aryFeedbackLinesDia[4].MoCSOP_stCurrState MoCSOP_aryFeedbackLinesDia[4].MoCSOP_cntrDebDia MoCSOP_aryFeedbackLinesDia[5].MoCSOP_stCurrState MoCSOP_aryFeedbackLinesDia[5].MoCSOP_cntrDebDia MoCSOP_aryInhbLinesDia[0].MoCSOP_stCurrState MoCSOP_aryInhbLinesDia[0].MoCSOP_cntrDebDia
      MoCSOP_aryInhbLinesDia[1].MoCSOP_stCurrState MoCSOP_aryInhbLinesDia[1].MoCSOP_cntrDebDia MoCSOP_aryInhbLinesDia[2].MoCSOP_stCurrState MoCSOP_aryInhbLinesDia[2].MoCSOP_cntrDebDia MoCSOP_ctErrMM MoCSOP_st
      MoCSOP_stActMsg MoCSOP_stActvMsg MoCSOP_stComActv MoCSOP_stComActvCpl MoCSOP_stInhbLine10ms MoCSOP_stOvl
      MoCSOP_stRdy MoCSOP_stRdyCan MoCSOP_stRdyCpl MoCSOP_stRdyFr MoCSOP_stRdyInj MoCSOP_stRdyMsg
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      MoCSOP_cntrBusErrInhbLine MoCSOP_cntrBusErrInhbLineCpl MoCSOP_cntrDebCtrlLinesActv MoCSOP_cntrDebCtrlLinesActvCpl MoCSOP_cntrDebErrPinActv MoCSOP_cntrDebErrPinActvCpl
      MoCSOP_cntrDebExtErrPinEveActv MoCSOP_cntrDebExtErrPinEveActvCpl MoCSOP_cntrDebExtErrPinEveActv_MP MoCSOP_cntrDebInhbLinePlausyChk MoCSOP_cntrDebInhbLinePlausyChkCpl MoCSOP_cntrDebSycDrv
      MoCSOP_cntrDebSycDrvCpl MoCSOP_cntrSignalSwtDelay MoCSOP_cntrSignalSwtDelayCpl MoCSOP_ctBusErr MoCSOP_ctBusErr_MP MoCSOP_ctDebSOPTst
      MoCSOP_ctDebSOPTstCpl MoCSOP_ctErrMM_mp MoCSOP_ctErrOSTimeout MoCSOP_ctIdx MoCSOP_ctRespOffsetTst MoCSOP_ctRst
      MoCSOP_ctRstCpl MoCSOP_flgABEStatus10ms MoCSOP_flgErrPinActvd MoCSOP_flgErrPinActvdCpl MoCSOP_flgReqSOPTest MoCSOP_flgReqSOPTestCpl
      MoCSOP_flgT15RisngEdge MoCSOP_flgT15RisngEdgeCpl MoCSOP_stBusErr MoCSOP_stBusErr_MP MoCSOP_stCheckState MoCSOP_stCheckStateCpl
      MoCSOP_stCheckState_mp MoCSOP_stCpl MoCSOP_stCtrlLineUnderTest MoCSOP_stDia MoCSOP_stDiaCpl MoCSOP_stEmmState_MP
      MoCSOP_stErr MoCSOP_stErrPinActvnReq MoCSOP_stErrPin_MP MoCSOP_stErrReactn MoCSOP_stInhbLine MoCSOP_stInhbLine10msCpl
      MoCSOP_stInhbLineCpl MoCSOP_stInhbLineStatus MoCSOP_stInhbLineStatusCpl MoCSOP_stInhbStrtCdn MoCSOP_stOvlCpl MoCSOP_stOVTstStatusEval
      MoCSOP_stOVTstStatusEvalCpl MoCSOP_stPVMTUnderTest MoCSOP_stRdyCanCpl MoCSOP_stRdyFrCpl MoCSOP_stRdyInjCpl MoCSOP_stReqPSStatus
      MoCSOP_stReqPSStatusBusErr MoCSOP_stReqSOPTest MoCSOP_stReqSOPTestCpl MoCSOP_stT15Old MoCSOP_stT15OldCpl Mo_flgIrrvErrSOPMsg
    /end LOC_MEASUREMENT
    FUNCTION_VERSION "81.29.0"

/end FUNCTION

/begin FUNCTION

    MoExe_Co
    "693.0.0"

    /begin IN_MEASUREMENT
      DSM_TripChgFinshd SyC_stSub
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      MoExe_ctCyc MoExe_ctCycCpl
    /end OUT_MEASUREMENT
    FUNCTION_VERSION "693.0.0"

/end FUNCTION

/begin FUNCTION

    MoFSrv_Lib
    "24.9.0"

    /begin IN_MEASUREMENT
      Mo_stCplChk Mo_stMoC Mo_stMoCCpl
    /end IN_MEASUREMENT
    FUNCTION_VERSION "24.9.0"

/end FUNCTION

/begin FUNCTION

    MoFVar_PostBldSel
    "2.1.0"

    /begin DEF_CHARACTERISTIC
      MoFTrqPtd_cntrActvPostBldCfg_C MoFTrqPtd_cntrNegChkPostBldCfg_C MoFTrqPtd_cntrPosChkPostBldCfg_C MoFTrqPtd_cntrRstPostBldSel_C MoFTrqPtd_cntrStabyChkPostBldCfg_C MoFTrqPtd_cntrTestPostBldSel_C
      MoFTrqPtd_stSwtPbsChk_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Mo_ctRst Mo_ctRstCpl Mo_stCplChk Mo_stMoC Mo_stMoCCpl Mo_stMoF
      Mo_stMoFCpl
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      MoFTrqPtd_flgIrrvErrPostBldSel
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      MoFTrqPtd_cntrActvPostBldCfg MoFTrqPtd_cntrActvPostBldCfgCpl MoFTrqPtd_cntrNegChkPostBldCfg MoFTrqPtd_cntrNegChkPostBldCfgCpl MoFTrqPtd_cntrPosChkPostBldCfg MoFTrqPtd_cntrPosChkPostBldCfgCpl
      MoFTrqPtd_cntrStabyChkPostBldCfg MoFTrqPtd_cntrStabyChkPostBldCfgCpl MoFTrqPtd_cntrTestPostBldSel MoFTrqPtd_flgAlt MoFTrqPtd_flgClrPostBldSel MoFTrqPtd_flgDrvgCycStabyChk_MP
      MoFTrqPtd_flgErrActPostBldCfg_MP MoFTrqPtd_flgErrNegChkPostBld_MP MoFTrqPtd_flgErrPosChk MoFTrqPtd_flgErrPosChk2 MoFTrqPtd_flgErrPosChkPostBld_MP MoFTrqPtd_flgIrrvErrPostBldSelMsg
      MoFTrqPtd_flgPostBldCfgRxd MoFTrqPtd_idxPostBldCfg MoFTrqPtd_idxPostBldCfgCpl MoFTrqPtd_idxPostBldCfgIni MoFTrqPtd_idxPostBldCfgIniCpl MoFTrqPtd_stRbGetActvPostBldVrntIdx_MP
      MoFTrqPtd_stRbMoInitCheckInverse_MP MoFTrqPtd_stRbMoInitCheck_MP MoFVarPostBldSel_bbLoc1Cpl MoFVarPostBldSel_bbOut1Cpl
    /end LOC_MEASUREMENT
    FUNCTION_VERSION "2.1.0"

/end FUNCTION

/begin FUNCTION

    MoFWDA_Co
    "16.0.0"

    /begin IN_MEASUREMENT
      Mo_stMoF
    /end IN_MEASUREMENT
    FUNCTION_VERSION "16.0.0"

/end FUNCTION

/begin FUNCTION

    MoSysCtrl_Co
    "3.0.1"

    /begin DEF_CHARACTERISTIC
      MoSysCtrl_ctErrReIniAllowd_C MoSysCtrl_ctReIniAllowd_C MoSysCtrl_ctReIniTstDeb_C MoSysCtrl_ctT15RsngEdgDetnAllwd_C MoSysCtrl_ctT15RsngEdgDetnPlausy_C MoSysCtrl_ctT15RsngEdgTurnOff_C
      MoSysCtrl_stSwtT15PlausEna_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Mo_stCplChk Mo_stMoC Mo_stMoCCpl Mo_stMoF Mo_stMoFCpl SyC_ctPostDrvLeave
      T15_st
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      MoSysCtrl_ctPostDrvLeave MoSysCtrl_flgErrReIniReqMsg MoSysCtrl_flgIrvErrReIniReqMsg MoSysCtrl_flgReIniClr MoSysCtrl_flgReIniReqTrig MoSysCtrl_flgReIniReqTrigMsg
      MoSysCtrl_flgReIniTestMsg
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      MoSysCtrlCo_bbLoc1Cpl MoSysCtrlCo_bbOut1Cpl MoSysCtrl_ctErrReIniAllowd MoSysCtrl_ctErrReIniAllowdCpl MoSysCtrl_ctPostDrvLeaveCpl MoSysCtrl_ctPostDrvLeaveOld
      MoSysCtrl_ctPostDrvLeaveOldCpl MoSysCtrl_ctReIniAllowd MoSysCtrl_ctReIniAllowdCpl MoSysCtrl_ctReIniTst MoSysCtrl_ctT15RsngEdgDetn MoSysCtrl_ctT15RsngEdgDetnCpl
      MoSysCtrl_ctT15RsngEdgDetnPlausy MoSysCtrl_ctT15RsngEdgDetnPlausyCpl MoSysCtrl_ctT15RsngEdgTurnOff MoSysCtrl_ctT15RsngEdgTurnOffCpl MoSysCtrl_flgErrReIniReq MoSysCtrl_flgReIniReq
      MoSysCtrl_flgReIniReqAlwd MoSysCtrl_flgT15 MoSysCtrl_flgT15Old MoSysCtrl_flgT15PlausyErr MoSysCtrl_flgT15PlausyErrOld MoSysCtrl_flgT15RsngEdgTurnOff
    /end LOC_MEASUREMENT
    FUNCTION_VERSION "3.0.1"

/end FUNCTION

/begin FUNCTION

    MoXEMM_Co
    "20.4.1"

    /begin DEF_CHARACTERISTIC
      MoXEMM_nrHwLTErrSimn_C MoXEMM_nrSmuAlmErrSimn_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      MoCEMM_stEmmAlrmsMsg SyC_ctPostDrvLeave
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      MoXEMM_stEMMAlrms MoXEMM_stEMMAlrmsAftRst
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      MoXEMM_cntrPostDrvLeaveOld MoXEMM_stHwLTResult
    /end LOC_MEASUREMENT
    FUNCTION_VERSION "20.4.1"

/end FUNCTION

/begin FUNCTION

    Mo_Conf
    "MO_0.18.37_1.0.0_RC40_ML"

    FUNCTION_VERSION "MO_0.18.37_1.0.0_RC40_ML"

/end FUNCTION

/begin FUNCTION

    Mo_Glbl
    "97.14.0"

    /begin DEF_CHARACTERISTIC
      Mo_cwMstSlave_C Mo_stSwtHyb_C Mo_swtClrCntrMax_C Mo_swtCyclCalUpdt_C Mo_trqIdcMax_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      SyC_stSub
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      MoGlbl_vblStruct.Mo_stMoC MoGlbl_vblStructCpl.Mo_stCplChk MoGlbl_vblStructCpl.Mo_stMoCCpl Mo_ctRst Mo_ctRstCpl Mo_ctRstMsg
      Mo_flgICOMsg Mo_stCplChk Mo_stErrHyb Mo_stErrHybCpl Mo_stMoC Mo_stMoCCpl
      Mo_stMoCExtdTsk Mo_stMoCExtdTskCpl Mo_stMoCExtdTskMsg Mo_stMoCMsg Mo_stMoF Mo_stMoFCpl
      Mo_stMoFExtdTsk Mo_stMoFExtdTskCpl Mo_stMoFExtdTskMsg Mo_stMoFMsg Mo_stVldR32Chk
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      MoGlbl_bbLocExtdTskCpl Mo_bAddConPFC Mo_bAddConPFCExtdTsk Mo_bAddDisblPreICORst Mo_bAddDisblPreICORstExtdTsk Mo_bCplChk
      Mo_bCplChkExtdTsk Mo_bEmgcyAir Mo_bICOL1 Mo_bICOL2 Mo_bICOL2ExtdTsk Mo_bIrvElMIdl
      Mo_bIrvHybLimpL1 Mo_bIrvHybLimpL2 Mo_bIrvHybP1LimpL2 Mo_bIrvTrqLimL1 Mo_bIrvTrqLimL2 Mo_bLoVltg
      Mo_bNlh Mo_bRamErr Mo_bRamErrExtdTsk Mo_bRomErr Mo_bSyncLos Mo_stProtRAM
    /end LOC_MEASUREMENT
    FUNCTION_VERSION "97.14.0"

/end FUNCTION

/begin FUNCTION

    Mo_Inst
    "604.0.0"

    /begin LOC_MEASUREMENT
      MoCMem_vblStructCpl_Core1_10ms_Nr1.MoCMem_ctDebErrChkRAMOld MoCMem_vblStructCpl_Core1_10ms_Nr1.MoCMem_ctDebErrChkRAMCpl MoCMem_vblStructCpl_Core1_10ms_Nr1.MoCMem_ctDebHealChkRAMCpl MoCMem_vblStructCpl_Core1_10ms_Nr1.MoCMem_nrRamChkCpl MoCMem_vblStructCpl_Core1_10ms_Nr1.MoCMem_nrStckChkCpl MoCMem_vblStructCpl_Core1_10ms_Nr1.MoCMem_nrCSAChkCpl
      MoCMem_vblStructCpl_Core1_10ms_Nr1.MoCMem_RamOffsetPtrCpl MoCMem_vblStructCpl_Core1_10ms_Nr1.MoCMem_CSAOffsetPtrCpl MoCMem_vblStructCpl_Core1_10ms_Nr1.MoCMem_StckOffsetPtrCpl MoCMem_vblStructCpl_Core1_10ms_Nr1.Mo_RamCyclicCheckCpl MoCMem_vblStructCpl_Core1_10ms_Nr1.MoCMem_ctLrnRAMCpl MoCMem_vblStructCpl_Core1_10ms_Nr1.MoCMem_tiRAMusOldCpl
      MoCMem_vblStructCpl_Core1_10ms_Nr1.MoCMem_tiRAMAccusCpl MoCMem_vblStructCpl_Core1_10ms_Nr1.MoCMem_tiRAMusCpl MoCMem_vblStructCpl_Core1_10ms_Nr1.MoCMem_ctLrnErrHdlrCpl MoCMem_vblStructCpl_Core1_10ms_Nr1.MoCMem_tiErrHdlrusOldCpl MoCMem_vblStructCpl_Core1_10ms_Nr1.MoCMem_tiErrHdlrusCpl MoCMem_vblStructCpl_Core1_10ms_Nr1.MoCMem_tiErrHdlrAccusCpl
      MoCMem_vblStructCpl_Core1_10ms_Nr1.MoCMem_numHealFacCpl MoCMem_vblStructEarlyClearedRAM_Core1_10ms_Nr1.MoCMem_st MoCMem_vblStructEarlyClearedRAM_Core1_10ms_Nr1.MoCMem_stCpl MoCMem_vblStructNVRAM_Core1_10ms_Nr1.MoCMem_ctDebErrChkRAMMaxNv MoCMem_vblStructNVRAM_Core1_10ms_Nr1.MoCMem_ctDebErrChkRAMExcddThdNv MoCMem_vblStruct_Core1_10ms_Nr1.MoCMem_ctDebErrChkRAM
      MoCMem_vblStruct_Core1_10ms_Nr1.MoCMem_ctDebHealChkRAM MoCMem_vblStruct_Core1_10ms_Nr1.MoCMem_nrRamChkSize MoCMem_vblStruct_Core1_10ms_Nr1.MoCMem_adrChkStckEnd MoCMem_vblStruct_Core1_10ms_Nr1.MoCMem_adrChkStckStrt MoCMem_vblStruct_Core1_10ms_Nr1.MoCMem_adrChkCSAStrt MoCMem_vblStruct_Core1_10ms_Nr1.MoCMem_adrChkCSAEnd
      MoCMem_vblStruct_Core1_10ms_Nr1.MoCMem_nrRamChk MoCMem_vblStruct_Core1_10ms_Nr1.MoCMem_nrStckChk MoCMem_vblStruct_Core1_10ms_Nr1.MoCMem_nrCSAChk MoCMem_vblStruct_Core1_10ms_Nr1.MoCMem_StckOffsetPtr MoCMem_vblStruct_Core1_10ms_Nr1.MoCMem_CSAOffsetPtr MoCMem_vblStruct_Core1_10ms_Nr1.MoCMem_adrChkStckSP
      MoCMem_vblStruct_Core1_10ms_Nr1.MoCMem_RamOffsetPtr MoCMem_vblStruct_Core1_10ms_Nr1.MoCMem_ChkRAMStck MoCMem_vblStruct_Core1_10ms_Nr1.MoCMem_ctLrnRAM MoCMem_vblStruct_Core1_10ms_Nr1.MoCMem_tiRAMus MoCMem_vblStruct_Core1_10ms_Nr1.MoCMem_tiRAMusOld MoCMem_vblStruct_Core1_10ms_Nr1.MoCMem_tiRAMAccus
      MoCMem_vblStruct_Core1_10ms_Nr1.MoCMem_ctLrnErrHdlr MoCMem_vblStruct_Core1_10ms_Nr1.MoCMem_tiErrHdlrusOld MoCMem_vblStruct_Core1_10ms_Nr1.MoCMem_tiErrHdlrus MoCMem_vblStruct_Core1_10ms_Nr1.MoCMem_tiErrHdlrAccus MoCMem_vblStruct_Core1_10ms_Nr1.MoCMem_numHealFac MoCPFC_vblStructCpl_Core1_10ms_Nr1.MoCPFC_cntr
      MoCPFC_vblStructCpl_Core1_10ms_Nr1.MoCPFC_numChkword MoCPFC_vblStructCpl_Core1_10ms_Nr1.MoCPFC_numChks MoCPFC_vblStructCpl_Core1_10ms_Nr1.MoCPFC_numConCatVal MoCPFC_vblStructCpl_Core1_10ms_Nr1.MoCPFC_cntrRollg MoCPFC_vblStructCpl_Core1_10ms_Nr1.MoCPFC_aryRingBuf MoCPFC_vblStructCpl_Core1_10ms_Nr1.MoCPFC_stWrErr
      MoCPFC_vblStructCpl_Core1_10ms_Nr1.MoCPFC_RingBuf_pst.startAdr MoCPFC_vblStructCpl_Core1_10ms_Nr1.MoCPFC_RingBuf_pst.size MoCPFC_vblStructCpl_Core1_10ms_Nr1.MoCPFC_RingBuf_pst.head MoCPFC_vblStructCpl_Core1_10ms_Nr1.MoCPFC_RingBuf_pst.tail MoCSCC_varStructCpl_Core1_10ms_Nr1.MoCSCC_stChpIdCpl MoCSCC_varStructCpl_Core1_10ms_Nr1.MoCSCC_cntrDebCpl
      MoCSCC_varStructCpl_Core1_10ms_Nr1.MoCSCC_stTrmDevCpl MoCSCC_varStructNVRAM_Core1_10ms_Nr1.MoCSCC_cntrDebMaxNv MoCSCC_varStructNVRAM_Core1_10ms_Nr1.MoCSCC_cntrDebExcddThdNv MoCSCC_varStructNVRAM_Core1_10ms_Nr1.MoCSCC_cntrDebOld MoCSCC_varStruct_Core1_10ms_Nr1.MoCSCC_stErr MoCSCC_varStruct_Core1_10ms_Nr1.MoCSCC_cntrDeb
      MoCSCC_varStruct_Core1_10ms_Nr1.MoCSCC_stTrmDev MoCSCC_varStruct_Core1_10ms_Nr1.MoCSCC_stChpId MoCSCC_varStruct_Core1_10ms_Nr1.MoCSCC_stRGDChkMPU0 MoCSCC_varStruct_Core1_10ms_Nr1.MoCSCC_stRGDChkMPU1 MoExe_varStructCpl_Core1_10ms_Nr1.MoExe_ctCycCpl MoExe_varStruct_Core1_10ms_Nr1.MoExe_ctCyc
      MoGlbl_vblStructCpl_Core1_10ms_Nr1.Mo_stCplChk MoGlbl_vblStructCpl_Core1_10ms_Nr1.Mo_stMoCCpl MoGlbl_vblStruct_Core1_10ms_Nr1.Mo_stMoC
    /end LOC_MEASUREMENT
    FUNCTION_VERSION "604.0.0"

/end FUNCTION

/begin FUNCTION

    MRly_Vld2Lcy
    "1.10.0    SW Adapter Main Relay Component Package: Mapping Valid to Legacy Interface Elements"

    /begin IN_MEASUREMENT
      BattU_uSens DSM_TripChgAndClrFinshd
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      MRly_ctErlyOpng MRly_st MRly_stAct
    /end OUT_MEASUREMENT
    FUNCTION_VERSION "1.10.0"

/end FUNCTION

/begin FUNCTION

    OCWDA_Co
    "251.0.0"

    /begin DEF_CHARACTERISTIC
      OCWDA_ctDebActvErr_C OCWDA_stErrSimn_C OCWDA_swtOffRst_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      BattU_u MoCCom_ctErrFC MoCCom_ctErrMM MoCSOP_stActMsg MoCSOP_stInhbLine10ms SyC_ctPostDrvLeave
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      OCWDA_stErrMonPtt
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      OCWDA_cntrPostDrvLeaveOld OCWDA_ctBattU OCWDA_ctDebActvErr OCWDA_ctDebErrNotActv OCWDA_ctTstOCWDA OCWDA_flgClrDebDFC
      OCWDA_stABE OCWDA_stABEActv OCWDA_stCheckState OCWDA_stErrPinActv OCWDA_stWDAActv
    /end LOC_MEASUREMENT
    FUNCTION_VERSION "251.0.0"

/end FUNCTION

/begin FUNCTION

    rba_BypAdapt
    "1.41.1    Adapter to the DGS Bypass functionality"

    /begin DEF_CHARACTERISTIC
      rba_SvbbEtk_DisableProcExec_KWB rba_SvbbEtk_ResIdSrvPt_KWB rba_SvbbEtk_SrvPtEnabled_KWB rba_SvbbEtk_SrvPtResId_KWB rba_SvbbEtk_TimeOutPost_KWB rba_SvbbEtk_TimeOutPre_KWB
    /end DEF_CHARACTERISTIC
    /begin LOC_MEASUREMENT
      test_bypass_rbaBypDrv_N_Rpl_u32_BefRpl test_bypass_rbaBypDrv_T_Add_f32_BefAdd test_bypass_rbaBypDrv_T_Add_s16_BefAdd test_bypass_rbaBypDrv_T_Add_s32_BefAdd test_bypass_rbaBypDrv_T_Add_s8_BefAdd test_bypass_rbaBypDrv_T_Add_u16_BefAdd
      test_bypass_rbaBypDrv_T_Add_u32_BefAdd test_bypass_rbaBypDrv_T_Add_u8_BefAdd test_bypass_rbaBypDrv_T_Rpl_f32_BefRpl test_bypass_rbaBypDrv_T_Rpl_s16_BefRpl test_bypass_rbaBypDrv_T_Rpl_s32_BefRpl test_bypass_rbaBypDrv_T_Rpl_s8_BefRpl
      test_bypass_rbaBypDrv_T_Rpl_u16_BefRpl test_bypass_rbaBypDrv_T_Rpl_u32_BefRpl test_bypass_rbaBypDrv_T_Rpl_u8_BefRepl
    /end LOC_MEASUREMENT
    FUNCTION_VERSION "1.41.1"

/end FUNCTION

/begin FUNCTION

    rba_DcmCore_If
    "1.10.0    MSR Interface generator for Autosar DCM"

    FUNCTION_VERSION "1.10.0"

/end FUNCTION

/begin FUNCTION

    rba_DiagAdapt
    "1.9.3     Adaption of the Diagcom Interfaces to Autosar DCM to enable usage of ComDia and DiaBas with DCM"

    FUNCTION_VERSION "1.9.3"

/end FUNCTION

/begin FUNCTION

    rba_EepAdaptDGS
    "1.37.0    Eep adapter"

    /begin DEF_CHARACTERISTIC
      Eep_ClrWrCounter_CW Eep_EnFirstInit_CW Eep_EnvRamClr_CW
    /end DEF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      B_eepwf B_pwf Eep_EnvRamHist Eep_EnvRamInvld
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      Eep_ctAbsCallWrFkt Eep_ctCallWrFkt Eep_ctMaxCallWrFkt Eep_PostdrvBlkIdx_s16 Eep_stBlk Eep_stMain
      Eep_stPostDrv
    /end LOC_MEASUREMENT
    FUNCTION_VERSION "1.37.0"

/end FUNCTION

/begin FUNCTION

    rba_IoDiagPwr
    "1.20.0    IO Diagnose Power"

    FUNCTION_VERSION "1.20.0"

/end FUNCTION

/begin FUNCTION

    rba_IoExtLib
    "1.21.0    Library for external devices"

    FUNCTION_VERSION "1.21.0"

/end FUNCTION

/begin FUNCTION

    rba_MemDiag
    "2.8.0     OBD diagnosis for memory components"

    /begin OUT_MEASUREMENT
      rba_MemDiagExtd_nrLstReadSngErr rba_MemDiag_flgInhbDiag rba_MemDiag_nrLstReadErr rba_MemDiag_nrLstWrErr
    /end OUT_MEASUREMENT
    FUNCTION_VERSION "2.8.0"

/end FUNCTION









/begin FUNCTION

    Reset_CallBack
    "8.10009.0_RC40_MLcallback function for Reset-Package"

    /begin IN_MEASUREMENT
      APP_rUnFlt BattU_u CoETS_rTrq Epm_nEng GlbDa_lTotDst T15_st
      VehV_v
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      Reset_Env_ctRst Reset_Env_xGrp Reset_Env_xId
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      Reset_APP_rUnFlt Reset_BattU_u Reset_CoETS_rTrq Reset_Epm_nEng Reset_GlbDa_lTotDst Reset_T15_st
      Reset_VehV_v
    /end LOC_MEASUREMENT
    FUNCTION_VERSION "8.10009.0_RC40_ML"

/end FUNCTION

/begin FUNCTION

    SignalsExtd_Std
    "30000.1.0 Interface for readout of ECU internal measurement values extended"

    FUNCTION_VERSION "30000.1.0"

/end FUNCTION

/begin FUNCTION

    Signals_Std
    "30000.70.0Interface for readout of ECU internal measurement values"

    /begin DEF_CHARACTERISTIC
      Signals_Mode1Pid_CA Signals_Mode1SigNum_CA
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      I15031_PID83A I15031_PID9BA I15031_PIDA1A I15031_PIDA7A I15031_PIDA8A
    /end IN_MEASUREMENT
    FUNCTION_VERSION "30000.70.0"

/end FUNCTION

/begin FUNCTION

    SigQly_GlbDefn
    "1.1.0     Signal Quality Global Definition"

    FUNCTION_VERSION "1.1.0"

/end FUNCTION

/begin FUNCTION

    SigQly_Srv
    "1.2.0     Signal Quality Services"

    FUNCTION_VERSION "1.2.0"

/end FUNCTION

/begin FUNCTION

    SrvB
    "220.10.0  Basic Services"

    FUNCTION_VERSION "220.10.0"

/end FUNCTION

/begin FUNCTION

    SrvF
    "220.7.1_1 Float Services"

    FUNCTION_VERSION "220.7.1_1"

/end FUNCTION

/begin FUNCTION

    SrvX
    "220.9.0   Extended Services"

    FUNCTION_VERSION "220.9.0"

/end FUNCTION

/begin FUNCTION

    StopLmp_DD
    "30017.5.0"

    /begin DEF_CHARACTERISTIC
      StopLmp_ATS.LimitTypeMsk_C StopLmp_ATS.CnvNorm_C StopLmp_ATS.LowLim_C StopLmp_ATS.UpLim_C StopLmp_ATS.CnvFac_C StopLmp_ATS.CnvOfs_C
      StopLmp_ATS.DfltVal_C StopLmp_nThres_C StopLmp_stEna_C StopLmp_stPsDisbl_C StopLmp_tiBln_C StopLmp_tiDel_C
      StopLmp_tiMax_C StopLmp_tiTst_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Com_stStopReq DevLib_stPwrStgEnaCond DFES_stErrLamp Epm_nEng SyC_stSub T15_st
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      StopLmp_stReq StopLmp_stSrc
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      StopLmp_stDigOut_mp
    /end LOC_MEASUREMENT
    FUNCTION_VERSION "30017.5.0"

/end FUNCTION

/begin FUNCTION

    SWAdp
    "1.0.0_RC40_MLcentral SW-Adapter (legacy)"

    /begin DEF_CHARACTERISTIC
      DFP_UBR HESrv_swtScndFlwActv_C PCR_pDesVal_C RBR_HW_INH_MV_C test_bypass_rbaBypDrv_u16_C test_bypass_rbaBypDrv_u32_C
      test_bypass_rbaBypDrv_u8_C
    /end DEF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      AFS_mAirPerCyl AirSys_tFld AmbPres_dataDigSens APP1_uRaw APP_r APP_rUnFlt
      BattU_facCor BattU_u BattU_uRaw BattU_uSens BrkP_uRaw Brk_st
      CEngDsT_t Clth_st CoDsplCtl_stDiaBlnIntv CoEng_bObdTmrInctg CoEng_flgShOffCtrlDne CoEng_st
      CoEng_stMai CoEng_stOld CoEng_stStopEng CoEng_tiNormal CoEng_tiNormalOBD CoEOM_stDSCHEDDem
      CoEOM_stOpModeActTSync CoEOM_stOpModePos CoEOM_stTransActv CoETS_rTrq Com_adrSrcAdrCtlDev Com_dDrvDemTrq
      Com_nEngSpd Com_rActEngTrq Com_rActEngTrqHiRes Com_rEngDemTrq Com_stEngTrqMode Com_stMILBlinkReq
      Com_stMILReq Com_stStopReq Com_stStSys Com_stSVSReq Com_stWrnReq EcuTemp_dataDigSens
      EngDa_tEng EngDa_tFld EnvP_p EnvT_t EnvT_t_Sq EnvT_uRaw
      EpmCrS_tiIncPer Epm_nEng Epm_nEngLRes Epm_numCyl Epm_stSpd ExhMod_pRelPfilDs
      Exh_tFld Fan_rPs GEVCtl_flgReqRefAdpnIntk GlbDa_lTotDst InjCtl_qSetUnBal OilP_p
      Oil_tSwmp PCR_pDesVal PthSet_stOvrRunCoord RBR_HW_INH_MV Sia_stErrLmpReq Strt_stStaActv
      TECU_t test_bypass_rbaBypDrv_N_Rpl_u32 test_bypass_rbaBypDrv_T_Add_f32 test_bypass_rbaBypDrv_T_Add_s16 test_bypass_rbaBypDrv_T_Add_s32 test_bypass_rbaBypDrv_T_Add_s8
      test_bypass_rbaBypDrv_T_Add_u16 test_bypass_rbaBypDrv_T_Add_u32 test_bypass_rbaBypDrv_T_Add_u8 test_bypass_rbaBypDrv_T_Rpl_f32 test_bypass_rbaBypDrv_T_Rpl_s16 test_bypass_rbaBypDrv_T_Rpl_s32
      test_bypass_rbaBypDrv_T_Rpl_s8 test_bypass_rbaBypDrv_T_Rpl_u16 test_bypass_rbaBypDrv_T_Rpl_u32 test_bypass_rbaBypDrv_T_Rpl_u8 test_bypass_rba_BypEhooksModifier_u32 test_bypass_rba_Svbb_ct10ms
      test_bypass_rba_Svbb_ctSeg1 upssp_w upwg1_w upwg2_w usfk_w VehV_v
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      Epm_tiSpd2Zero SwAdp_Hbr_Dcyc SwAdp_Hbr_Period SWAdp_rPwmInDutycycle SWAdp_stDIOin SwAdp_stHbr_OnOff
      SWAdp_stPwmInSignal SWAdp_tiPwmInPeriod
    /end LOC_MEASUREMENT
    FUNCTION_VERSION "1.0.0_RC40_ML"

/end FUNCTION

/begin FUNCTION

    SyC_Vld2Lcy
    "1.19.0    SW Adapter System Control: Mapping Valid to Legacy Interface Elements"

    /begin IN_MEASUREMENT
      CoEng_st DSM_TripChgAndClrFinshd Epm_nEng
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      SyC_ctDrvEnter SyC_ctIrrSwOff SyC_ctPostDrvLeave SyC_stMn SyC_stMnOld SyC_stPostDrv
      SyC_stPostDrvDel SyC_stPreDrv SyC_stPreDrvDel SyC_stSub SyC_stSubOld SyC_tiDrv
      SyC_tiFrst10ms SyC_tiPostDrv SyC_tiPreDrv
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      SyC_stSwtOn_mp SyC_tiBoot_mp SyC_tiIniEnd_mp SyC_tiIniSyn_mp SyC_tiIni_mp
    /end LOC_MEASUREMENT
    FUNCTION_VERSION "1.19.0"

/end FUNCTION

/begin FUNCTION

    T15_Vld2Lcy
    "1.11.0    SW Adapter Terminal15 Component Package: Mapping Valid to Legacy Interface Elements"

    /begin OUT_MEASUREMENT
      T15_flgOn T15_st T15_stRaw T15_stRawTurnOffDly_Sq
    /end OUT_MEASUREMENT
    FUNCTION_VERSION "1.11.0"

/end FUNCTION

/begin FUNCTION

    WrnLmp_DD
    "30017.6.0"

    /begin DEF_CHARACTERISTIC
      WrnLmp_ATS.LimitTypeMsk_C WrnLmp_ATS.CnvNorm_C WrnLmp_ATS.LowLim_C WrnLmp_ATS.UpLim_C WrnLmp_ATS.CnvFac_C WrnLmp_ATS.CnvOfs_C
      WrnLmp_ATS.DfltVal_C WrnLmp_nThres_C WrnLmp_stEna_C WrnLmp_stPsDisbl_C WrnLmp_tiBln_C WrnLmp_tiDel_C
      WrnLmp_tiMax_C WrnLmp_tiTst_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Com_stWrnReq DevLib_stPwrStgEnaCond DFES_stErrLamp Epm_nEng SyC_stSub T15_st
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      WrnLmp_stDigOut WrnLmp_stReq WrnLmp_stSrc
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      WrnLmp_stDigOut_mp
    /end LOC_MEASUREMENT
    FUNCTION_VERSION "30017.6.0"

/end FUNCTION

/begin FUNCTION

    XcpAppl
    "4200.2.0_RC40_MLXCP Calibration Protocol Applikation"

    FUNCTION_VERSION "4200.2.0_RC40_ML"

/end FUNCTION



/***********   Start of merged COMPU_METHOD blocks    ***********/

/begin  COMPU_METHOD

    RB_RBA_Common_CentralElements_CompuMethods_Identical
    "The internal value and the physical one are identical. No physical unit available"
    RAT_FUNC
    "%10.5"
    "noUnit"

    COEFFS 0.0 1.0 0.0 0.0 0.0 1.0
    REF_UNIT RB_RBA_Common_CentralElements_Units_NoUnit

/end COMPU_METHOD


/begin  COMPU_METHOD

    AUTOSAR_CanSM_CompuMethods_CanSM_NetworkModeStateType_Enum_comp
    "Computation method for the enum CanSM_NetworkModeStateType"
    TAB_VERB
    "%10.5"
    "noUnit"

    COMPU_TAB_REF AUTOSAR_CanSM_CompuMethods_CanSM_NetworkModeStateType_Enum_comp

    REF_UNIT AUTOSAR_CanSM_Units_NoUnit

/end COMPU_METHOD


/begin  COMPU_METHOD

    AUTOSAR_CanSM_CompuMethods_CanSM_TimerStateType_Enum_comp
    "Computation method for the enum CanSM_TimerStateType"
    TAB_VERB
    "%10.5"
    "noUnit"

    COMPU_TAB_REF AUTOSAR_CanSM_CompuMethods_CanSM_TimerStateType_Enum_comp

    REF_UNIT AUTOSAR_CanSM_Units_NoUnit

/end COMPU_METHOD


/begin  COMPU_METHOD

    AUTOSAR_CanSM_CompuMethods_CanSM_BusOffRecoveryStateType_Enum_comp
    "Computation method for the enum CanSM_BusOffRecoveryStateType"
    TAB_VERB
    "%10.5"
    "noUnit"

    COMPU_TAB_REF AUTOSAR_CanSM_CompuMethods_CanSM_BusOffRecoveryStateType_Enum_comp

    REF_UNIT AUTOSAR_CanSM_Units_NoUnit

/end COMPU_METHOD


/begin  COMPU_METHOD

    AUTOSAR_Com_CompuMethods_Com_IPduStatus_enum_type
    "Computation Method for ComIPdu Calibration Status"
    TAB_VERB
    "%10.5"
    "noUnit"

    COMPU_TAB_REF AUTOSAR_Com_CompuMethods_Com_IPduStatus_enum_type

    REF_UNIT AUTOSAR_Com_Units_NoUnit

/end COMPU_METHOD


/begin  COMPU_METHOD

    AUTOSAR_EthSM_CompuMethods_EthSM_Enum_NetworkModeStateType
    "Enumeration for EthSM Network Mode State Type"
    TAB_VERB
    "%10.5"
    "noUnit"

    COMPU_TAB_REF AUTOSAR_EthSM_CompuMethods_EthSM_Enum_NetworkModeStateType

    REF_UNIT AUTOSAR_EthSM_Units_NoUnit

/end COMPU_METHOD


/begin  COMPU_METHOD

    AUTOSAR_LinSM_CompuMethods_LinSM_CompuMethod_OperationalMode
    "computation method displaying the Operational modes of LinSM"
    TAB_VERB
    "%10.5"
    "noUnit"

    COMPU_TAB_REF AUTOSAR_LinSM_CompuMethods_LinSM_CompuMethod_OperationalMode

    REF_UNIT AUTOSAR_LinSM_Units_NoUnit

/end COMPU_METHOD


/begin  COMPU_METHOD

    AUTOSAR_TcpIp_CompuMethods_TcpIp_Enum_StateType
    "Enumeration for TcpIp State Type"
    TAB_VERB
    "%10.5"
    "noUnit"

    COMPU_TAB_REF AUTOSAR_TcpIp_CompuMethods_TcpIp_Enum_StateType

    REF_UNIT AUTOSAR_TcpIp_Units_NoUnit

/end COMPU_METHOD


/begin  COMPU_METHOD

    AUTOSAR_Platform_CompuMethods_boolean
    ""
    TAB_VERB
    "%10.5"
    ""

    COMPU_TAB_REF AUTOSAR_Platform_CompuMethods_boolean


/end COMPU_METHOD


/begin  COMPU_METHOD

    RB_RBA_rba_IoDiagHlfBr_CompuMethods_rba_IoDiagHlfBr_SwtOffDiagSts_tu8_CompuMethod
    "CompuMethod for state of switch-off mode diagnosis"
    TAB_VERB
    "%10.5"
    "noUnit"

    COMPU_TAB_REF RB_RBA_rba_IoDiagHlfBr_CompuMethods_rba_IoDiagHlfBr_SwtOffDiagSts_tu8_CompuMethod

    REF_UNIT RB_RBA_rba_IoDiagHlfBr_Units_NoUnit

/end COMPU_METHOD


/begin  COMPU_METHOD

    RB_RBA_rba_IoSigHlfBr_CompuMethods_rba_IoSigHlfBr_HWSigPathCompuMethod_bds_Pb_preDefRef_vrnt01
    "CompuMethod used for calibration parameters for signals in the post build data set bds_Pb_preDefRef_vrnt01"
    TAB_VERB
    "%10.5"
    "noUnit"

    COMPU_TAB_REF RB_RBA_rba_IoSigHlfBr_CompuMethods_rba_IoSigHlfBr_HWSigPathCompuMethod_bds_Pb_preDefRef_vrnt01

    REF_UNIT RB_RBA_rba_IoSigHlfBr_Units_NoUnit

/end COMPU_METHOD


/begin  COMPU_METHOD

    RB_RBA_rba_MRly_BswModuleDescriptions_rba_MRly_Ctrl_States_CompuMethod
    "CompuMethod for control states of Main Relay"
    TAB_VERB
    "%10.5"
    "nounit"

    COMPU_TAB_REF RB_RBA_rba_MRly_BswModuleDescriptions_rba_MRly_Ctrl_States_CompuMethod

    REF_UNIT RB_RBA_rba_MRly_Units_NoUnit

/end COMPU_METHOD


/begin  COMPU_METHOD

    RB_RBA_rba_MRly_BswModuleDescriptions_rba_MRly_Calibration_Common_milliseconds_CompuMethod
    "CompuMethod for calibration in milliseconds of Main Relay"
    RAT_FUNC
    "%10.5"
    "ms"

    COEFFS 0.0 -1.0 0.0 0.0 0.0 -1.0
    REF_UNIT RB_RBA_rba_MRly_Units_ms

/end COMPU_METHOD


/begin  COMPU_METHOD

    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_PercConversion
    "Os measurement conversion factor for percent"
    RAT_FUNC
    "%10.5"
    "%"

    COEFFS 0.0 -1.0 0.0 0.0 0.0 -0.01
    REF_UNIT RB_RBA_rba_OsMeasmt_Units_Perc

/end COMPU_METHOD


/begin  COMPU_METHOD

    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    "Task response time computation method"
    RAT_FUNC
    "%10.5"
    "us"

    COEFFS 0.0 -1.0 0.0 0.0 0.0 -0.01
    REF_UNIT RB_RBA_rba_OsMeasmt_Units_MicroSec

/end COMPU_METHOD


/begin  COMPU_METHOD

    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_CET_T1_CompuMethod
    "Task CET computation method for T1"
    RAT_FUNC
    "%10.5"
    "us"

    COEFFS 0.0 -1.0 0.0 0.0 0.0 -1.0
    REF_UNIT RB_RBA_rba_OsShell_Units_MicroSec

/end COMPU_METHOD


/begin  COMPU_METHOD

    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_T1_PercConversion
    "Os measurement conversion factor for T1 percent"
    RAT_FUNC
    "%10.5"
    "%"

    COEFFS 0.0 -1.0 0.0 0.0 0.0 -0.01
    REF_UNIT RB_RBA_rba_OsMeasmt_Units_Perc

/end COMPU_METHOD


/begin  COMPU_METHOD

    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_SwTrace_InitMode_CompuMethod
    "Enum for different Gliwa Init Modes"
    TAB_VERB
    "%10.5"
    "noUnit"

    COMPU_TAB_REF RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_SwTrace_InitMode_CompuMethod

    REF_UNIT RB_RBA_rba_OsMeasmt_Units_NoUnit

/end COMPU_METHOD


/begin  COMPU_METHOD

    RB_RBA_rba_OsShell_CompuMethods_rba_OsShell_ResourceConversion
    "rba_OsShell resource conversion factor"
    RAT_FUNC
    "%10.5"
    "%"

    COEFFS 0.0 -1.0 0.0 0.0 0.0 -0.01
    REF_UNIT RB_RBA_rba_OsShell_Units_Perc

/end COMPU_METHOD


/begin  COMPU_METHOD

    RB_RBA_rba_Reset_CompuMethods_rba_Reset_Id_ten
    "CompuMethod for the Reset Ids"
    TAB_VERB
    "%10.5"
    "noUnit"

    COMPU_TAB_REF RB_RBA_rba_Reset_CompuMethods_rba_Reset_Id_ten

    REF_UNIT RB_RBA_rba_Reset_Units_NoUnit

/end COMPU_METHOD


/begin  COMPU_METHOD

    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    "Timer ticks in Micro Seconds"
    RAT_FUNC
    "%10.5"
    "us"

    COEFFS 0.0 -1.0 0.0 0.0 0.0 -0.01
    REF_UNIT RB_RBA_rba_Runtime_Units_MicroSec

/end COMPU_METHOD


/begin  COMPU_METHOD

    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    "Percentage Value"
    RAT_FUNC
    "%10.5"
    "%"

    COEFFS 0.0 -1.0 0.0 0.0 0.0 -0.00152587890625
    REF_UNIT RB_RBA_rba_Runtime_Units_Perc

/end COMPU_METHOD


/begin  COMPU_METHOD

    RB_RBA_rba_SvbbEtk_CompuMethods_rba_SvbbEtk_StateEnable_CM
    "CompuMethod for SvbbEtk state"
    TAB_VERB
    "%10.5"
    "noUnit"

    COMPU_TAB_REF RB_RBA_rba_SvbbEtk_CompuMethods_rba_SvbbEtk_StateEnable_CM

    REF_UNIT RB_RBA_rba_SvbbEtk_Units_NoUnit

/end COMPU_METHOD


/begin  COMPU_METHOD

    RB_RBA_rba_SvbbEtk_CompuMethods_rba_SvbbEtk_Enable_CM
    "CompuMethod for SvbbEtk state"
    TAB_VERB
    "%10.5"
    "noUnit"

    COMPU_TAB_REF RB_RBA_rba_SvbbEtk_CompuMethods_rba_SvbbEtk_Enable_CM

    REF_UNIT RB_RBA_rba_SvbbEtk_Units_NoUnit

/end COMPU_METHOD


/begin  COMPU_METHOD

    RB_RBA_rba_SyC_States_BswModuleDescriptions_rba_SyC_States_CompuMethod
    "CompuMethod for states in System Control"
    TAB_VERB
    "%10.5"
    "nounit"

    COMPU_TAB_REF RB_RBA_rba_SyC_States_BswModuleDescriptions_rba_SyC_States_CompuMethod

    REF_UNIT RB_RBA_rba_SyC_States_Units_rba_SyC_States_NoUnit

/end COMPU_METHOD


/begin  COMPU_METHOD

    RB_RBA_rba_SyC_States_BswModuleDescriptions_rba_SyC_Prolongers_CompuMethod
    "CompuMethod for Prolongers in System Control"
    RAT_FUNC
    "%10.5"
    "s"

    COEFFS 0.0 1.0 0.0 0.0 0.0 1.0
    REF_UNIT RB_RBA_rba_SyC_States_Units_rba_SyC_States_1second

/end COMPU_METHOD


/begin  COMPU_METHOD

    RB_RBA_rba_SyC_States_BswModuleDescriptions_rba_SyC_States_PostDrive_CompuMethod
    "CompuMethod for PostDrive state of System Control"
    TAB_VERB
    "%10.5"
    "nounit"

    COMPU_TAB_REF RB_RBA_rba_SyC_States_BswModuleDescriptions_rba_SyC_States_PostDrive_CompuMethod

    REF_UNIT RB_RBA_rba_SyC_States_Units_rba_SyC_States_NoUnit

/end COMPU_METHOD


/begin  COMPU_METHOD

    RB_RBA_rba_SyC_States_BswModuleDescriptions_rba_SyC_States_PrepareDrive_CompuMethod
    "CompuMethod for PrepareDrive state in System Control"
    TAB_VERB
    "%10.5"
    "nounit"

    COMPU_TAB_REF RB_RBA_rba_SyC_States_BswModuleDescriptions_rba_SyC_States_PrepareDrive_CompuMethod

    REF_UNIT RB_RBA_rba_SyC_States_Units_rba_SyC_States_NoUnit

/end COMPU_METHOD


/begin  COMPU_METHOD

    RB_RBA_rba_SyC_States_BswModuleDescriptions_rba_SyC_States_PrepareShutdown_CompuMethod
    "CompuMethod for PrepareShutdown state in System Control"
    TAB_VERB
    "%10.5"
    "nounit"

    COMPU_TAB_REF RB_RBA_rba_SyC_States_BswModuleDescriptions_rba_SyC_States_PrepareShutdown_CompuMethod

    REF_UNIT RB_RBA_rba_SyC_States_Units_rba_SyC_States_NoUnit

/end COMPU_METHOD


/begin  COMPU_METHOD

    RB_RBA_rba_SyC_States_BswModuleDescriptions_rba_SyC_States_Wait_CompuMethod
    "CompuMethod for Wait state in System Control"
    TAB_VERB
    "%10.5"
    "nounit"

    COMPU_TAB_REF RB_RBA_rba_SyC_States_BswModuleDescriptions_rba_SyC_States_Wait_CompuMethod

    REF_UNIT RB_RBA_rba_SyC_States_Units_rba_SyC_States_NoUnit

/end COMPU_METHOD


/begin  COMPU_METHOD

    RB_RBA_rba_SyC_States_BswModuleDescriptions_rba_SyC_States_Calibration_Timeout_CompuMethod
    "CompuMethod for timeout calibration for states in System Control"
    RAT_FUNC
    "%10.5"
    "s"

    COEFFS 0.0 1000.0 0.0 0.0 0.0 1.0
    REF_UNIT RB_RBA_rba_SyC_States_Units_rba_SyC_States_1second

/end COMPU_METHOD


/begin  COMPU_METHOD

    RB_RBA_rba_T15_BswModuleDescriptions_rba_T15_Signal_Status_CompuMethod
    "CompuMethod for signal status of Terminal 15"
    TAB_VERB
    "%10.5"
    "nounit"

    COMPU_TAB_REF RB_RBA_rba_T15_BswModuleDescriptions_rba_T15_Signal_Status_CompuMethod

    REF_UNIT RB_RBA_rba_T15_Units_NoUnit

/end COMPU_METHOD


/begin  COMPU_METHOD

    RB_RBA_rba_T15_BswModuleDescriptions_rba_T15_Signal_StatusValid_CompuMethod
    "CompuMethod for signal status validity of Terminal 15"
    TAB_VERB
    "%10.5"
    "nounit"

    COMPU_TAB_REF RB_RBA_rba_T15_BswModuleDescriptions_rba_T15_Signal_StatusValid_CompuMethod

    REF_UNIT RB_RBA_rba_T15_Units_NoUnit

/end COMPU_METHOD


/begin  COMPU_METHOD

    RB_RBA_rba_T15_BswModuleDescriptions_rba_T15_Diag_Calibration_CompuMethod
    "CompuMethod for calibration diagnosis of Terminal 15"
    RAT_FUNC
    "%10.5"
    "ms"

    COEFFS 0.0 -1.0 0.0 0.0 0.0 -1.0
    REF_UNIT RB_RBA_rba_T15_Units_ms

/end COMPU_METHOD


/begin  COMPU_METHOD

    RB_RBA_rba_T15_BswModuleDescriptions_rba_T15_Signal_Calibration_CompuMethod
    "CompuMethod for signal calibration of Terminal 15"
    RAT_FUNC
    "%10.5"
    "ms"

    COEFFS 0.0 -1.0 0.0 0.0 0.0 -10.0
    REF_UNIT RB_RBA_rba_T15_Units_ms

/end COMPU_METHOD


/begin  COMPU_METHOD

    SwComponentTypes_ComDia_Dcm_Rte_Adapter_SwComponentTypes_EngN
    ""
    RAT_FUNC
    "%10.5"
    "rpm"

    COEFFS 0.0 0.0 2.0 0.0 1.0 1.0
    REF_UNIT AUTOSAR_AISpecification_Units_Rpm

/end COMPU_METHOD


/begin  COMPU_METHOD

    SwComponentTypes_ComDia_Dcm_Rte_Adapter_SwComponentTypes_t100msxs_uw_b6553p5
    ""
    RAT_FUNC
    "%10.5"
    "ms"

    COEFFS 0.0 0.0 1.0 0.0 0.1 1.0
    REF_UNIT RB_RBA_rba_MRly_Units_ms

/end COMPU_METHOD


/begin  COMPU_METHOD

    DefaultIdenticalCompu
    ""
    RAT_FUNC
    "%10.5"
    ""

    COEFFS 0.0 1.0 0.0 0.0 0.0 1.0

/end COMPU_METHOD


/begin  COMPU_METHOD

    TimedCom_HrmcCh_StMac_COMPU_VERB
    "Mapping for enum TimedCom_HrmcCh_StMac"
    TAB_VERB
    "%6.3"
    ""

    COMPU_TAB_REF TimedCom_HrmcCh_StMac_COMPU_VERB


/end COMPU_METHOD


/begin  COMPU_METHOD

    TimedCom_HrmcCh_Err_COMPU_VERB
    "Mapping for enum TimedCom_HrmcCh_Err"
    TAB_VERB
    "%6.3"
    ""

    COMPU_TAB_REF TimedCom_HrmcCh_Err_COMPU_VERB


/end COMPU_METHOD


/begin  COMPU_METHOD

    TimedCom_AsyncCh_StMac_COMPU_VERB
    "Mapping for enum TimedCom_AsyncCh_StMac"
    TAB_VERB
    "%6.3"
    ""

    COMPU_TAB_REF TimedCom_AsyncCh_StMac_COMPU_VERB


/end COMPU_METHOD


/begin  COMPU_METHOD

    TimedCom_AsyncCh_Err_COMPU_VERB
    "Mapping for enum TimedCom_AsyncCh_Err"
    TAB_VERB
    "%6.3"
    ""

    COMPU_TAB_REF TimedCom_AsyncCh_Err_COMPU_VERB


/end COMPU_METHOD


/begin  COMPU_METHOD

    OneToOne_us
    ""
    RAT_FUNC
    "%6.2"
    "us"

    COEFFS 0 1 0 0 0 1

/end COMPU_METHOD


/***********   End of merged COMPU_METHOD blocks    ***********/
/begin COMPU_METHOD

    AccHi
    ""
    RAT_FUNC
    "%7.6"
    "m/s^2"

    COEFFS 0 10000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    ACCHRGRINTKT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ACCHRGRINTKT_TYPAVL_SC_Compu
    
/end COMPU_METHOD



/***********   Start of merged COMPU_VTAB blocks    ***********/


/begin COMPU_VTAB
    AUTOSAR_CanSM_CompuMethods_CanSM_NetworkModeStateType_Enum_comp
    "Computation method for the enum CanSM_NetworkModeStateType"
    TAB_VERB
    10
    0 "CANSM_BSM_S_NOCOM"
    1 "CANSM_BSM_S_SILENTCOM"
    2 "CANSM_BSM_S_FULLCOM"
    3 "CANSM_BSM_S_NOT_INITIALIZED"
    4 "CANSM_BSM_S_PRE_NOCOM"
    5 "CANSM_BSM_WUVALIDATION"
    6 "CANSM_BSM_S_PRE_FULLCOM"
    7 "CANSM_BSM_S_SET_BAUDRATE"
    8 "CANSM_BSM_S_SILENTCOM_BOR"
    9 "CANSM_BSM_S_TX_TIMEOUT_EXCEPTION"
/end COMPU_VTAB




/begin COMPU_VTAB
    AUTOSAR_CanSM_CompuMethods_CanSM_TimerStateType_Enum_comp
    "Computation method for the enum CanSM_TimerStateType"
    TAB_VERB
    4
    1 "CANSM_TIMER_INIT"
    2 "CANSM_TIMER_RUNNING"
    3 "CANSM_TIMER_ELAPSED"
    4 "CANSM_TIMER_CANCELLED"
/end COMPU_VTAB




/begin COMPU_VTAB
    AUTOSAR_CanSM_CompuMethods_CanSM_BusOffRecoveryStateType_Enum_comp
    "Computation method for the enum CanSM_BusOffRecoveryStateType"
    TAB_VERB
    6
    1 "CANSM_BOR_IDLE"
    2 "CANSM_S_BUS_OFF_CHECK"
    3 "CANSM_S_NO_BUS_OFF"
    4 "CANSM_S_TX_OFF"
    5 "CANSM_S_RESTART_CC"
    6 "CANSM_S_RESTART_CC_WAIT"
/end COMPU_VTAB




/begin COMPU_VTAB
    AUTOSAR_Com_CompuMethods_Com_IPduStatus_enum_type
    "Computation Method for ComIPdu Calibration Status"
    TAB_VERB
    2
    0 "INACTIVE"
    1 "ACTIVE"
/end COMPU_VTAB




/begin COMPU_VTAB
    AUTOSAR_EthSM_CompuMethods_EthSM_Enum_NetworkModeStateType
    "Enumeration for EthSM Network Mode State Type"
    TAB_VERB
    6
    0 "ETHSM_STATE_OFFLINE"
    1 "ETHSM_STATE_WAIT_TRCVLINK"
    2 "ETHSM_STATE_WAIT_ONLINE"
    3 "ETHSM_STATE_ONLINE"
    4 "ETHSM_STATE_ONHOLD"
    5 "ETHSM_STATE_WAIT_OFFLINE"
/end COMPU_VTAB




/begin COMPU_VTAB
    AUTOSAR_LinSM_CompuMethods_LinSM_CompuMethod_OperationalMode
    "computation method displaying the Operational modes of LinSM"
    TAB_VERB
    2
    1 "LINSM_FULL_COM"
    2 "LINSM_NO_COM"
/end COMPU_VTAB




/begin COMPU_VTAB
    AUTOSAR_TcpIp_CompuMethods_TcpIp_Enum_StateType
    "Enumeration for TcpIp State Type"
    TAB_VERB
    5
    1 "TCPIP_STATE_ONLINE"
    2 "TCPIP_STATE_ONHOLD"
    3 "TCPIP_STATE_OFFLINE"
    4 "TCPIP_STATE_STARTUP"
    5 "TCPIP_STATE_SHUTDOWN"
/end COMPU_VTAB




/begin COMPU_VTAB
    AUTOSAR_Platform_CompuMethods_boolean
    ""
    TAB_VERB
    2
    0 "FALSE"
    1 "TRUE"
/end COMPU_VTAB




/begin COMPU_VTAB
    RB_RBA_rba_IoDiagHlfBr_CompuMethods_rba_IoDiagHlfBr_SwtOffDiagSts_tu8_CompuMethod
    "CompuMethod for state of switch-off mode diagnosis"
    TAB_VERB
    6
    0 "RBA_IODIAGHLFBR_SWTOFFDIAG_NOTREQ"
    1 "RBA_IODIAGHLFBR_SWTOFFDIAG_START_REQD"
    2 "RBA_IODIAGHLFBR_SWTOFFDIAG_ABORT_REQD"
    3 "RBA_IODIAGHLFBR_SWTOFFDIAG_RUNNG"
    4 "RBA_IODIAGHLFBR_SWTOFFDIAG_ABORTED"
    5 "RBA_IODIAGHLFBR_SWTOFFDIAG_FINSHD"
/end COMPU_VTAB




/begin COMPU_VTAB
    RB_RBA_rba_IoSigHlfBr_CompuMethods_rba_IoSigHlfBr_HWSigPathCompuMethod_bds_Pb_preDefRef_vrnt01
    "CompuMethod used for calibration parameters for signals in the post build data set bds_Pb_preDefRef_vrnt01"
    TAB_VERB
    1
    0 "HBR1_PIN_K13_K12 (HWSigPath_NULL_07_01)"
/end COMPU_VTAB




/begin COMPU_VTAB
    RB_RBA_rba_MRly_BswModuleDescriptions_rba_MRly_Ctrl_States_CompuMethod
    "CompuMethod for control states of Main Relay"
    TAB_VERB
    2
    0 "rba_MRly_Ctrl_Open_e"
    1 "rba_MRly_Ctrl_Close_e"
/end COMPU_VTAB




/begin COMPU_VTAB
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_SwTrace_InitMode_CompuMethod
    "Enum for different Gliwa Init Modes"
    TAB_VERB
    3
    0 "GLIWA_T1_PRODUCTIVE"
    1 "GLIWA_T1_DEVELOPMENT"
    2 "GLIWA_T1_OFF"
/end COMPU_VTAB




/begin COMPU_VTAB
    RB_RBA_rba_Reset_CompuMethods_rba_Reset_Id_ten
    "CompuMethod for the Reset Ids"
    TAB_VERB
    3592
    0 "RBA_RESET_POWERON_E"
    1 "RBA_RESET_POWERON_WARM_E"
    2 "RBA_RESET_POWERON_WDT_E"
    3 "RBA_RESET_POWERON_KL15_E"
    4 "RBA_RESET_ESR0_E"
    5 "RBA_RESET_ESR1_E"
    6 "RBA_RESET_WDT_E"
    7 "RBA_RESET_SMU_E"
    8 "RBA_RESET_STM012_E"
    9 "RBA_RESET_OCDS_E"
    10 "RBA_RESET_CB013_E"
    11 "RBA_RESET_SWD_E"
    12 "RBA_RESET_HSM_E"
    13 "RBA_RESET_TP_E"
    14 "RBA_RESET_CANWAK_E"
    15 "RBA_RESET_PIN1WAK_E"
    16 "RBA_RESET_PIN2WAK_E"
    17 "RBA_RESET_PIN3WAK_E"
    18 "RBA_RESET_STCWAK_E"
    19 "RBA_RESET_HW_E"
    4096 "RBA_RESET_POWERON_SIMU_E"
    4097 "RBA_RESET_HWRESET_SIMU_E"
    4098 "RBA_RESET_RB_PROG_E"
    4099 "RBA_RESET_CBPROG_E"
    4100 "RBA_RESET_CBCPU_E"
    4101 "RBA_RESET_RB_PROG_ILLEGAL_PATH_E"
    4102 "RBA_RESET_TSW_EXIT_E"
    4103 "RBA_RESET_TSW_MAGICPATTERN_E"
    4104 "RBA_RESET_TRAP_IN_SB_E"
    4105 "RBA_RESET_SWDESTRST_RAMVALID_E"
    4106 "RBA_RESET_SWDESTRST_RAMINVALID_E"
    4107 "RBA_RESET_SWDESTRST_REQ_RAMVALID_E"
    4108 "RBA_RESET_OBD_SVC11_RESET_E"
    4109 "RBA_RESET_PLL_LOSS_OF_LOCK_E"
    4110 "RBA_RESET_BCTL_FCCU_ERRABORT_E"
    4111 "RBA_RESET_RBA_BOOTCTRL_SB_OVERLAYRAM_INIT_FAILURE"
    4112 "RBA_RESET_COMMON_DESTRUCTIVE_E"
    4113 "RBA_RESET_DUMMY06_E"
    4114 "RBA_RESET_DUMMY07_E"
    4115 "RBA_RESET_DUMMY08_E"
    4116 "RBA_RESET_POWERON_SIMU_SOFTRST_E"
    4117 "RBA_RESET_CBPROG_SOFTRST_E"
    12288 "ECUM_E_RESET_CONFIGURATION_DATA_INCONSISTENT"
    12289 "ECUM_E_RESET_GENERAL"
    12290 "ECUM_E_RESET_INVALID_PTR_RETURNED"
    12291 "ECUM_E_RESET_NULL_PTR_RETURNED"
    12292 "ECUM_E_RESET_RAM_CHECK_FAILED"
    12293 "ECUM_E_RESET_START_CORE_FAILED"
    12294 "ECUM_RESET"
    12295 "MCU_RB_RESET_BUSERR_SBCU"
    12296 "MCU_RB_RESET_DTS_ERROR"
    12297 "MCU_RB_RESET_UNKNOWN"
    12298 "MCU_RB_RESET_XBAR_DOM0_PROT_ID_SCI01_DMU"
    12299 "MCU_RB_RESET_XBAR_DOM0_PROT_ID_SCI02_DAM0"
    12300 "MCU_RB_RESET_XBAR_DOM0_PROT_ID_SCI03_CPU0P"
    12301 "MCU_RB_RESET_XBAR_DOM0_PROT_ID_SCI04_CPU0S"
    12302 "MCU_RB_RESET_XBAR_DOM0_PROT_ID_SCI05_CPU1P"
    12303 "MCU_RB_RESET_XBAR_DOM0_PROT_ID_SCI06_CPU1S"
    12304 "MCU_RB_RESET_XBAR_DOM0_PROT_ID_SCI07_CPU2P"
    12305 "MCU_RB_RESET_XBAR_DOM0_PROT_ID_SCI08_CPU2S"
    12306 "MCU_RB_RESET_XBAR_DOM0_PROT_ID_SCI09_CPU3P"
    12307 "MCU_RB_RESET_XBAR_DOM0_PROT_ID_SCI10_CPU3S"
    12308 "MCU_RB_RESET_XBAR_DOM0_PROT_ID_SCI11_LMU0"
    12309 "MCU_RB_RESET_XBAR_DOM0_PROT_ID_SCI14_MINI_MCDS"
    12310 "MCU_RB_RESET_XBAR_DOM0_PROT_ID_SCI15_DEFAULT_SLAVE"
    12311 "MCU_RB_RESET_XBAR_DOM0_TRANS_ID_MCI00_DMA_MIF0"
    12312 "MCU_RB_RESET_XBAR_DOM0_TRANS_ID_MCI01_SFI_F2S"
    12313 "MCU_RB_RESET_XBAR_DOM0_TRANS_ID_MCI02_CPU0"
    12314 "MCU_RB_RESET_XBAR_DOM0_TRANS_ID_MCI03_CPU1"
    12315 "MCU_RB_RESET_XBAR_DOM0_TRANS_ID_MCI04_CPU2"
    12316 "MCU_RB_RESET_XBAR_DOM0_TRANS_ID_MCI05_CPU3"
    12317 "MCU_RB_RESET_XBAR_DOM0_TRANS_ID_MCI08_HSSL0"
    12318 "MCU_RB_RESET_XBAR_DOM0_TRANS_ID_MCI09_GETH"
    12319 "MCU_RB_RESET_XBAR_DOM0_TRANS_ID_SCI01_DMU"
    12320 "MCU_RB_RESET_XBAR_DOM0_TRANS_ID_SCI02_DAM0"
    12321 "MCU_RB_RESET_XBAR_DOM0_TRANS_ID_SCI03_CPU0P"
    12322 "MCU_RB_RESET_XBAR_DOM0_TRANS_ID_SCI04_CPU0S"
    12323 "MCU_RB_RESET_XBAR_DOM0_TRANS_ID_SCI05_CPU1P"
    12324 "MCU_RB_RESET_XBAR_DOM0_TRANS_ID_SCI06_CPU1S"
    12325 "MCU_RB_RESET_XBAR_DOM0_TRANS_ID_SCI07_CPU2P"
    12326 "MCU_RB_RESET_XBAR_DOM0_TRANS_ID_SCI08_CPU2S"
    12327 "MCU_RB_RESET_XBAR_DOM0_TRANS_ID_SCI09_CPU3P"
    12328 "MCU_RB_RESET_XBAR_DOM0_TRANS_ID_SCI10_CPU3S"
    12329 "MCU_RB_RESET_XBAR_DOM0_TRANS_ID_SCI11_LMU0"
    12330 "MCU_RB_RESET_XBAR_DOM0_TRANS_ID_SCI14_MINI_MCDS"
    12331 "MCU_RB_RESET_XBAR_DOM0_TRANS_ID_SCI15_DEFAULT_SLAVE"
    12332 "MCU_RESET_ILLEGAL_CALL_OF_MCU_PERFORM_RESET"
    12333 "MCU_RESET_UNDEFINED"
    12334 "RBA_ADCDS_RESET_UNEXPECTED_FUNCTION_CALL_TO_SETGAIN"
    12335 "RBA_EMM_ERRORPIN_SWRESET_CFG_RESET"
    12336 "RBA_EMM_EVR13OVCFG_ERROR_RESET"
    12337 "RBA_EMM_EVR13UVCFG_ERROR_RESET"
    12338 "RBA_EMM_EVR33OVCFG_ERROR_RESET"
    12339 "RBA_EMM_EVR33UVCFG_ERROR_RESET"
    12340 "RBA_EMM_EVR50OVCFG_ERROR_RESET"
    12341 "RBA_EMM_EVR50UVCFG_ERROR_RESET"
    12342 "RBA_EMM_INT_TEMP_MON_RESET"
    12343 "RBA_EMM_INVALID_STAT_RESET"
    12344 "RBA_EMM_UNEXPECTED_LOCK_RESET"
    12345 "RBA_EMM_VDDMOVCFG_ERROR_RESET"
    12346 "RBA_EMM_VDDMUVCFG_ERROR_RESET"
    12347 "RBA_EMM_VDDPDOVCFG_ERROR_RESET"
    12348 "RBA_EMM_VDDPDUVCFG_ERROR_RESET"
    12349 "RBA_EMM_VEVRSBOVCFG_ERROR_RESET"
    12350 "RBA_EMM_VEVRSBUVCFG_ERROR_RESET"
    12351 "RBA_MPU_COREMPU_INVALID_ADDRESS_ALIGNMENT_RESET"
    12352 "RBA_MPU_COREMPU_INVALID_NUMBER_CODE_REGIONS_RESET"
    12353 "RBA_MPU_COREMPU_INVALID_NUMBER_DATA_REGIONS_RESET"
    12354 "RBA_MPU_COREMPU_INVALID_NUMBER_REGIONS_RESET"
    12355 "RBA_MPU_COREMPU_INVALID_REGION_RESET"
    12356 "RBA_MPU_COREMPU_INVALID_SETUP_RESET"
    12357 "RBA_MPU_COREMPU_REGION_ILLEGAL_ACCESS_RESET"
    12358 "RBA_MPU_COREMPU_REGION_START_END_ADDRESS_RESET"
    12359 "RBA_MPU_COREMPU_UNEQUAL_NUMBER_REGIONS_RESET"
    12360 "RBA_MPU_INVALID_ADDRESS_ALIGNMENT_RESET"
    12361 "RBA_MPU_INVALID_NUMBER_REGIONS_RESET"
    12362 "RBA_MPU_INVALID_NUMBER_SYSRAM_REGIONS_RESET"
    12363 "RBA_MPU_INVALID_REGION_ADDRESS_RESET"
    12364 "RBA_MPU_INVALID_SYSRAM_REGION_ADDRESS_RESET"
    12365 "RBA_MPU_REGION_START_END_ADDRESS_RESET"
    12366 "RBA_MPU_SYSRAM_CACHEABLE_REGION_ADDRESS_RESET"
    12367 "RBA_MULTISTACKTRACE_UNDEROVERFLOW"
    12368 "RBA_RESET_BSW_DEFAULT_E"
    12369 "RBA_RESET_CANSOPTEST_FAILED"
    12370 "RBA_RESET_FIRST_SWRESET"
    12371 "RBA_RESET_FRSOPTEST_FAILED"
    12372 "RBA_RESET_INFOBLK_FAULT"
    12373 "RBA_RESET_INJSOPTEST_FAILED"
    12374 "RBA_RESET_MOCCOM_WRTEST_FAILED"
    12375 "RBA_RESET_MOCEMM_CPLCHK_FAILED"
    12376 "RBA_RESET_MOCEMM_INITORDER"
    12377 "RBA_RESET_MOCEMM_PLAUSY_FAILED"
    12378 "RBA_RESET_MOCEMM_STARTUPTEST_FAILED"
    12379 "RBA_RESET_MOCEMM_WTCHK_FAILED"
    12380 "RBA_RESET_MOCMEMSTRTUP_ECC_FAILED"
    12381 "RBA_RESET_MOCMEMSTRTUP_ININORD"
    12382 "RBA_RESET_MOCMEMSTRTUP_RAMCHK_FAILED"
    12383 "RBA_RESET_MOCMEMSTRTUP_ROMCHK_FAILED"
    12384 "RBA_RESET_MOCMEMSTRTUP_WTCHK_FAILED"
    12385 "RBA_RESET_MOCSCC_FAILED"
    12386 "RBA_RESET_MOCSOP_INHBBUS_ERROR"
    12387 "RBA_RESET_MOCSOP_REPSOPTEST"
    12388 "RBA_RESET_MOCSOP_WRGSTATE"
    12389 "RBA_RESET_MOCSOP_WRTEST_FAILED"
    12390 "RBA_RESET_RBA_BSWSRV_ADDRESS_RANGE_VIOLATION_E"
    12391 "RBA_RESET_RBA_BSWSRV_INTSUSP_CORRUPTION"
    12392 "RBA_RESET_RBA_BSWSRV_INTSUSP_CTR_VIOLATION_E"
    12393 "RBA_RESET_RBA_BSWSRV_LOCK_CTR_VIOLATION_E"
    12394 "RBA_RESET_RBA_BSWSRV_LOCK_NESTING_VIOLATION_E"
    12395 "RBA_RESET_RBA_BYP_FINISH_E"
    12396 "RBA_RESET_RBA_CALWUPFINISH_E"
    12397 "RBA_RESET_RBA_IOEXTFSCSRV_CLK_ERROR_E"
    12398 "RBA_RESET_RBA_IOEXTFSCSRV_SPI_ERROR_E"
    12399 "RBA_RESET_RBA_MEMLAY_CB_RAM1_SIZE_E"
    12400 "RBA_RESET_RBA_MEMLAY_CB_RAM2_SIZE_E"
    12401 "RBA_RESET_RBA_MEMLAY_CB_SYS_SIZE_E"
    12402 "RBA_RESET_RBA_MEMLAY_PCACHE_TIME_E"
    12403 "RBA_RESET_RBA_SVBB_FINISH_E"
    12404 "RBA_RESET_SOPTESTTIMEOUT_ERROR"
    12405 "RBA_RESET_SOPTEST_FAILED"
    12406 "RBA_RESET_SWRST_EEPACTFIRSTINIT_E"
    12407 "RBA_RESET_SWRST_EEPDELENVRAM_E"
    12408 "RBA_SYC_RESET_T15"
    12409 "RBA_SYC_SHUTDOWNSERVICES_RSTID_T15"
    12410 "RESET_SWRESET_CPLCHK_FAILED"
    12411 "RESET_SWRESET_ESC_SCHED_RESET_E"
    12412 "RESET_SWRESET_ILLEGAL_SW_PATH"
    12413 "RESET_SWRESET_MOCCOM_BUS_ERROR"
    12414 "RESET_SWRESET_MOCCOM_CPLCHK_FAILED"
    12415 "RESET_SWRESET_MOCCOM_OS_TIMEOUT_ERROR"
    12416 "RESET_SWRESET_MOCGTM_CHKROM_FAILED"
    12417 "RESET_SWRESET_MOCGTM_FAILED"
    12418 "RESET_SWRESET_MOCGTM_INI_COMPLEMENT_FAILED"
    12419 "RESET_SWRESET_MOCGTM_INI_FAILED"
    12420 "RESET_SWRESET_MOCMEM_CHKRAM_FAILED"
    12421 "RESET_SWRESET_MOCMEM_CHKROM_FAILED"
    12422 "RESET_SWRESET_MOCMEM_CPLCHK_FAILED"
    12423 "RESET_SWRESET_MOCMEM_NUMBLKERR_FAILED"
    12424 "RESET_SWRESET_MOCMEM_WTRAM_FAILED"
    12425 "RESET_SWRESET_MOCMEM_WTROM_FAILED"
    12426 "RESET_SWRESET_OCWDA_ABE_ACTV"
    12427 "RESET_SWRESET_OCWDA_ERRPIN_ACTV"
    12428 "RESET_SWRESET_OCWDA_WDA_MONITOR"
    12429 "RESET_SWRESET_TAA_ILLEG_SWPATH"
    12430 "SWRESET_MOFVARPOSTBLDSEL_PREICO"
    12431 "SWRESET_POWERON_KL15_E"
    12432 "SWRESET_UNEXPSYCSTSUB_E"
    12433 "SWRST_ASDDCPARSEL_E"
    12434 "SWRST_ASDRFPARSEL_E"
    12435 "SWRST_ASDRFSTATEMACHINE_E"
    12436 "SWRST_HLSDEMPARSELPREDEFTRQ_E"
    12437 "SWRST_HLSDEMPARSELREVGEAR_E"
    12438 "SWRST_HLSDEMPARSEL_E"
    12439 "SWRST_IVADJQNT_E"
    12440 "SWRST_MEUNSETCRNT_E"
    12441 "SWRST_PCVSETCRNT_E"
    12442 "SWRST_RAILCTLLOOP_E"
    12443 "SWRST_RAILCTLTYPESWT_E"
    12444 "SWRST_RAILMON_E"
    12445 "SWRST_RAILPOFSTST_E"
    16384 "RBA_SYC_POWERUNDERVOLTAGE_RSTID_UV_DETECTED"
    16385 "RBA_SYC_RESET_RESTART"
    16386 "RBA_SYC_RESET_WAKEUP"
    16387 "RBA_SYC_SHUTDOWNSERVICES_RSTID_WAKEUP"
    20480 "RBA_RESET_CPU0_TRAP_MMU_VAF_E"
    20481 "RBA_RESET_CPU0_TRAP_MMU_VAP_E"
    20482 "RBA_RESET_CPU0_TRAP_TCN0_UNKNOWN_E"
    20483 "RBA_RESET_CPU0_TRAP_TCN1_TIN0_E"
    20484 "RBA_RESET_CPU0_TRAP_INTPROT_PRIV_E"
    20485 "RBA_RESET_CPU0_TRAP_INTPROT_MPR_E"
    20486 "RBA_RESET_CPU0_TRAP_INTPROT_MPW_E"
    20487 "RBA_RESET_CPU0_TRAP_INTPROT_MPX_E"
    20488 "RBA_RESET_CPU0_TRAP_INTPROT_MPP_E"
    20489 "RBA_RESET_CPU0_TRAP_INTPROT_MPN_E"
    20490 "RBA_RESET_CPU0_TRAP_INTPROT_GRWP_E"
    20491 "RBA_RESET_CPU0_TRAP_TCN1_UNKNOWN_E"
    20492 "RBA_RESET_CPU0_TRAP_TCN2_TIN0_E"
    20493 "RBA_RESET_CPU0_TRAP_INSTRERR_IOPC_E"
    20494 "RBA_RESET_CPU0_TRAP_INSTRERR_UOPC_E"
    20495 "RBA_RESET_CPU0_TRAP_INSTRERR_OPD_E"
    20496 "RBA_RESET_CPU0_TRAP_INSTRERR_ALN_E"
    20497 "RBA_RESET_CPU0_TRAP_INSTRERR_MEM_E"
    20498 "RBA_RESET_CPU0_TRAP_TCN2_UNKNOWN_E"
    20499 "RBA_RESET_CPU0_TRAP_TCN3_TIN0_E"
    20500 "RBA_RESET_CPU0_TRAP_CONTMANA_FCD_E"
    20501 "RBA_RESET_CPU0_TRAP_CONTMANA_CDO_E"
    20502 "RBA_RESET_CPU0_TRAP_CONTMANA_CDU_E"
    20503 "RBA_RESET_CPU0_TRAP_CONTMANA_FCU_E"
    20504 "RBA_RESET_CPU0_TRAP_CONTMANA_CSU_E"
    20505 "RBA_RESET_CPU0_TRAP_CONTMANA_CTYP_E"
    20506 "RBA_RESET_CPU0_TRAP_CONTMANA_NEST_E"
    20507 "RBA_RESET_CPU0_TRAP_TCN3_UNKNOWN_E"
    20508 "RBA_RESET_CPU0_TRAP_TCN4_TIN0_E"
    20509 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PSE_E"
    20510 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DSE_E"
    20511 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DAE_E"
    20512 "RBA_RESET_CPU0_TRAP_SYSBUSERR_CAE_E"
    20513 "RBA_RESET_CPU0_TRAP_FPU_INEXACT_E"
    20514 "RBA_RESET_CPU0_TRAP_FPU_UNRFLW_E"
    20515 "RBA_RESET_CPU0_TRAP_FPU_DIVZRO_E"
    20516 "RBA_RESET_CPU0_TRAP_FPU_OVRFLW_E"
    20517 "RBA_RESET_CPU0_TRAP_FPU_INVOPR_E"
    20518 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_UNKNOWN_E"
    20519 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IED_DMA_PARTITION_0_E"
    20520 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_T_DMA_PARTITION_0_E"
    20521 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_C_DMA_PARTITION_0_E"
    20522 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_S_DMA_PARTITION_0_E"
    20523 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BI_DMA_PARTITION_0_E"
    20524 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_UNC_DMA_PARTITION_0_E"
    20525 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_SP_DMA_PARTITION_0_E"
    20526 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BS_DMA_PARTITION_0_E"
    20527 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_ADDR_DMA_PARTITION_0_E"
    20528 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_LPB_DMA_PARTITION_0_E"
    20529 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_MTMV_DMA_PARTITION_0_E"
    20530 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IED_CPU0_DMI_NONESAFE_E"
    20531 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_T_CPU0_DMI_NONESAFE_E"
    20532 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_C_CPU0_DMI_NONESAFE_E"
    20533 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_S_CPU0_DMI_NONESAFE_E"
    20534 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BI_CPU0_DMI_NONESAFE_E"
    20535 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_UNC_CPU0_DMI_NONESAFE_E"
    20536 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_SP_CPU0_DMI_NONESAFE_E"
    20537 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BS_CPU0_DMI_NONESAFE_E"
    20538 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU0_DMI_NONESAFE_E"
    20539 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_LPB_CPU0_DMI_NONESAFE_E"
    20540 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU0_DMI_NONESAFE_E"
    20541 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IED_CPU0_DMI_SAFE_E"
    20542 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_T_CPU0_DMI_SAFE_E"
    20543 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_C_CPU0_DMI_SAFE_E"
    20544 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_S_CPU0_DMI_SAFE_E"
    20545 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BI_CPU0_DMI_SAFE_E"
    20546 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_UNC_CPU0_DMI_SAFE_E"
    20547 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_SP_CPU0_DMI_SAFE_E"
    20548 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BS_CPU0_DMI_SAFE_E"
    20549 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU0_DMI_SAFE_E"
    20550 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_LPB_CPU0_DMI_SAFE_E"
    20551 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU0_DMI_SAFE_E"
    20552 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IED_HSMCMI_HSMRMI_E"
    20553 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_T_HSMCMI_HSMRMI_E"
    20554 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_C_HSMCMI_HSMRMI_E"
    20555 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_S_HSMCMI_HSMRMI_E"
    20556 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BI_HSMCMI_HSMRMI_E"
    20557 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_UNC_HSMCMI_HSMRMI_E"
    20558 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_SP_HSMCMI_HSMRMI_E"
    20559 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BS_HSMCMI_HSMRMI_E"
    20560 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_ADDR_HSMCMI_HSMRMI_E"
    20561 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_LPB_HSMCMI_HSMRMI_E"
    20562 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_MTMV_HSMCMI_HSMRMI_E"
    20563 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IED_DMA_PARTITION_1_E"
    20564 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_T_DMA_PARTITION_1_E"
    20565 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_C_DMA_PARTITION_1_E"
    20566 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_S_DMA_PARTITION_1_E"
    20567 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BI_DMA_PARTITION_1_E"
    20568 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_UNC_DMA_PARTITION_1_E"
    20569 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_SP_DMA_PARTITION_1_E"
    20570 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BS_DMA_PARTITION_1_E"
    20571 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_ADDR_DMA_PARTITION_1_E"
    20572 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_LPB_DMA_PARTITION_1_E"
    20573 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_MTMV_DMA_PARTITION_1_E"
    20574 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IED_CPU1_DMI_NONESAFE_E"
    20575 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_T_CPU1_DMI_NONESAFE_E"
    20576 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_C_CPU1_DMI_NONESAFE_E"
    20577 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_S_CPU1_DMI_NONESAFE_E"
    20578 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BI_CPU1_DMI_NONESAFE_E"
    20579 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_UNC_CPU1_DMI_NONESAFE_E"
    20580 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_SP_CPU1_DMI_NONESAFE_E"
    20581 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BS_CPU1_DMI_NONESAFE_E"
    20582 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU1_DMI_NONESAFE_E"
    20583 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_LPB_CPU1_DMI_NONESAFE_E"
    20584 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU1_DMI_NONESAFE_E"
    20585 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IED_CPU1_DMI_SAFE_E"
    20586 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_T_CPU1_DMI_SAFE_E"
    20587 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_C_CPU1_DMI_SAFE_E"
    20588 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_S_CPU1_DMI_SAFE_E"
    20589 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BI_CPU1_DMI_SAFE_E"
    20590 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_UNC_CPU1_DMI_SAFE_E"
    20591 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_SP_CPU1_DMI_SAFE_E"
    20592 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BS_CPU1_DMI_SAFE_E"
    20593 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU1_DMI_SAFE_E"
    20594 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_LPB_CPU1_DMI_SAFE_E"
    20595 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU1_DMI_SAFE_E"
    20596 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IED_SDMMC_E"
    20597 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_T_SDMMC_E"
    20598 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_C_SDMMC_E"
    20599 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_S_SDMMC_E"
    20600 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BI_SDMMC_E"
    20601 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_UNC_SDMMC_E"
    20602 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_SP_SDMMC_E"
    20603 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BS_SDMMC_E"
    20604 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_ADDR_SDMMC_E"
    20605 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_LPB_SDMMC_E"
    20606 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_MTMV_SDMMC_E"
    20607 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IED_DMA_PARTITION_2_E"
    20608 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_T_DMA_PARTITION_2_E"
    20609 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_C_DMA_PARTITION_2_E"
    20610 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_S_DMA_PARTITION_2_E"
    20611 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BI_DMA_PARTITION_2_E"
    20612 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_UNC_DMA_PARTITION_2_E"
    20613 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_SP_DMA_PARTITION_2_E"
    20614 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BS_DMA_PARTITION_2_E"
    20615 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_ADDR_DMA_PARTITION_2_E"
    20616 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_LPB_DMA_PARTITION_2_E"
    20617 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_MTMV_DMA_PARTITION_2_E"
    20618 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IED_CPU2_DMI_NONESAFE_E"
    20619 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_T_CPU2_DMI_NONESAFE_E"
    20620 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_C_CPU2_DMI_NONESAFE_E"
    20621 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_S_CPU2_DMI_NONESAFE_E"
    20622 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BI_CPU2_DMI_NONESAFE_E"
    20623 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_UNC_CPU2_DMI_NONESAFE_E"
    20624 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_SP_CPU2_DMI_NONESAFE_E"
    20625 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BS_CPU2_DMI_NONESAFE_E"
    20626 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU2_DMI_NONESAFE_E"
    20627 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_LPB_CPU2_DMI_NONESAFE_E"
    20628 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU2_DMI_NONESAFE_E"
    20629 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IED_CPU2_DMI_SAFE_E"
    20630 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_T_CPU2_DMI_SAFE_E"
    20631 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_C_CPU2_DMI_SAFE_E"
    20632 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_S_CPU2_DMI_SAFE_E"
    20633 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BI_CPU2_DMI_SAFE_E"
    20634 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_UNC_CPU2_DMI_SAFE_E"
    20635 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_SP_CPU2_DMI_SAFE_E"
    20636 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BS_CPU2_DMI_SAFE_E"
    20637 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU2_DMI_SAFE_E"
    20638 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_LPB_CPU2_DMI_SAFE_E"
    20639 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU2_DMI_SAFE_E"
    20640 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IED_HSSL0_E"
    20641 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_T_HSSL0_E"
    20642 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_C_HSSL0_E"
    20643 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_S_HSSL0_E"
    20644 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BI_HSSL0_E"
    20645 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_UNC_HSSL0_E"
    20646 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_SP_HSSL0_E"
    20647 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BS_HSSL0_E"
    20648 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_ADDR_HSSL0_E"
    20649 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_LPB_HSSL0_E"
    20650 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_MTMV_HSSL0_E"
    20651 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IED_DMA_PARTITION_3_E"
    20652 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_T_DMA_PARTITION_3_E"
    20653 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_C_DMA_PARTITION_3_E"
    20654 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_S_DMA_PARTITION_3_E"
    20655 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BI_DMA_PARTITION_3_E"
    20656 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_UNC_DMA_PARTITION_3_E"
    20657 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_SP_DMA_PARTITION_3_E"
    20658 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BS_DMA_PARTITION_3_E"
    20659 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_ADDR_DMA_PARTITION_3_E"
    20660 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_LPB_DMA_PARTITION_3_E"
    20661 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_MTMV_DMA_PARTITION_3_E"
    20662 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IED_CPU3_DMI_NONESAFE_E"
    20663 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_T_CPU3_DMI_NONESAFE_E"
    20664 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_C_CPU3_DMI_NONESAFE_E"
    20665 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_S_CPU3_DMI_NONESAFE_E"
    20666 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BI_CPU3_DMI_NONESAFE_E"
    20667 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_UNC_CPU3_DMI_NONESAFE_E"
    20668 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_SP_CPU3_DMI_NONESAFE_E"
    20669 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BS_CPU3_DMI_NONESAFE_E"
    20670 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU3_DMI_NONESAFE_E"
    20671 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_LPB_CPU3_DMI_NONESAFE_E"
    20672 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU3_DMI_NONESAFE_E"
    20673 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IED_CPU3_DMI_SAFE_E"
    20674 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_T_CPU3_DMI_SAFE_E"
    20675 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_C_CPU3_DMI_SAFE_E"
    20676 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_S_CPU3_DMI_SAFE_E"
    20677 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BI_CPU3_DMI_SAFE_E"
    20678 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_UNC_CPU3_DMI_SAFE_E"
    20679 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_SP_CPU3_DMI_SAFE_E"
    20680 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BS_CPU3_DMI_SAFE_E"
    20681 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU3_DMI_SAFE_E"
    20682 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_LPB_CPU3_DMI_SAFE_E"
    20683 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU3_DMI_SAFE_E"
    20684 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IED_HSSL1_E"
    20685 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_T_HSSL1_E"
    20686 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_C_HSSL1_E"
    20687 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_S_HSSL1_E"
    20688 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BI_HSSL1_E"
    20689 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_UNC_HSSL1_E"
    20690 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_SP_HSSL1_E"
    20691 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BS_HSSL1_E"
    20692 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_ADDR_HSSL1_E"
    20693 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_LPB_HSSL1_E"
    20694 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_MTMV_HSSL1_E"
    20695 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IED_CPU4_DMI_NONESAFE_E"
    20696 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_T_CPU4_DMI_NONESAFE_E"
    20697 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_C_CPU4_DMI_NONESAFE_E"
    20698 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_S_CPU4_DMI_NONESAFE_E"
    20699 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BI_CPU4_DMI_NONESAFE_E"
    20700 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_UNC_CPU4_DMI_NONESAFE_E"
    20701 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_SP_CPU4_DMI_NONESAFE_E"
    20702 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BS_CPU4_DMI_NONESAFE_E"
    20703 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU4_DMI_NONESAFE_E"
    20704 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_LPB_CPU4_DMI_NONESAFE_E"
    20705 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU4_DMI_NONESAFE_E"
    20706 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IED_CPU4_DMI_SAFE_E"
    20707 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_T_CPU4_DMI_SAFE_E"
    20708 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_C_CPU4_DMI_SAFE_E"
    20709 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_S_CPU4_DMI_SAFE_E"
    20710 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BI_CPU4_DMI_SAFE_E"
    20711 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_UNC_CPU4_DMI_SAFE_E"
    20712 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_SP_CPU4_DMI_SAFE_E"
    20713 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BS_CPU4_DMI_SAFE_E"
    20714 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU4_DMI_SAFE_E"
    20715 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_LPB_CPU4_DMI_SAFE_E"
    20716 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU4_DMI_SAFE_E"
    20717 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IED_CIF1_E"
    20718 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_T_CIF1_E"
    20719 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_C_CIF1_E"
    20720 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_S_CIF1_E"
    20721 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BI_CIF1_E"
    20722 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_UNC_CIF1_E"
    20723 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_SP_CIF1_E"
    20724 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BS_CIF1_E"
    20725 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_ADDR_CIF1_E"
    20726 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_LPB_CIF1_E"
    20727 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_MTMV_CIF1_E"
    20728 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IED_CPU5_DMI_NONESAFE_E"
    20729 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_T_CPU5_DMI_NONESAFE_E"
    20730 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_C_CPU5_DMI_NONESAFE_E"
    20731 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_S_CPU5_DMI_NONESAFE_E"
    20732 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BI_CPU5_DMI_NONESAFE_E"
    20733 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_UNC_CPU5_DMI_NONESAFE_E"
    20734 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_SP_CPU5_DMI_NONESAFE_E"
    20735 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BS_CPU5_DMI_NONESAFE_E"
    20736 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU5_DMI_NONESAFE_E"
    20737 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_LPB_CPU5_DMI_NONESAFE_E"
    20738 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU5_DMI_NONESAFE_E"
    20739 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IED_CPU5_DMI_SAFE_E"
    20740 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_T_CPU5_DMI_SAFE_E"
    20741 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_C_CPU5_DMI_SAFE_E"
    20742 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_S_CPU5_DMI_SAFE_E"
    20743 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BI_CPU5_DMI_SAFE_E"
    20744 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_UNC_CPU5_DMI_SAFE_E"
    20745 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_SP_CPU5_DMI_SAFE_E"
    20746 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BS_CPU5_DMI_SAFE_E"
    20747 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU5_DMI_SAFE_E"
    20748 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_LPB_CPU5_DMI_SAFE_E"
    20749 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU5_DMI_SAFE_E"
    20750 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IED_CERBERUS_IOC32P_E"
    20751 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_T_CERBERUS_IOC32P_E"
    20752 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_C_CERBERUS_IOC32P_E"
    20753 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_S_CERBERUS_IOC32P_E"
    20754 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BI_CERBERUS_IOC32P_E"
    20755 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_UNC_CERBERUS_IOC32P_E"
    20756 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_SP_CERBERUS_IOC32P_E"
    20757 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BS_CERBERUS_IOC32P_E"
    20758 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_ADDR_CERBERUS_IOC32P_E"
    20759 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_LPB_CERBERUS_IOC32P_E"
    20760 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_MTMV_CERBERUS_IOC32P_E"
    20761 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IED_IOC32E_E"
    20762 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_T_IOC32E_E"
    20763 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_C_IOC32E_E"
    20764 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_S_IOC32E_E"
    20765 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BI_IOC32E_E"
    20766 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_UNC_IOC32E_E"
    20767 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_SP_IOC32E_E"
    20768 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BS_IOC32E_E"
    20769 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_ADDR_IOC32E_E"
    20770 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_LPB_IOC32E_E"
    20771 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_MTMV_IOC32E_E"
    20772 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IED_CPU0_PMI_PMBI_E"
    20773 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_T_CPU0_PMI_PMBI_E"
    20774 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_C_CPU0_PMI_PMBI_E"
    20775 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_S_CPU0_PMI_PMBI_E"
    20776 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BI_CPU0_PMI_PMBI_E"
    20777 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_UNC_CPU0_PMI_PMBI_E"
    20778 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_SP_CPU0_PMI_PMBI_E"
    20779 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BS_CPU0_PMI_PMBI_E"
    20780 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU0_PMI_PMBI_E"
    20781 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_LPB_CPU0_PMI_PMBI_E"
    20782 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU0_PMI_PMBI_E"
    20783 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IED_CPU1_PMI_PMBI_E"
    20784 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_T_CPU1_PMI_PMBI_E"
    20785 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_C_CPU1_PMI_PMBI_E"
    20786 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_S_CPU1_PMI_PMBI_E"
    20787 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BI_CPU1_PMI_PMBI_E"
    20788 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_UNC_CPU1_PMI_PMBI_E"
    20789 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_SP_CPU1_PMI_PMBI_E"
    20790 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BS_CPU1_PMI_PMBI_E"
    20791 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU1_PMI_PMBI_E"
    20792 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_LPB_CPU1_PMI_PMBI_E"
    20793 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU1_PMI_PMBI_E"
    20794 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IED_CPU2_PMI_PMBI_E"
    20795 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_T_CPU2_PMI_PMBI_E"
    20796 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_C_CPU2_PMI_PMBI_E"
    20797 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_S_CPU2_PMI_PMBI_E"
    20798 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BI_CPU2_PMI_PMBI_E"
    20799 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_UNC_CPU2_PMI_PMBI_E"
    20800 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_SP_CPU2_PMI_PMBI_E"
    20801 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BS_CPU2_PMI_PMBI_E"
    20802 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU2_PMI_PMBI_E"
    20803 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_LPB_CPU2_PMI_PMBI_E"
    20804 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU2_PMI_PMBI_E"
    20805 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IED_CPU3_PMI_PMBI_E"
    20806 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_T_CPU3_PMI_PMBI_E"
    20807 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_C_CPU3_PMI_PMBI_E"
    20808 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_S_CPU3_PMI_PMBI_E"
    20809 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BI_CPU3_PMI_PMBI_E"
    20810 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_UNC_CPU3_PMI_PMBI_E"
    20811 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_SP_CPU3_PMI_PMBI_E"
    20812 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BS_CPU3_PMI_PMBI_E"
    20813 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU3_PMI_PMBI_E"
    20814 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_LPB_CPU3_PMI_PMBI_E"
    20815 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU3_PMI_PMBI_E"
    20816 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IED_CPU4_PMI_PMBI_E"
    20817 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_T_CPU4_PMI_PMBI_E"
    20818 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_C_CPU4_PMI_PMBI_E"
    20819 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_S_CPU4_PMI_PMBI_E"
    20820 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BI_CPU4_PMI_PMBI_E"
    20821 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_UNC_CPU4_PMI_PMBI_E"
    20822 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_SP_CPU4_PMI_PMBI_E"
    20823 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BS_CPU4_PMI_PMBI_E"
    20824 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU4_PMI_PMBI_E"
    20825 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_LPB_CPU4_PMI_PMBI_E"
    20826 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU4_PMI_PMBI_E"
    20827 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IED_CPU5_PMI_PMBI_E"
    20828 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_T_CPU5_PMI_PMBI_E"
    20829 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_C_CPU5_PMI_PMBI_E"
    20830 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_S_CPU5_PMI_PMBI_E"
    20831 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BI_CPU5_PMI_PMBI_E"
    20832 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_UNC_CPU5_PMI_PMBI_E"
    20833 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_SP_CPU5_PMI_PMBI_E"
    20834 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BS_CPU5_PMI_PMBI_E"
    20835 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU5_PMI_PMBI_E"
    20836 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_LPB_CPU5_PMI_PMBI_E"
    20837 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU5_PMI_PMBI_E"
    20838 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IED_GETH_DMA0_E"
    20839 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_T_GETH_DMA0_E"
    20840 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_C_GETH_DMA0_E"
    20841 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_S_GETH_DMA0_E"
    20842 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BI_GETH_DMA0_E"
    20843 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_UNC_GETH_DMA0_E"
    20844 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_SP_GETH_DMA0_E"
    20845 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BS_GETH_DMA0_E"
    20846 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_ADDR_GETH_DMA0_E"
    20847 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_LPB_GETH_DMA0_E"
    20848 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_MTMV_GETH_DMA0_E"
    20849 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IED_GETH_DMA1_E"
    20850 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_T_GETH_DMA1_E"
    20851 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_C_GETH_DMA1_E"
    20852 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_S_GETH_DMA1_E"
    20853 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BI_GETH_DMA1_E"
    20854 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_UNC_GETH_DMA1_E"
    20855 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_SP_GETH_DMA1_E"
    20856 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BS_GETH_DMA1_E"
    20857 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_ADDR_GETH_DMA1_E"
    20858 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_LPB_GETH_DMA1_E"
    20859 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_MTMV_GETH_DMA1_E"
    20860 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IED_GETH_DMA2_E"
    20861 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_T_GETH_DMA2_E"
    20862 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_C_GETH_DMA2_E"
    20863 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_S_GETH_DMA2_E"
    20864 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BI_GETH_DMA2_E"
    20865 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_UNC_GETH_DMA2_E"
    20866 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_SP_GETH_DMA2_E"
    20867 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BS_GETH_DMA2_E"
    20868 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_ADDR_GETH_DMA2_E"
    20869 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_LPB_GETH_DMA2_E"
    20870 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_MTMV_GETH_DMA2_E"
    20871 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IED_GETH_DMA3_E"
    20872 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_T_GETH_DMA3_E"
    20873 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_C_GETH_DMA3_E"
    20874 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_S_GETH_DMA3_E"
    20875 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BI_GETH_DMA3_E"
    20876 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_UNC_GETH_DMA3_E"
    20877 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_SP_GETH_DMA3_E"
    20878 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BS_GETH_DMA3_E"
    20879 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_ADDR_GETH_DMA3_E"
    20880 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_LPB_GETH_DMA3_E"
    20881 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_MTMV_GETH_DMA3_E"
    20882 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IED_DAM0_E"
    20883 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_T_DAM0_E"
    20884 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_C_DAM0_E"
    20885 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_S_DAM0_E"
    20886 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BI_DAM0_E"
    20887 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_UNC_DAM0_E"
    20888 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_SP_DAM0_E"
    20889 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BS_DAM0_E"
    20890 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_ADDR_DAM0_E"
    20891 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_LPB_DAM0_E"
    20892 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_MTMV_DAM0_E"
    20893 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IED_DAM1_E"
    20894 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_T_DAM1_E"
    20895 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_C_DAM1_E"
    20896 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_S_DAM1_E"
    20897 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BI_DAM1_E"
    20898 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_UNC_DAM1_E"
    20899 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_SP_DAM1_E"
    20900 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_BS_DAM1_E"
    20901 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_ADDR_DAM1_E"
    20902 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_LPB_DAM1_E"
    20903 "RBA_RESET_CPU0_TRAP_SYSBUSERR_PIE_IE_MTMV_DAM1_E"
    20904 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_UNKNOWN_E"
    20905 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IED_DMA_PARTITION_0_E"
    20906 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_T_DMA_PARTITION_0_E"
    20907 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_C_DMA_PARTITION_0_E"
    20908 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_S_DMA_PARTITION_0_E"
    20909 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BI_DMA_PARTITION_0_E"
    20910 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_UNC_DMA_PARTITION_0_E"
    20911 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_SP_DMA_PARTITION_0_E"
    20912 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BS_DMA_PARTITION_0_E"
    20913 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_ADDR_DMA_PARTITION_0_E"
    20914 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_LPB_DMA_PARTITION_0_E"
    20915 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_MTMV_DMA_PARTITION_0_E"
    20916 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IED_CPU0_DMI_NONESAFE_E"
    20917 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_T_CPU0_DMI_NONESAFE_E"
    20918 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_C_CPU0_DMI_NONESAFE_E"
    20919 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_S_CPU0_DMI_NONESAFE_E"
    20920 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BI_CPU0_DMI_NONESAFE_E"
    20921 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_UNC_CPU0_DMI_NONESAFE_E"
    20922 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_SP_CPU0_DMI_NONESAFE_E"
    20923 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BS_CPU0_DMI_NONESAFE_E"
    20924 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU0_DMI_NONESAFE_E"
    20925 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_LPB_CPU0_DMI_NONESAFE_E"
    20926 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU0_DMI_NONESAFE_E"
    20927 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IED_CPU0_DMI_SAFE_E"
    20928 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_T_CPU0_DMI_SAFE_E"
    20929 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_C_CPU0_DMI_SAFE_E"
    20930 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_S_CPU0_DMI_SAFE_E"
    20931 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BI_CPU0_DMI_SAFE_E"
    20932 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_UNC_CPU0_DMI_SAFE_E"
    20933 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_SP_CPU0_DMI_SAFE_E"
    20934 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BS_CPU0_DMI_SAFE_E"
    20935 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU0_DMI_SAFE_E"
    20936 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_LPB_CPU0_DMI_SAFE_E"
    20937 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU0_DMI_SAFE_E"
    20938 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IED_HSMCMI_HSMRMI_E"
    20939 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_T_HSMCMI_HSMRMI_E"
    20940 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_C_HSMCMI_HSMRMI_E"
    20941 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_S_HSMCMI_HSMRMI_E"
    20942 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BI_HSMCMI_HSMRMI_E"
    20943 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_UNC_HSMCMI_HSMRMI_E"
    20944 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_SP_HSMCMI_HSMRMI_E"
    20945 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BS_HSMCMI_HSMRMI_E"
    20946 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_ADDR_HSMCMI_HSMRMI_E"
    20947 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_LPB_HSMCMI_HSMRMI_E"
    20948 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_MTMV_HSMCMI_HSMRMI_E"
    20949 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IED_DMA_PARTITION_1_E"
    20950 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_T_DMA_PARTITION_1_E"
    20951 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_C_DMA_PARTITION_1_E"
    20952 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_S_DMA_PARTITION_1_E"
    20953 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BI_DMA_PARTITION_1_E"
    20954 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_UNC_DMA_PARTITION_1_E"
    20955 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_SP_DMA_PARTITION_1_E"
    20956 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BS_DMA_PARTITION_1_E"
    20957 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_ADDR_DMA_PARTITION_1_E"
    20958 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_LPB_DMA_PARTITION_1_E"
    20959 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_MTMV_DMA_PARTITION_1_E"
    20960 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IED_CPU1_DMI_NONESAFE_E"
    20961 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_T_CPU1_DMI_NONESAFE_E"
    20962 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_C_CPU1_DMI_NONESAFE_E"
    20963 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_S_CPU1_DMI_NONESAFE_E"
    20964 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BI_CPU1_DMI_NONESAFE_E"
    20965 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_UNC_CPU1_DMI_NONESAFE_E"
    20966 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_SP_CPU1_DMI_NONESAFE_E"
    20967 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BS_CPU1_DMI_NONESAFE_E"
    20968 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU1_DMI_NONESAFE_E"
    20969 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_LPB_CPU1_DMI_NONESAFE_E"
    20970 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU1_DMI_NONESAFE_E"
    20971 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IED_CPU1_DMI_SAFE_E"
    20972 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_T_CPU1_DMI_SAFE_E"
    20973 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_C_CPU1_DMI_SAFE_E"
    20974 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_S_CPU1_DMI_SAFE_E"
    20975 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BI_CPU1_DMI_SAFE_E"
    20976 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_UNC_CPU1_DMI_SAFE_E"
    20977 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_SP_CPU1_DMI_SAFE_E"
    20978 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BS_CPU1_DMI_SAFE_E"
    20979 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU1_DMI_SAFE_E"
    20980 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_LPB_CPU1_DMI_SAFE_E"
    20981 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU1_DMI_SAFE_E"
    20982 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IED_SDMMC_E"
    20983 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_T_SDMMC_E"
    20984 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_C_SDMMC_E"
    20985 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_S_SDMMC_E"
    20986 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BI_SDMMC_E"
    20987 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_UNC_SDMMC_E"
    20988 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_SP_SDMMC_E"
    20989 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BS_SDMMC_E"
    20990 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_ADDR_SDMMC_E"
    20991 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_LPB_SDMMC_E"
    20992 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_MTMV_SDMMC_E"
    20993 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IED_DMA_PARTITION_2_E"
    20994 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_T_DMA_PARTITION_2_E"
    20995 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_C_DMA_PARTITION_2_E"
    20996 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_S_DMA_PARTITION_2_E"
    20997 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BI_DMA_PARTITION_2_E"
    20998 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_UNC_DMA_PARTITION_2_E"
    20999 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_SP_DMA_PARTITION_2_E"
    21000 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BS_DMA_PARTITION_2_E"
    21001 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_ADDR_DMA_PARTITION_2_E"
    21002 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_LPB_DMA_PARTITION_2_E"
    21003 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_MTMV_DMA_PARTITION_2_E"
    21004 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IED_CPU2_DMI_NONESAFE_E"
    21005 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_T_CPU2_DMI_NONESAFE_E"
    21006 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_C_CPU2_DMI_NONESAFE_E"
    21007 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_S_CPU2_DMI_NONESAFE_E"
    21008 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BI_CPU2_DMI_NONESAFE_E"
    21009 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_UNC_CPU2_DMI_NONESAFE_E"
    21010 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_SP_CPU2_DMI_NONESAFE_E"
    21011 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BS_CPU2_DMI_NONESAFE_E"
    21012 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU2_DMI_NONESAFE_E"
    21013 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_LPB_CPU2_DMI_NONESAFE_E"
    21014 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU2_DMI_NONESAFE_E"
    21015 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IED_CPU2_DMI_SAFE_E"
    21016 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_T_CPU2_DMI_SAFE_E"
    21017 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_C_CPU2_DMI_SAFE_E"
    21018 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_S_CPU2_DMI_SAFE_E"
    21019 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BI_CPU2_DMI_SAFE_E"
    21020 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_UNC_CPU2_DMI_SAFE_E"
    21021 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_SP_CPU2_DMI_SAFE_E"
    21022 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BS_CPU2_DMI_SAFE_E"
    21023 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU2_DMI_SAFE_E"
    21024 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_LPB_CPU2_DMI_SAFE_E"
    21025 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU2_DMI_SAFE_E"
    21026 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IED_HSSL0_E"
    21027 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_T_HSSL0_E"
    21028 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_C_HSSL0_E"
    21029 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_S_HSSL0_E"
    21030 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BI_HSSL0_E"
    21031 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_UNC_HSSL0_E"
    21032 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_SP_HSSL0_E"
    21033 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BS_HSSL0_E"
    21034 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_ADDR_HSSL0_E"
    21035 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_LPB_HSSL0_E"
    21036 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_MTMV_HSSL0_E"
    21037 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IED_DMA_PARTITION_3_E"
    21038 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_T_DMA_PARTITION_3_E"
    21039 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_C_DMA_PARTITION_3_E"
    21040 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_S_DMA_PARTITION_3_E"
    21041 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BI_DMA_PARTITION_3_E"
    21042 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_UNC_DMA_PARTITION_3_E"
    21043 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_SP_DMA_PARTITION_3_E"
    21044 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BS_DMA_PARTITION_3_E"
    21045 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_ADDR_DMA_PARTITION_3_E"
    21046 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_LPB_DMA_PARTITION_3_E"
    21047 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_MTMV_DMA_PARTITION_3_E"
    21048 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IED_CPU3_DMI_NONESAFE_E"
    21049 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_T_CPU3_DMI_NONESAFE_E"
    21050 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_C_CPU3_DMI_NONESAFE_E"
    21051 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_S_CPU3_DMI_NONESAFE_E"
    21052 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BI_CPU3_DMI_NONESAFE_E"
    21053 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_UNC_CPU3_DMI_NONESAFE_E"
    21054 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_SP_CPU3_DMI_NONESAFE_E"
    21055 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BS_CPU3_DMI_NONESAFE_E"
    21056 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU3_DMI_NONESAFE_E"
    21057 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_LPB_CPU3_DMI_NONESAFE_E"
    21058 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU3_DMI_NONESAFE_E"
    21059 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IED_CPU3_DMI_SAFE_E"
    21060 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_T_CPU3_DMI_SAFE_E"
    21061 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_C_CPU3_DMI_SAFE_E"
    21062 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_S_CPU3_DMI_SAFE_E"
    21063 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BI_CPU3_DMI_SAFE_E"
    21064 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_UNC_CPU3_DMI_SAFE_E"
    21065 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_SP_CPU3_DMI_SAFE_E"
    21066 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BS_CPU3_DMI_SAFE_E"
    21067 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU3_DMI_SAFE_E"
    21068 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_LPB_CPU3_DMI_SAFE_E"
    21069 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU3_DMI_SAFE_E"
    21070 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IED_HSSL1_E"
    21071 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_T_HSSL1_E"
    21072 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_C_HSSL1_E"
    21073 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_S_HSSL1_E"
    21074 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BI_HSSL1_E"
    21075 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_UNC_HSSL1_E"
    21076 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_SP_HSSL1_E"
    21077 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BS_HSSL1_E"
    21078 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_ADDR_HSSL1_E"
    21079 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_LPB_HSSL1_E"
    21080 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_MTMV_HSSL1_E"
    21081 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IED_CPU4_DMI_NONESAFE_E"
    21082 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_T_CPU4_DMI_NONESAFE_E"
    21083 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_C_CPU4_DMI_NONESAFE_E"
    21084 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_S_CPU4_DMI_NONESAFE_E"
    21085 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BI_CPU4_DMI_NONESAFE_E"
    21086 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_UNC_CPU4_DMI_NONESAFE_E"
    21087 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_SP_CPU4_DMI_NONESAFE_E"
    21088 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BS_CPU4_DMI_NONESAFE_E"
    21089 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU4_DMI_NONESAFE_E"
    21090 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_LPB_CPU4_DMI_NONESAFE_E"
    21091 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU4_DMI_NONESAFE_E"
    21092 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IED_CPU4_DMI_SAFE_E"
    21093 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_T_CPU4_DMI_SAFE_E"
    21094 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_C_CPU4_DMI_SAFE_E"
    21095 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_S_CPU4_DMI_SAFE_E"
    21096 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BI_CPU4_DMI_SAFE_E"
    21097 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_UNC_CPU4_DMI_SAFE_E"
    21098 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_SP_CPU4_DMI_SAFE_E"
    21099 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BS_CPU4_DMI_SAFE_E"
    21100 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU4_DMI_SAFE_E"
    21101 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_LPB_CPU4_DMI_SAFE_E"
    21102 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU4_DMI_SAFE_E"
    21103 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IED_CIF1_E"
    21104 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_T_CIF1_E"
    21105 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_C_CIF1_E"
    21106 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_S_CIF1_E"
    21107 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BI_CIF1_E"
    21108 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_UNC_CIF1_E"
    21109 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_SP_CIF1_E"
    21110 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BS_CIF1_E"
    21111 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_ADDR_CIF1_E"
    21112 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_LPB_CIF1_E"
    21113 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_MTMV_CIF1_E"
    21114 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IED_CPU5_DMI_NONESAFE_E"
    21115 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_T_CPU5_DMI_NONESAFE_E"
    21116 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_C_CPU5_DMI_NONESAFE_E"
    21117 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_S_CPU5_DMI_NONESAFE_E"
    21118 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BI_CPU5_DMI_NONESAFE_E"
    21119 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_UNC_CPU5_DMI_NONESAFE_E"
    21120 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_SP_CPU5_DMI_NONESAFE_E"
    21121 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BS_CPU5_DMI_NONESAFE_E"
    21122 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU5_DMI_NONESAFE_E"
    21123 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_LPB_CPU5_DMI_NONESAFE_E"
    21124 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU5_DMI_NONESAFE_E"
    21125 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IED_CPU5_DMI_SAFE_E"
    21126 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_T_CPU5_DMI_SAFE_E"
    21127 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_C_CPU5_DMI_SAFE_E"
    21128 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_S_CPU5_DMI_SAFE_E"
    21129 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BI_CPU5_DMI_SAFE_E"
    21130 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_UNC_CPU5_DMI_SAFE_E"
    21131 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_SP_CPU5_DMI_SAFE_E"
    21132 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BS_CPU5_DMI_SAFE_E"
    21133 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU5_DMI_SAFE_E"
    21134 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_LPB_CPU5_DMI_SAFE_E"
    21135 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU5_DMI_SAFE_E"
    21136 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IED_CERBERUS_IOC32P_E"
    21137 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_T_CERBERUS_IOC32P_E"
    21138 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_C_CERBERUS_IOC32P_E"
    21139 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_S_CERBERUS_IOC32P_E"
    21140 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BI_CERBERUS_IOC32P_E"
    21141 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_UNC_CERBERUS_IOC32P_E"
    21142 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_SP_CERBERUS_IOC32P_E"
    21143 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BS_CERBERUS_IOC32P_E"
    21144 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_ADDR_CERBERUS_IOC32P_E"
    21145 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_LPB_CERBERUS_IOC32P_E"
    21146 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_MTMV_CERBERUS_IOC32P_E"
    21147 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IED_IOC32E_E"
    21148 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_T_IOC32E_E"
    21149 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_C_IOC32E_E"
    21150 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_S_IOC32E_E"
    21151 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BI_IOC32E_E"
    21152 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_UNC_IOC32E_E"
    21153 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_SP_IOC32E_E"
    21154 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BS_IOC32E_E"
    21155 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_ADDR_IOC32E_E"
    21156 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_LPB_IOC32E_E"
    21157 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_MTMV_IOC32E_E"
    21158 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IED_CPU0_PMI_PMBI_E"
    21159 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_T_CPU0_PMI_PMBI_E"
    21160 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_C_CPU0_PMI_PMBI_E"
    21161 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_S_CPU0_PMI_PMBI_E"
    21162 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BI_CPU0_PMI_PMBI_E"
    21163 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_UNC_CPU0_PMI_PMBI_E"
    21164 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_SP_CPU0_PMI_PMBI_E"
    21165 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BS_CPU0_PMI_PMBI_E"
    21166 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU0_PMI_PMBI_E"
    21167 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_LPB_CPU0_PMI_PMBI_E"
    21168 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU0_PMI_PMBI_E"
    21169 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IED_CPU1_PMI_PMBI_E"
    21170 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_T_CPU1_PMI_PMBI_E"
    21171 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_C_CPU1_PMI_PMBI_E"
    21172 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_S_CPU1_PMI_PMBI_E"
    21173 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BI_CPU1_PMI_PMBI_E"
    21174 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_UNC_CPU1_PMI_PMBI_E"
    21175 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_SP_CPU1_PMI_PMBI_E"
    21176 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BS_CPU1_PMI_PMBI_E"
    21177 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU1_PMI_PMBI_E"
    21178 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_LPB_CPU1_PMI_PMBI_E"
    21179 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU1_PMI_PMBI_E"
    21180 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IED_CPU2_PMI_PMBI_E"
    21181 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_T_CPU2_PMI_PMBI_E"
    21182 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_C_CPU2_PMI_PMBI_E"
    21183 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_S_CPU2_PMI_PMBI_E"
    21184 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BI_CPU2_PMI_PMBI_E"
    21185 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_UNC_CPU2_PMI_PMBI_E"
    21186 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_SP_CPU2_PMI_PMBI_E"
    21187 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BS_CPU2_PMI_PMBI_E"
    21188 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU2_PMI_PMBI_E"
    21189 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_LPB_CPU2_PMI_PMBI_E"
    21190 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU2_PMI_PMBI_E"
    21191 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IED_CPU3_PMI_PMBI_E"
    21192 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_T_CPU3_PMI_PMBI_E"
    21193 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_C_CPU3_PMI_PMBI_E"
    21194 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_S_CPU3_PMI_PMBI_E"
    21195 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BI_CPU3_PMI_PMBI_E"
    21196 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_UNC_CPU3_PMI_PMBI_E"
    21197 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_SP_CPU3_PMI_PMBI_E"
    21198 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BS_CPU3_PMI_PMBI_E"
    21199 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU3_PMI_PMBI_E"
    21200 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_LPB_CPU3_PMI_PMBI_E"
    21201 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU3_PMI_PMBI_E"
    21202 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IED_CPU4_PMI_PMBI_E"
    21203 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_T_CPU4_PMI_PMBI_E"
    21204 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_C_CPU4_PMI_PMBI_E"
    21205 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_S_CPU4_PMI_PMBI_E"
    21206 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BI_CPU4_PMI_PMBI_E"
    21207 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_UNC_CPU4_PMI_PMBI_E"
    21208 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_SP_CPU4_PMI_PMBI_E"
    21209 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BS_CPU4_PMI_PMBI_E"
    21210 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU4_PMI_PMBI_E"
    21211 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_LPB_CPU4_PMI_PMBI_E"
    21212 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU4_PMI_PMBI_E"
    21213 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IED_CPU5_PMI_PMBI_E"
    21214 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_T_CPU5_PMI_PMBI_E"
    21215 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_C_CPU5_PMI_PMBI_E"
    21216 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_S_CPU5_PMI_PMBI_E"
    21217 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BI_CPU5_PMI_PMBI_E"
    21218 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_UNC_CPU5_PMI_PMBI_E"
    21219 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_SP_CPU5_PMI_PMBI_E"
    21220 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BS_CPU5_PMI_PMBI_E"
    21221 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU5_PMI_PMBI_E"
    21222 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_LPB_CPU5_PMI_PMBI_E"
    21223 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU5_PMI_PMBI_E"
    21224 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IED_GETH_DMA0_E"
    21225 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_T_GETH_DMA0_E"
    21226 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_C_GETH_DMA0_E"
    21227 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_S_GETH_DMA0_E"
    21228 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BI_GETH_DMA0_E"
    21229 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_UNC_GETH_DMA0_E"
    21230 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_SP_GETH_DMA0_E"
    21231 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BS_GETH_DMA0_E"
    21232 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_ADDR_GETH_DMA0_E"
    21233 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_LPB_GETH_DMA0_E"
    21234 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_MTMV_GETH_DMA0_E"
    21235 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IED_GETH_DMA1_E"
    21236 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_T_GETH_DMA1_E"
    21237 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_C_GETH_DMA1_E"
    21238 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_S_GETH_DMA1_E"
    21239 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BI_GETH_DMA1_E"
    21240 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_UNC_GETH_DMA1_E"
    21241 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_SP_GETH_DMA1_E"
    21242 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BS_GETH_DMA1_E"
    21243 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_ADDR_GETH_DMA1_E"
    21244 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_LPB_GETH_DMA1_E"
    21245 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_MTMV_GETH_DMA1_E"
    21246 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IED_GETH_DMA2_E"
    21247 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_T_GETH_DMA2_E"
    21248 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_C_GETH_DMA2_E"
    21249 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_S_GETH_DMA2_E"
    21250 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BI_GETH_DMA2_E"
    21251 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_UNC_GETH_DMA2_E"
    21252 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_SP_GETH_DMA2_E"
    21253 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BS_GETH_DMA2_E"
    21254 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_ADDR_GETH_DMA2_E"
    21255 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_LPB_GETH_DMA2_E"
    21256 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_MTMV_GETH_DMA2_E"
    21257 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IED_GETH_DMA3_E"
    21258 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_T_GETH_DMA3_E"
    21259 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_C_GETH_DMA3_E"
    21260 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_S_GETH_DMA3_E"
    21261 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BI_GETH_DMA3_E"
    21262 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_UNC_GETH_DMA3_E"
    21263 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_SP_GETH_DMA3_E"
    21264 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BS_GETH_DMA3_E"
    21265 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_ADDR_GETH_DMA3_E"
    21266 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_LPB_GETH_DMA3_E"
    21267 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_MTMV_GETH_DMA3_E"
    21268 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IED_DAM0_E"
    21269 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_T_DAM0_E"
    21270 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_C_DAM0_E"
    21271 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_S_DAM0_E"
    21272 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BI_DAM0_E"
    21273 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_UNC_DAM0_E"
    21274 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_SP_DAM0_E"
    21275 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BS_DAM0_E"
    21276 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_ADDR_DAM0_E"
    21277 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_LPB_DAM0_E"
    21278 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_MTMV_DAM0_E"
    21279 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IED_DAM1_E"
    21280 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_T_DAM1_E"
    21281 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_C_DAM1_E"
    21282 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_S_DAM1_E"
    21283 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BI_DAM1_E"
    21284 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_UNC_DAM1_E"
    21285 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_SP_DAM1_E"
    21286 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_BS_DAM1_E"
    21287 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_ADDR_DAM1_E"
    21288 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_LPB_DAM1_E"
    21289 "RBA_RESET_CPU0_TRAP_SYSBUSERR_DIE_IE_MTMV_DAM1_E"
    21290 "RBA_RESET_CPU0_TRAP_TCN4_UNKNOWN_E"
    21291 "RBA_RESET_CPU0_TRAP_TCN5_TIN0_E"
    21292 "RBA_RESET_CPU0_TRAP_ASSTRAP_OVF_E"
    21293 "RBA_RESET_CPU0_TRAP_ASSTRAP_SOVF_E"
    21294 "RBA_RESET_CPU0_TRAP_TCN5_UNKNOWN_E"
    21295 "RBA_RESET_CPU0_TRAP_SYSCALL_SYS_E"
    21296 "RBA_RESET_CPU0_TRAP_NMI_UNKNOWN_E"
    21297 "RBA_RESET_CPU0_TRAP_NMI_ESR0_E"
    21298 "RBA_RESET_CPU0_TRAP_NMI_ESR1_E"
    21299 "RBA_RESET_CPU0_TRAP_NMI_SMUT_E"
    21300 "RBA_RESET_CPU0_TRAP_NMI_SMU_CPU0_MPU_E"
    21301 "RBA_RESET_CPU0_TRAP_NMI_SMU_CPU1_MPU_E"
    21302 "RBA_RESET_CPU0_TRAP_NMI_SMU_CPU2_MPU_E"
    21303 "RBA_RESET_CPU0_TRAP_NMI_SMU_IR_E"
    21304 "RBA_RESET_CPU0_TRAP_NMI_SMU_CGU_WDT_E"
    21305 "RBA_RESET_CPU0_TRAP_NMI_SMU_CGU_PLLLOL_E"
    21306 "RBA_RESET_CPU0_TRAP_NMI_SMU_CGU_PLLERAYLOL_E"
    21307 "RBA_RESET_CPU0_TRAP_NMI_SMU_CGU_STM_E"
    21308 "RBA_RESET_CPU0_TRAP_NMI_SMU_CGU_PLLERAY_E"
    21309 "RBA_RESET_CPU0_TRAP_NMI_SMU_CGU_PLL_E"
    21310 "RBA_RESET_CPU0_TRAP_NMI_SMU_CGU_SRI_E"
    21311 "RBA_RESET_CPU0_TRAP_NMI_SMU_CGU_SPB_E"
    21312 "RBA_RESET_CPU0_TRAP_NMI_SMU_CGU_CPU0_E"
    21313 "RBA_RESET_CPU0_TRAP_NMI_SMU_SCUEVR_12UV_E"
    21314 "RBA_RESET_CPU0_TRAP_NMI_SMU_SCUEVR_12OV_E"
    21315 "RBA_RESET_CPU0_TRAP_NMI_SMU_SCUEVR_33UV_E"
    21316 "RBA_RESET_CPU0_TRAP_NMI_SMU_SCUEVR_33OV_E"
    21317 "RBA_RESET_CPU0_TRAP_NMI_SMU_SCUEVR_5UV_E"
    21318 "RBA_RESET_CPU0_TRAP_NMI_SMU_SCUEVR_5OV_E"
    21319 "RBA_RESET_CPU0_TRAP_NMI_SMU_SWDT_E"
    21320 "RBA_RESET_CPU0_TRAP_NMI_SMU_WDT0_E"
    21321 "RBA_RESET_CPU0_TRAP_NMI_SMU_WDT1_E"
    21322 "RBA_RESET_CPU0_TRAP_NMI_SMU_WDT2_E"
    21323 "RBA_RESET_CPU0_TRAP_NMI_SMU_WDT3_E"
    21324 "RBA_RESET_CPU0_TRAP_NMI_SMU_WDT4_E"
    21325 "RBA_RESET_CPU0_TRAP_NMI_SMU_WDT5_E"
    21326 "RBA_RESET_CPU0_TRAP_TCN7_UNKNOWN_E"
    24576 "RBA_RESET_CPU1_TRAP_MMU_VAF_E"
    24577 "RBA_RESET_CPU1_TRAP_MMU_VAP_E"
    24578 "RBA_RESET_CPU1_TRAP_TCN0_UNKNOWN_E"
    24579 "RBA_RESET_CPU1_TRAP_TCN1_TIN0_E"
    24580 "RBA_RESET_CPU1_TRAP_INTPROT_PRIV_E"
    24581 "RBA_RESET_CPU1_TRAP_INTPROT_MPR_E"
    24582 "RBA_RESET_CPU1_TRAP_INTPROT_MPW_E"
    24583 "RBA_RESET_CPU1_TRAP_INTPROT_MPX_E"
    24584 "RBA_RESET_CPU1_TRAP_INTPROT_MPP_E"
    24585 "RBA_RESET_CPU1_TRAP_INTPROT_MPN_E"
    24586 "RBA_RESET_CPU1_TRAP_INTPROT_GRWP_E"
    24587 "RBA_RESET_CPU1_TRAP_TCN1_UNKNOWN_E"
    24588 "RBA_RESET_CPU1_TRAP_TCN2_TIN0_E"
    24589 "RBA_RESET_CPU1_TRAP_INSTRERR_IOPC_E"
    24590 "RBA_RESET_CPU1_TRAP_INSTRERR_UOPC_E"
    24591 "RBA_RESET_CPU1_TRAP_INSTRERR_OPD_E"
    24592 "RBA_RESET_CPU1_TRAP_INSTRERR_ALN_E"
    24593 "RBA_RESET_CPU1_TRAP_INSTRERR_MEM_E"
    24594 "RBA_RESET_CPU1_TRAP_TCN2_UNKNOWN_E"
    24595 "RBA_RESET_CPU1_TRAP_TCN3_TIN0_E"
    24596 "RBA_RESET_CPU1_TRAP_CONTMANA_FCD_E"
    24597 "RBA_RESET_CPU1_TRAP_CONTMANA_CDO_E"
    24598 "RBA_RESET_CPU1_TRAP_CONTMANA_CDU_E"
    24599 "RBA_RESET_CPU1_TRAP_CONTMANA_FCU_E"
    24600 "RBA_RESET_CPU1_TRAP_CONTMANA_CSU_E"
    24601 "RBA_RESET_CPU1_TRAP_CONTMANA_CTYP_E"
    24602 "RBA_RESET_CPU1_TRAP_CONTMANA_NEST_E"
    24603 "RBA_RESET_CPU1_TRAP_TCN3_UNKNOWN_E"
    24604 "RBA_RESET_CPU1_TRAP_TCN4_TIN0_E"
    24605 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PSE_E"
    24606 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DSE_E"
    24607 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DAE_E"
    24608 "RBA_RESET_CPU1_TRAP_SYSBUSERR_CAE_E"
    24609 "RBA_RESET_CPU1_TRAP_FPU_INEXACT_E"
    24610 "RBA_RESET_CPU1_TRAP_FPU_UNRFLW_E"
    24611 "RBA_RESET_CPU1_TRAP_FPU_DIVZRO_E"
    24612 "RBA_RESET_CPU1_TRAP_FPU_OVRFLW_E"
    24613 "RBA_RESET_CPU1_TRAP_FPU_INVOPR_E"
    24614 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_UNKNOWN_E"
    24615 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IED_DMA_PARTITION_0_E"
    24616 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_T_DMA_PARTITION_0_E"
    24617 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_C_DMA_PARTITION_0_E"
    24618 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_S_DMA_PARTITION_0_E"
    24619 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BI_DMA_PARTITION_0_E"
    24620 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_UNC_DMA_PARTITION_0_E"
    24621 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_SP_DMA_PARTITION_0_E"
    24622 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BS_DMA_PARTITION_0_E"
    24623 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_ADDR_DMA_PARTITION_0_E"
    24624 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_LPB_DMA_PARTITION_0_E"
    24625 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_MTMV_DMA_PARTITION_0_E"
    24626 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IED_CPU0_DMI_NONESAFE_E"
    24627 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_T_CPU0_DMI_NONESAFE_E"
    24628 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_C_CPU0_DMI_NONESAFE_E"
    24629 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_S_CPU0_DMI_NONESAFE_E"
    24630 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BI_CPU0_DMI_NONESAFE_E"
    24631 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_UNC_CPU0_DMI_NONESAFE_E"
    24632 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_SP_CPU0_DMI_NONESAFE_E"
    24633 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BS_CPU0_DMI_NONESAFE_E"
    24634 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU0_DMI_NONESAFE_E"
    24635 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_LPB_CPU0_DMI_NONESAFE_E"
    24636 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU0_DMI_NONESAFE_E"
    24637 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IED_CPU0_DMI_SAFE_E"
    24638 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_T_CPU0_DMI_SAFE_E"
    24639 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_C_CPU0_DMI_SAFE_E"
    24640 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_S_CPU0_DMI_SAFE_E"
    24641 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BI_CPU0_DMI_SAFE_E"
    24642 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_UNC_CPU0_DMI_SAFE_E"
    24643 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_SP_CPU0_DMI_SAFE_E"
    24644 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BS_CPU0_DMI_SAFE_E"
    24645 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU0_DMI_SAFE_E"
    24646 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_LPB_CPU0_DMI_SAFE_E"
    24647 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU0_DMI_SAFE_E"
    24648 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IED_HSMCMI_HSMRMI_E"
    24649 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_T_HSMCMI_HSMRMI_E"
    24650 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_C_HSMCMI_HSMRMI_E"
    24651 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_S_HSMCMI_HSMRMI_E"
    24652 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BI_HSMCMI_HSMRMI_E"
    24653 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_UNC_HSMCMI_HSMRMI_E"
    24654 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_SP_HSMCMI_HSMRMI_E"
    24655 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BS_HSMCMI_HSMRMI_E"
    24656 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_ADDR_HSMCMI_HSMRMI_E"
    24657 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_LPB_HSMCMI_HSMRMI_E"
    24658 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_MTMV_HSMCMI_HSMRMI_E"
    24659 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IED_DMA_PARTITION_1_E"
    24660 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_T_DMA_PARTITION_1_E"
    24661 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_C_DMA_PARTITION_1_E"
    24662 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_S_DMA_PARTITION_1_E"
    24663 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BI_DMA_PARTITION_1_E"
    24664 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_UNC_DMA_PARTITION_1_E"
    24665 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_SP_DMA_PARTITION_1_E"
    24666 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BS_DMA_PARTITION_1_E"
    24667 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_ADDR_DMA_PARTITION_1_E"
    24668 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_LPB_DMA_PARTITION_1_E"
    24669 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_MTMV_DMA_PARTITION_1_E"
    24670 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IED_CPU1_DMI_NONESAFE_E"
    24671 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_T_CPU1_DMI_NONESAFE_E"
    24672 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_C_CPU1_DMI_NONESAFE_E"
    24673 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_S_CPU1_DMI_NONESAFE_E"
    24674 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BI_CPU1_DMI_NONESAFE_E"
    24675 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_UNC_CPU1_DMI_NONESAFE_E"
    24676 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_SP_CPU1_DMI_NONESAFE_E"
    24677 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BS_CPU1_DMI_NONESAFE_E"
    24678 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU1_DMI_NONESAFE_E"
    24679 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_LPB_CPU1_DMI_NONESAFE_E"
    24680 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU1_DMI_NONESAFE_E"
    24681 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IED_CPU1_DMI_SAFE_E"
    24682 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_T_CPU1_DMI_SAFE_E"
    24683 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_C_CPU1_DMI_SAFE_E"
    24684 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_S_CPU1_DMI_SAFE_E"
    24685 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BI_CPU1_DMI_SAFE_E"
    24686 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_UNC_CPU1_DMI_SAFE_E"
    24687 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_SP_CPU1_DMI_SAFE_E"
    24688 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BS_CPU1_DMI_SAFE_E"
    24689 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU1_DMI_SAFE_E"
    24690 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_LPB_CPU1_DMI_SAFE_E"
    24691 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU1_DMI_SAFE_E"
    24692 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IED_SDMMC_E"
    24693 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_T_SDMMC_E"
    24694 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_C_SDMMC_E"
    24695 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_S_SDMMC_E"
    24696 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BI_SDMMC_E"
    24697 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_UNC_SDMMC_E"
    24698 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_SP_SDMMC_E"
    24699 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BS_SDMMC_E"
    24700 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_ADDR_SDMMC_E"
    24701 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_LPB_SDMMC_E"
    24702 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_MTMV_SDMMC_E"
    24703 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IED_DMA_PARTITION_2_E"
    24704 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_T_DMA_PARTITION_2_E"
    24705 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_C_DMA_PARTITION_2_E"
    24706 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_S_DMA_PARTITION_2_E"
    24707 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BI_DMA_PARTITION_2_E"
    24708 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_UNC_DMA_PARTITION_2_E"
    24709 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_SP_DMA_PARTITION_2_E"
    24710 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BS_DMA_PARTITION_2_E"
    24711 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_ADDR_DMA_PARTITION_2_E"
    24712 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_LPB_DMA_PARTITION_2_E"
    24713 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_MTMV_DMA_PARTITION_2_E"
    24714 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IED_CPU2_DMI_NONESAFE_E"
    24715 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_T_CPU2_DMI_NONESAFE_E"
    24716 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_C_CPU2_DMI_NONESAFE_E"
    24717 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_S_CPU2_DMI_NONESAFE_E"
    24718 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BI_CPU2_DMI_NONESAFE_E"
    24719 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_UNC_CPU2_DMI_NONESAFE_E"
    24720 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_SP_CPU2_DMI_NONESAFE_E"
    24721 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BS_CPU2_DMI_NONESAFE_E"
    24722 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU2_DMI_NONESAFE_E"
    24723 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_LPB_CPU2_DMI_NONESAFE_E"
    24724 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU2_DMI_NONESAFE_E"
    24725 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IED_CPU2_DMI_SAFE_E"
    24726 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_T_CPU2_DMI_SAFE_E"
    24727 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_C_CPU2_DMI_SAFE_E"
    24728 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_S_CPU2_DMI_SAFE_E"
    24729 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BI_CPU2_DMI_SAFE_E"
    24730 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_UNC_CPU2_DMI_SAFE_E"
    24731 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_SP_CPU2_DMI_SAFE_E"
    24732 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BS_CPU2_DMI_SAFE_E"
    24733 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU2_DMI_SAFE_E"
    24734 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_LPB_CPU2_DMI_SAFE_E"
    24735 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU2_DMI_SAFE_E"
    24736 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IED_HSSL0_E"
    24737 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_T_HSSL0_E"
    24738 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_C_HSSL0_E"
    24739 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_S_HSSL0_E"
    24740 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BI_HSSL0_E"
    24741 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_UNC_HSSL0_E"
    24742 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_SP_HSSL0_E"
    24743 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BS_HSSL0_E"
    24744 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_ADDR_HSSL0_E"
    24745 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_LPB_HSSL0_E"
    24746 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_MTMV_HSSL0_E"
    24747 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IED_DMA_PARTITION_3_E"
    24748 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_T_DMA_PARTITION_3_E"
    24749 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_C_DMA_PARTITION_3_E"
    24750 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_S_DMA_PARTITION_3_E"
    24751 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BI_DMA_PARTITION_3_E"
    24752 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_UNC_DMA_PARTITION_3_E"
    24753 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_SP_DMA_PARTITION_3_E"
    24754 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BS_DMA_PARTITION_3_E"
    24755 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_ADDR_DMA_PARTITION_3_E"
    24756 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_LPB_DMA_PARTITION_3_E"
    24757 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_MTMV_DMA_PARTITION_3_E"
    24758 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IED_CPU3_DMI_NONESAFE_E"
    24759 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_T_CPU3_DMI_NONESAFE_E"
    24760 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_C_CPU3_DMI_NONESAFE_E"
    24761 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_S_CPU3_DMI_NONESAFE_E"
    24762 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BI_CPU3_DMI_NONESAFE_E"
    24763 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_UNC_CPU3_DMI_NONESAFE_E"
    24764 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_SP_CPU3_DMI_NONESAFE_E"
    24765 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BS_CPU3_DMI_NONESAFE_E"
    24766 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU3_DMI_NONESAFE_E"
    24767 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_LPB_CPU3_DMI_NONESAFE_E"
    24768 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU3_DMI_NONESAFE_E"
    24769 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IED_CPU3_DMI_SAFE_E"
    24770 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_T_CPU3_DMI_SAFE_E"
    24771 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_C_CPU3_DMI_SAFE_E"
    24772 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_S_CPU3_DMI_SAFE_E"
    24773 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BI_CPU3_DMI_SAFE_E"
    24774 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_UNC_CPU3_DMI_SAFE_E"
    24775 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_SP_CPU3_DMI_SAFE_E"
    24776 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BS_CPU3_DMI_SAFE_E"
    24777 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU3_DMI_SAFE_E"
    24778 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_LPB_CPU3_DMI_SAFE_E"
    24779 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU3_DMI_SAFE_E"
    24780 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IED_HSSL1_E"
    24781 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_T_HSSL1_E"
    24782 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_C_HSSL1_E"
    24783 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_S_HSSL1_E"
    24784 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BI_HSSL1_E"
    24785 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_UNC_HSSL1_E"
    24786 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_SP_HSSL1_E"
    24787 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BS_HSSL1_E"
    24788 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_ADDR_HSSL1_E"
    24789 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_LPB_HSSL1_E"
    24790 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_MTMV_HSSL1_E"
    24791 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IED_CPU4_DMI_NONESAFE_E"
    24792 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_T_CPU4_DMI_NONESAFE_E"
    24793 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_C_CPU4_DMI_NONESAFE_E"
    24794 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_S_CPU4_DMI_NONESAFE_E"
    24795 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BI_CPU4_DMI_NONESAFE_E"
    24796 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_UNC_CPU4_DMI_NONESAFE_E"
    24797 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_SP_CPU4_DMI_NONESAFE_E"
    24798 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BS_CPU4_DMI_NONESAFE_E"
    24799 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU4_DMI_NONESAFE_E"
    24800 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_LPB_CPU4_DMI_NONESAFE_E"
    24801 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU4_DMI_NONESAFE_E"
    24802 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IED_CPU4_DMI_SAFE_E"
    24803 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_T_CPU4_DMI_SAFE_E"
    24804 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_C_CPU4_DMI_SAFE_E"
    24805 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_S_CPU4_DMI_SAFE_E"
    24806 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BI_CPU4_DMI_SAFE_E"
    24807 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_UNC_CPU4_DMI_SAFE_E"
    24808 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_SP_CPU4_DMI_SAFE_E"
    24809 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BS_CPU4_DMI_SAFE_E"
    24810 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU4_DMI_SAFE_E"
    24811 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_LPB_CPU4_DMI_SAFE_E"
    24812 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU4_DMI_SAFE_E"
    24813 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IED_CIF1_E"
    24814 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_T_CIF1_E"
    24815 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_C_CIF1_E"
    24816 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_S_CIF1_E"
    24817 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BI_CIF1_E"
    24818 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_UNC_CIF1_E"
    24819 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_SP_CIF1_E"
    24820 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BS_CIF1_E"
    24821 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_ADDR_CIF1_E"
    24822 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_LPB_CIF1_E"
    24823 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_MTMV_CIF1_E"
    24824 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IED_CPU5_DMI_NONESAFE_E"
    24825 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_T_CPU5_DMI_NONESAFE_E"
    24826 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_C_CPU5_DMI_NONESAFE_E"
    24827 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_S_CPU5_DMI_NONESAFE_E"
    24828 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BI_CPU5_DMI_NONESAFE_E"
    24829 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_UNC_CPU5_DMI_NONESAFE_E"
    24830 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_SP_CPU5_DMI_NONESAFE_E"
    24831 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BS_CPU5_DMI_NONESAFE_E"
    24832 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU5_DMI_NONESAFE_E"
    24833 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_LPB_CPU5_DMI_NONESAFE_E"
    24834 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU5_DMI_NONESAFE_E"
    24835 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IED_CPU5_DMI_SAFE_E"
    24836 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_T_CPU5_DMI_SAFE_E"
    24837 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_C_CPU5_DMI_SAFE_E"
    24838 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_S_CPU5_DMI_SAFE_E"
    24839 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BI_CPU5_DMI_SAFE_E"
    24840 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_UNC_CPU5_DMI_SAFE_E"
    24841 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_SP_CPU5_DMI_SAFE_E"
    24842 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BS_CPU5_DMI_SAFE_E"
    24843 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU5_DMI_SAFE_E"
    24844 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_LPB_CPU5_DMI_SAFE_E"
    24845 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU5_DMI_SAFE_E"
    24846 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IED_CERBERUS_IOC32P_E"
    24847 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_T_CERBERUS_IOC32P_E"
    24848 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_C_CERBERUS_IOC32P_E"
    24849 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_S_CERBERUS_IOC32P_E"
    24850 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BI_CERBERUS_IOC32P_E"
    24851 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_UNC_CERBERUS_IOC32P_E"
    24852 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_SP_CERBERUS_IOC32P_E"
    24853 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BS_CERBERUS_IOC32P_E"
    24854 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_ADDR_CERBERUS_IOC32P_E"
    24855 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_LPB_CERBERUS_IOC32P_E"
    24856 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_MTMV_CERBERUS_IOC32P_E"
    24857 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IED_IOC32E_E"
    24858 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_T_IOC32E_E"
    24859 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_C_IOC32E_E"
    24860 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_S_IOC32E_E"
    24861 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BI_IOC32E_E"
    24862 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_UNC_IOC32E_E"
    24863 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_SP_IOC32E_E"
    24864 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BS_IOC32E_E"
    24865 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_ADDR_IOC32E_E"
    24866 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_LPB_IOC32E_E"
    24867 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_MTMV_IOC32E_E"
    24868 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IED_CPU0_PMI_PMBI_E"
    24869 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_T_CPU0_PMI_PMBI_E"
    24870 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_C_CPU0_PMI_PMBI_E"
    24871 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_S_CPU0_PMI_PMBI_E"
    24872 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BI_CPU0_PMI_PMBI_E"
    24873 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_UNC_CPU0_PMI_PMBI_E"
    24874 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_SP_CPU0_PMI_PMBI_E"
    24875 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BS_CPU0_PMI_PMBI_E"
    24876 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU0_PMI_PMBI_E"
    24877 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_LPB_CPU0_PMI_PMBI_E"
    24878 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU0_PMI_PMBI_E"
    24879 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IED_CPU1_PMI_PMBI_E"
    24880 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_T_CPU1_PMI_PMBI_E"
    24881 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_C_CPU1_PMI_PMBI_E"
    24882 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_S_CPU1_PMI_PMBI_E"
    24883 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BI_CPU1_PMI_PMBI_E"
    24884 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_UNC_CPU1_PMI_PMBI_E"
    24885 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_SP_CPU1_PMI_PMBI_E"
    24886 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BS_CPU1_PMI_PMBI_E"
    24887 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU1_PMI_PMBI_E"
    24888 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_LPB_CPU1_PMI_PMBI_E"
    24889 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU1_PMI_PMBI_E"
    24890 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IED_CPU2_PMI_PMBI_E"
    24891 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_T_CPU2_PMI_PMBI_E"
    24892 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_C_CPU2_PMI_PMBI_E"
    24893 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_S_CPU2_PMI_PMBI_E"
    24894 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BI_CPU2_PMI_PMBI_E"
    24895 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_UNC_CPU2_PMI_PMBI_E"
    24896 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_SP_CPU2_PMI_PMBI_E"
    24897 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BS_CPU2_PMI_PMBI_E"
    24898 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU2_PMI_PMBI_E"
    24899 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_LPB_CPU2_PMI_PMBI_E"
    24900 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU2_PMI_PMBI_E"
    24901 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IED_CPU3_PMI_PMBI_E"
    24902 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_T_CPU3_PMI_PMBI_E"
    24903 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_C_CPU3_PMI_PMBI_E"
    24904 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_S_CPU3_PMI_PMBI_E"
    24905 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BI_CPU3_PMI_PMBI_E"
    24906 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_UNC_CPU3_PMI_PMBI_E"
    24907 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_SP_CPU3_PMI_PMBI_E"
    24908 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BS_CPU3_PMI_PMBI_E"
    24909 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU3_PMI_PMBI_E"
    24910 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_LPB_CPU3_PMI_PMBI_E"
    24911 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU3_PMI_PMBI_E"
    24912 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IED_CPU4_PMI_PMBI_E"
    24913 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_T_CPU4_PMI_PMBI_E"
    24914 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_C_CPU4_PMI_PMBI_E"
    24915 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_S_CPU4_PMI_PMBI_E"
    24916 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BI_CPU4_PMI_PMBI_E"
    24917 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_UNC_CPU4_PMI_PMBI_E"
    24918 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_SP_CPU4_PMI_PMBI_E"
    24919 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BS_CPU4_PMI_PMBI_E"
    24920 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU4_PMI_PMBI_E"
    24921 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_LPB_CPU4_PMI_PMBI_E"
    24922 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU4_PMI_PMBI_E"
    24923 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IED_CPU5_PMI_PMBI_E"
    24924 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_T_CPU5_PMI_PMBI_E"
    24925 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_C_CPU5_PMI_PMBI_E"
    24926 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_S_CPU5_PMI_PMBI_E"
    24927 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BI_CPU5_PMI_PMBI_E"
    24928 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_UNC_CPU5_PMI_PMBI_E"
    24929 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_SP_CPU5_PMI_PMBI_E"
    24930 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BS_CPU5_PMI_PMBI_E"
    24931 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU5_PMI_PMBI_E"
    24932 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_LPB_CPU5_PMI_PMBI_E"
    24933 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU5_PMI_PMBI_E"
    24934 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IED_GETH_DMA0_E"
    24935 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_T_GETH_DMA0_E"
    24936 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_C_GETH_DMA0_E"
    24937 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_S_GETH_DMA0_E"
    24938 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BI_GETH_DMA0_E"
    24939 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_UNC_GETH_DMA0_E"
    24940 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_SP_GETH_DMA0_E"
    24941 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BS_GETH_DMA0_E"
    24942 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_ADDR_GETH_DMA0_E"
    24943 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_LPB_GETH_DMA0_E"
    24944 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_MTMV_GETH_DMA0_E"
    24945 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IED_GETH_DMA1_E"
    24946 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_T_GETH_DMA1_E"
    24947 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_C_GETH_DMA1_E"
    24948 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_S_GETH_DMA1_E"
    24949 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BI_GETH_DMA1_E"
    24950 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_UNC_GETH_DMA1_E"
    24951 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_SP_GETH_DMA1_E"
    24952 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BS_GETH_DMA1_E"
    24953 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_ADDR_GETH_DMA1_E"
    24954 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_LPB_GETH_DMA1_E"
    24955 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_MTMV_GETH_DMA1_E"
    24956 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IED_GETH_DMA2_E"
    24957 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_T_GETH_DMA2_E"
    24958 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_C_GETH_DMA2_E"
    24959 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_S_GETH_DMA2_E"
    24960 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BI_GETH_DMA2_E"
    24961 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_UNC_GETH_DMA2_E"
    24962 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_SP_GETH_DMA2_E"
    24963 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BS_GETH_DMA2_E"
    24964 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_ADDR_GETH_DMA2_E"
    24965 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_LPB_GETH_DMA2_E"
    24966 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_MTMV_GETH_DMA2_E"
    24967 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IED_GETH_DMA3_E"
    24968 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_T_GETH_DMA3_E"
    24969 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_C_GETH_DMA3_E"
    24970 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_S_GETH_DMA3_E"
    24971 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BI_GETH_DMA3_E"
    24972 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_UNC_GETH_DMA3_E"
    24973 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_SP_GETH_DMA3_E"
    24974 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BS_GETH_DMA3_E"
    24975 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_ADDR_GETH_DMA3_E"
    24976 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_LPB_GETH_DMA3_E"
    24977 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_MTMV_GETH_DMA3_E"
    24978 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IED_DAM0_E"
    24979 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_T_DAM0_E"
    24980 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_C_DAM0_E"
    24981 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_S_DAM0_E"
    24982 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BI_DAM0_E"
    24983 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_UNC_DAM0_E"
    24984 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_SP_DAM0_E"
    24985 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BS_DAM0_E"
    24986 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_ADDR_DAM0_E"
    24987 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_LPB_DAM0_E"
    24988 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_MTMV_DAM0_E"
    24989 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IED_DAM1_E"
    24990 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_T_DAM1_E"
    24991 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_C_DAM1_E"
    24992 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_S_DAM1_E"
    24993 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BI_DAM1_E"
    24994 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_UNC_DAM1_E"
    24995 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_SP_DAM1_E"
    24996 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_BS_DAM1_E"
    24997 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_ADDR_DAM1_E"
    24998 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_LPB_DAM1_E"
    24999 "RBA_RESET_CPU1_TRAP_SYSBUSERR_PIE_IE_MTMV_DAM1_E"
    25000 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_UNKNOWN_E"
    25001 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IED_DMA_PARTITION_0_E"
    25002 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_T_DMA_PARTITION_0_E"
    25003 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_C_DMA_PARTITION_0_E"
    25004 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_S_DMA_PARTITION_0_E"
    25005 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BI_DMA_PARTITION_0_E"
    25006 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_UNC_DMA_PARTITION_0_E"
    25007 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_SP_DMA_PARTITION_0_E"
    25008 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BS_DMA_PARTITION_0_E"
    25009 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_ADDR_DMA_PARTITION_0_E"
    25010 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_LPB_DMA_PARTITION_0_E"
    25011 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_MTMV_DMA_PARTITION_0_E"
    25012 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IED_CPU0_DMI_NONESAFE_E"
    25013 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_T_CPU0_DMI_NONESAFE_E"
    25014 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_C_CPU0_DMI_NONESAFE_E"
    25015 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_S_CPU0_DMI_NONESAFE_E"
    25016 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BI_CPU0_DMI_NONESAFE_E"
    25017 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_UNC_CPU0_DMI_NONESAFE_E"
    25018 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_SP_CPU0_DMI_NONESAFE_E"
    25019 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BS_CPU0_DMI_NONESAFE_E"
    25020 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU0_DMI_NONESAFE_E"
    25021 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_LPB_CPU0_DMI_NONESAFE_E"
    25022 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU0_DMI_NONESAFE_E"
    25023 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IED_CPU0_DMI_SAFE_E"
    25024 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_T_CPU0_DMI_SAFE_E"
    25025 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_C_CPU0_DMI_SAFE_E"
    25026 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_S_CPU0_DMI_SAFE_E"
    25027 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BI_CPU0_DMI_SAFE_E"
    25028 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_UNC_CPU0_DMI_SAFE_E"
    25029 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_SP_CPU0_DMI_SAFE_E"
    25030 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BS_CPU0_DMI_SAFE_E"
    25031 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU0_DMI_SAFE_E"
    25032 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_LPB_CPU0_DMI_SAFE_E"
    25033 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU0_DMI_SAFE_E"
    25034 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IED_HSMCMI_HSMRMI_E"
    25035 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_T_HSMCMI_HSMRMI_E"
    25036 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_C_HSMCMI_HSMRMI_E"
    25037 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_S_HSMCMI_HSMRMI_E"
    25038 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BI_HSMCMI_HSMRMI_E"
    25039 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_UNC_HSMCMI_HSMRMI_E"
    25040 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_SP_HSMCMI_HSMRMI_E"
    25041 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BS_HSMCMI_HSMRMI_E"
    25042 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_ADDR_HSMCMI_HSMRMI_E"
    25043 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_LPB_HSMCMI_HSMRMI_E"
    25044 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_MTMV_HSMCMI_HSMRMI_E"
    25045 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IED_DMA_PARTITION_1_E"
    25046 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_T_DMA_PARTITION_1_E"
    25047 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_C_DMA_PARTITION_1_E"
    25048 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_S_DMA_PARTITION_1_E"
    25049 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BI_DMA_PARTITION_1_E"
    25050 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_UNC_DMA_PARTITION_1_E"
    25051 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_SP_DMA_PARTITION_1_E"
    25052 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BS_DMA_PARTITION_1_E"
    25053 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_ADDR_DMA_PARTITION_1_E"
    25054 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_LPB_DMA_PARTITION_1_E"
    25055 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_MTMV_DMA_PARTITION_1_E"
    25056 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IED_CPU1_DMI_NONESAFE_E"
    25057 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_T_CPU1_DMI_NONESAFE_E"
    25058 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_C_CPU1_DMI_NONESAFE_E"
    25059 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_S_CPU1_DMI_NONESAFE_E"
    25060 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BI_CPU1_DMI_NONESAFE_E"
    25061 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_UNC_CPU1_DMI_NONESAFE_E"
    25062 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_SP_CPU1_DMI_NONESAFE_E"
    25063 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BS_CPU1_DMI_NONESAFE_E"
    25064 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU1_DMI_NONESAFE_E"
    25065 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_LPB_CPU1_DMI_NONESAFE_E"
    25066 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU1_DMI_NONESAFE_E"
    25067 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IED_CPU1_DMI_SAFE_E"
    25068 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_T_CPU1_DMI_SAFE_E"
    25069 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_C_CPU1_DMI_SAFE_E"
    25070 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_S_CPU1_DMI_SAFE_E"
    25071 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BI_CPU1_DMI_SAFE_E"
    25072 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_UNC_CPU1_DMI_SAFE_E"
    25073 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_SP_CPU1_DMI_SAFE_E"
    25074 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BS_CPU1_DMI_SAFE_E"
    25075 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU1_DMI_SAFE_E"
    25076 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_LPB_CPU1_DMI_SAFE_E"
    25077 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU1_DMI_SAFE_E"
    25078 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IED_SDMMC_E"
    25079 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_T_SDMMC_E"
    25080 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_C_SDMMC_E"
    25081 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_S_SDMMC_E"
    25082 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BI_SDMMC_E"
    25083 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_UNC_SDMMC_E"
    25084 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_SP_SDMMC_E"
    25085 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BS_SDMMC_E"
    25086 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_ADDR_SDMMC_E"
    25087 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_LPB_SDMMC_E"
    25088 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_MTMV_SDMMC_E"
    25089 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IED_DMA_PARTITION_2_E"
    25090 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_T_DMA_PARTITION_2_E"
    25091 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_C_DMA_PARTITION_2_E"
    25092 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_S_DMA_PARTITION_2_E"
    25093 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BI_DMA_PARTITION_2_E"
    25094 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_UNC_DMA_PARTITION_2_E"
    25095 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_SP_DMA_PARTITION_2_E"
    25096 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BS_DMA_PARTITION_2_E"
    25097 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_ADDR_DMA_PARTITION_2_E"
    25098 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_LPB_DMA_PARTITION_2_E"
    25099 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_MTMV_DMA_PARTITION_2_E"
    25100 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IED_CPU2_DMI_NONESAFE_E"
    25101 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_T_CPU2_DMI_NONESAFE_E"
    25102 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_C_CPU2_DMI_NONESAFE_E"
    25103 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_S_CPU2_DMI_NONESAFE_E"
    25104 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BI_CPU2_DMI_NONESAFE_E"
    25105 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_UNC_CPU2_DMI_NONESAFE_E"
    25106 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_SP_CPU2_DMI_NONESAFE_E"
    25107 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BS_CPU2_DMI_NONESAFE_E"
    25108 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU2_DMI_NONESAFE_E"
    25109 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_LPB_CPU2_DMI_NONESAFE_E"
    25110 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU2_DMI_NONESAFE_E"
    25111 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IED_CPU2_DMI_SAFE_E"
    25112 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_T_CPU2_DMI_SAFE_E"
    25113 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_C_CPU2_DMI_SAFE_E"
    25114 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_S_CPU2_DMI_SAFE_E"
    25115 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BI_CPU2_DMI_SAFE_E"
    25116 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_UNC_CPU2_DMI_SAFE_E"
    25117 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_SP_CPU2_DMI_SAFE_E"
    25118 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BS_CPU2_DMI_SAFE_E"
    25119 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU2_DMI_SAFE_E"
    25120 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_LPB_CPU2_DMI_SAFE_E"
    25121 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU2_DMI_SAFE_E"
    25122 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IED_HSSL0_E"
    25123 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_T_HSSL0_E"
    25124 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_C_HSSL0_E"
    25125 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_S_HSSL0_E"
    25126 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BI_HSSL0_E"
    25127 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_UNC_HSSL0_E"
    25128 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_SP_HSSL0_E"
    25129 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BS_HSSL0_E"
    25130 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_ADDR_HSSL0_E"
    25131 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_LPB_HSSL0_E"
    25132 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_MTMV_HSSL0_E"
    25133 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IED_DMA_PARTITION_3_E"
    25134 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_T_DMA_PARTITION_3_E"
    25135 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_C_DMA_PARTITION_3_E"
    25136 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_S_DMA_PARTITION_3_E"
    25137 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BI_DMA_PARTITION_3_E"
    25138 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_UNC_DMA_PARTITION_3_E"
    25139 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_SP_DMA_PARTITION_3_E"
    25140 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BS_DMA_PARTITION_3_E"
    25141 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_ADDR_DMA_PARTITION_3_E"
    25142 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_LPB_DMA_PARTITION_3_E"
    25143 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_MTMV_DMA_PARTITION_3_E"
    25144 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IED_CPU3_DMI_NONESAFE_E"
    25145 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_T_CPU3_DMI_NONESAFE_E"
    25146 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_C_CPU3_DMI_NONESAFE_E"
    25147 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_S_CPU3_DMI_NONESAFE_E"
    25148 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BI_CPU3_DMI_NONESAFE_E"
    25149 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_UNC_CPU3_DMI_NONESAFE_E"
    25150 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_SP_CPU3_DMI_NONESAFE_E"
    25151 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BS_CPU3_DMI_NONESAFE_E"
    25152 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU3_DMI_NONESAFE_E"
    25153 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_LPB_CPU3_DMI_NONESAFE_E"
    25154 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU3_DMI_NONESAFE_E"
    25155 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IED_CPU3_DMI_SAFE_E"
    25156 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_T_CPU3_DMI_SAFE_E"
    25157 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_C_CPU3_DMI_SAFE_E"
    25158 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_S_CPU3_DMI_SAFE_E"
    25159 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BI_CPU3_DMI_SAFE_E"
    25160 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_UNC_CPU3_DMI_SAFE_E"
    25161 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_SP_CPU3_DMI_SAFE_E"
    25162 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BS_CPU3_DMI_SAFE_E"
    25163 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU3_DMI_SAFE_E"
    25164 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_LPB_CPU3_DMI_SAFE_E"
    25165 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU3_DMI_SAFE_E"
    25166 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IED_HSSL1_E"
    25167 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_T_HSSL1_E"
    25168 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_C_HSSL1_E"
    25169 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_S_HSSL1_E"
    25170 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BI_HSSL1_E"
    25171 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_UNC_HSSL1_E"
    25172 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_SP_HSSL1_E"
    25173 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BS_HSSL1_E"
    25174 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_ADDR_HSSL1_E"
    25175 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_LPB_HSSL1_E"
    25176 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_MTMV_HSSL1_E"
    25177 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IED_CPU4_DMI_NONESAFE_E"
    25178 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_T_CPU4_DMI_NONESAFE_E"
    25179 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_C_CPU4_DMI_NONESAFE_E"
    25180 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_S_CPU4_DMI_NONESAFE_E"
    25181 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BI_CPU4_DMI_NONESAFE_E"
    25182 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_UNC_CPU4_DMI_NONESAFE_E"
    25183 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_SP_CPU4_DMI_NONESAFE_E"
    25184 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BS_CPU4_DMI_NONESAFE_E"
    25185 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU4_DMI_NONESAFE_E"
    25186 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_LPB_CPU4_DMI_NONESAFE_E"
    25187 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU4_DMI_NONESAFE_E"
    25188 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IED_CPU4_DMI_SAFE_E"
    25189 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_T_CPU4_DMI_SAFE_E"
    25190 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_C_CPU4_DMI_SAFE_E"
    25191 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_S_CPU4_DMI_SAFE_E"
    25192 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BI_CPU4_DMI_SAFE_E"
    25193 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_UNC_CPU4_DMI_SAFE_E"
    25194 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_SP_CPU4_DMI_SAFE_E"
    25195 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BS_CPU4_DMI_SAFE_E"
    25196 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU4_DMI_SAFE_E"
    25197 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_LPB_CPU4_DMI_SAFE_E"
    25198 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU4_DMI_SAFE_E"
    25199 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IED_CIF1_E"
    25200 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_T_CIF1_E"
    25201 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_C_CIF1_E"
    25202 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_S_CIF1_E"
    25203 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BI_CIF1_E"
    25204 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_UNC_CIF1_E"
    25205 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_SP_CIF1_E"
    25206 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BS_CIF1_E"
    25207 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_ADDR_CIF1_E"
    25208 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_LPB_CIF1_E"
    25209 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_MTMV_CIF1_E"
    25210 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IED_CPU5_DMI_NONESAFE_E"
    25211 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_T_CPU5_DMI_NONESAFE_E"
    25212 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_C_CPU5_DMI_NONESAFE_E"
    25213 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_S_CPU5_DMI_NONESAFE_E"
    25214 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BI_CPU5_DMI_NONESAFE_E"
    25215 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_UNC_CPU5_DMI_NONESAFE_E"
    25216 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_SP_CPU5_DMI_NONESAFE_E"
    25217 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BS_CPU5_DMI_NONESAFE_E"
    25218 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU5_DMI_NONESAFE_E"
    25219 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_LPB_CPU5_DMI_NONESAFE_E"
    25220 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU5_DMI_NONESAFE_E"
    25221 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IED_CPU5_DMI_SAFE_E"
    25222 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_T_CPU5_DMI_SAFE_E"
    25223 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_C_CPU5_DMI_SAFE_E"
    25224 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_S_CPU5_DMI_SAFE_E"
    25225 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BI_CPU5_DMI_SAFE_E"
    25226 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_UNC_CPU5_DMI_SAFE_E"
    25227 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_SP_CPU5_DMI_SAFE_E"
    25228 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BS_CPU5_DMI_SAFE_E"
    25229 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU5_DMI_SAFE_E"
    25230 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_LPB_CPU5_DMI_SAFE_E"
    25231 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU5_DMI_SAFE_E"
    25232 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IED_CERBERUS_IOC32P_E"
    25233 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_T_CERBERUS_IOC32P_E"
    25234 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_C_CERBERUS_IOC32P_E"
    25235 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_S_CERBERUS_IOC32P_E"
    25236 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BI_CERBERUS_IOC32P_E"
    25237 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_UNC_CERBERUS_IOC32P_E"
    25238 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_SP_CERBERUS_IOC32P_E"
    25239 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BS_CERBERUS_IOC32P_E"
    25240 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_ADDR_CERBERUS_IOC32P_E"
    25241 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_LPB_CERBERUS_IOC32P_E"
    25242 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_MTMV_CERBERUS_IOC32P_E"
    25243 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IED_IOC32E_E"
    25244 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_T_IOC32E_E"
    25245 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_C_IOC32E_E"
    25246 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_S_IOC32E_E"
    25247 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BI_IOC32E_E"
    25248 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_UNC_IOC32E_E"
    25249 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_SP_IOC32E_E"
    25250 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BS_IOC32E_E"
    25251 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_ADDR_IOC32E_E"
    25252 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_LPB_IOC32E_E"
    25253 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_MTMV_IOC32E_E"
    25254 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IED_CPU0_PMI_PMBI_E"
    25255 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_T_CPU0_PMI_PMBI_E"
    25256 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_C_CPU0_PMI_PMBI_E"
    25257 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_S_CPU0_PMI_PMBI_E"
    25258 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BI_CPU0_PMI_PMBI_E"
    25259 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_UNC_CPU0_PMI_PMBI_E"
    25260 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_SP_CPU0_PMI_PMBI_E"
    25261 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BS_CPU0_PMI_PMBI_E"
    25262 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU0_PMI_PMBI_E"
    25263 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_LPB_CPU0_PMI_PMBI_E"
    25264 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU0_PMI_PMBI_E"
    25265 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IED_CPU1_PMI_PMBI_E"
    25266 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_T_CPU1_PMI_PMBI_E"
    25267 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_C_CPU1_PMI_PMBI_E"
    25268 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_S_CPU1_PMI_PMBI_E"
    25269 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BI_CPU1_PMI_PMBI_E"
    25270 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_UNC_CPU1_PMI_PMBI_E"
    25271 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_SP_CPU1_PMI_PMBI_E"
    25272 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BS_CPU1_PMI_PMBI_E"
    25273 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU1_PMI_PMBI_E"
    25274 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_LPB_CPU1_PMI_PMBI_E"
    25275 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU1_PMI_PMBI_E"
    25276 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IED_CPU2_PMI_PMBI_E"
    25277 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_T_CPU2_PMI_PMBI_E"
    25278 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_C_CPU2_PMI_PMBI_E"
    25279 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_S_CPU2_PMI_PMBI_E"
    25280 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BI_CPU2_PMI_PMBI_E"
    25281 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_UNC_CPU2_PMI_PMBI_E"
    25282 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_SP_CPU2_PMI_PMBI_E"
    25283 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BS_CPU2_PMI_PMBI_E"
    25284 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU2_PMI_PMBI_E"
    25285 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_LPB_CPU2_PMI_PMBI_E"
    25286 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU2_PMI_PMBI_E"
    25287 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IED_CPU3_PMI_PMBI_E"
    25288 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_T_CPU3_PMI_PMBI_E"
    25289 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_C_CPU3_PMI_PMBI_E"
    25290 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_S_CPU3_PMI_PMBI_E"
    25291 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BI_CPU3_PMI_PMBI_E"
    25292 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_UNC_CPU3_PMI_PMBI_E"
    25293 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_SP_CPU3_PMI_PMBI_E"
    25294 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BS_CPU3_PMI_PMBI_E"
    25295 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU3_PMI_PMBI_E"
    25296 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_LPB_CPU3_PMI_PMBI_E"
    25297 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU3_PMI_PMBI_E"
    25298 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IED_CPU4_PMI_PMBI_E"
    25299 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_T_CPU4_PMI_PMBI_E"
    25300 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_C_CPU4_PMI_PMBI_E"
    25301 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_S_CPU4_PMI_PMBI_E"
    25302 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BI_CPU4_PMI_PMBI_E"
    25303 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_UNC_CPU4_PMI_PMBI_E"
    25304 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_SP_CPU4_PMI_PMBI_E"
    25305 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BS_CPU4_PMI_PMBI_E"
    25306 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU4_PMI_PMBI_E"
    25307 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_LPB_CPU4_PMI_PMBI_E"
    25308 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU4_PMI_PMBI_E"
    25309 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IED_CPU5_PMI_PMBI_E"
    25310 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_T_CPU5_PMI_PMBI_E"
    25311 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_C_CPU5_PMI_PMBI_E"
    25312 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_S_CPU5_PMI_PMBI_E"
    25313 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BI_CPU5_PMI_PMBI_E"
    25314 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_UNC_CPU5_PMI_PMBI_E"
    25315 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_SP_CPU5_PMI_PMBI_E"
    25316 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BS_CPU5_PMI_PMBI_E"
    25317 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU5_PMI_PMBI_E"
    25318 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_LPB_CPU5_PMI_PMBI_E"
    25319 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU5_PMI_PMBI_E"
    25320 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IED_GETH_DMA0_E"
    25321 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_T_GETH_DMA0_E"
    25322 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_C_GETH_DMA0_E"
    25323 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_S_GETH_DMA0_E"
    25324 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BI_GETH_DMA0_E"
    25325 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_UNC_GETH_DMA0_E"
    25326 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_SP_GETH_DMA0_E"
    25327 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BS_GETH_DMA0_E"
    25328 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_ADDR_GETH_DMA0_E"
    25329 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_LPB_GETH_DMA0_E"
    25330 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_MTMV_GETH_DMA0_E"
    25331 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IED_GETH_DMA1_E"
    25332 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_T_GETH_DMA1_E"
    25333 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_C_GETH_DMA1_E"
    25334 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_S_GETH_DMA1_E"
    25335 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BI_GETH_DMA1_E"
    25336 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_UNC_GETH_DMA1_E"
    25337 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_SP_GETH_DMA1_E"
    25338 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BS_GETH_DMA1_E"
    25339 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_ADDR_GETH_DMA1_E"
    25340 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_LPB_GETH_DMA1_E"
    25341 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_MTMV_GETH_DMA1_E"
    25342 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IED_GETH_DMA2_E"
    25343 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_T_GETH_DMA2_E"
    25344 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_C_GETH_DMA2_E"
    25345 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_S_GETH_DMA2_E"
    25346 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BI_GETH_DMA2_E"
    25347 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_UNC_GETH_DMA2_E"
    25348 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_SP_GETH_DMA2_E"
    25349 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BS_GETH_DMA2_E"
    25350 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_ADDR_GETH_DMA2_E"
    25351 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_LPB_GETH_DMA2_E"
    25352 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_MTMV_GETH_DMA2_E"
    25353 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IED_GETH_DMA3_E"
    25354 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_T_GETH_DMA3_E"
    25355 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_C_GETH_DMA3_E"
    25356 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_S_GETH_DMA3_E"
    25357 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BI_GETH_DMA3_E"
    25358 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_UNC_GETH_DMA3_E"
    25359 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_SP_GETH_DMA3_E"
    25360 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BS_GETH_DMA3_E"
    25361 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_ADDR_GETH_DMA3_E"
    25362 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_LPB_GETH_DMA3_E"
    25363 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_MTMV_GETH_DMA3_E"
    25364 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IED_DAM0_E"
    25365 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_T_DAM0_E"
    25366 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_C_DAM0_E"
    25367 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_S_DAM0_E"
    25368 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BI_DAM0_E"
    25369 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_UNC_DAM0_E"
    25370 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_SP_DAM0_E"
    25371 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BS_DAM0_E"
    25372 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_ADDR_DAM0_E"
    25373 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_LPB_DAM0_E"
    25374 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_MTMV_DAM0_E"
    25375 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IED_DAM1_E"
    25376 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_T_DAM1_E"
    25377 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_C_DAM1_E"
    25378 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_S_DAM1_E"
    25379 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BI_DAM1_E"
    25380 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_UNC_DAM1_E"
    25381 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_SP_DAM1_E"
    25382 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_BS_DAM1_E"
    25383 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_ADDR_DAM1_E"
    25384 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_LPB_DAM1_E"
    25385 "RBA_RESET_CPU1_TRAP_SYSBUSERR_DIE_IE_MTMV_DAM1_E"
    25386 "RBA_RESET_CPU1_TRAP_TCN4_UNKNOWN_E"
    25387 "RBA_RESET_CPU1_TRAP_TCN5_TIN0_E"
    25388 "RBA_RESET_CPU1_TRAP_ASSTRAP_OVF_E"
    25389 "RBA_RESET_CPU1_TRAP_ASSTRAP_SOVF_E"
    25390 "RBA_RESET_CPU1_TRAP_TCN5_UNKNOWN_E"
    25391 "RBA_RESET_CPU1_TRAP_SYSCALL_SYS_E"
    25392 "RBA_RESET_CPU1_TRAP_NMI_UNKNOWN_E"
    25393 "RBA_RESET_CPU1_TRAP_NMI_ESR0_E"
    25394 "RBA_RESET_CPU1_TRAP_NMI_ESR1_E"
    25395 "RBA_RESET_CPU1_TRAP_NMI_SMUT_E"
    25396 "RBA_RESET_CPU1_TRAP_NMI_SMU_CPU0_MPU_E"
    25397 "RBA_RESET_CPU1_TRAP_NMI_SMU_CPU1_MPU_E"
    25398 "RBA_RESET_CPU1_TRAP_NMI_SMU_CPU2_MPU_E"
    25399 "RBA_RESET_CPU1_TRAP_NMI_SMU_IR_E"
    25400 "RBA_RESET_CPU1_TRAP_NMI_SMU_CGU_WDT_E"
    25401 "RBA_RESET_CPU1_TRAP_NMI_SMU_CGU_PLLLOL_E"
    25402 "RBA_RESET_CPU1_TRAP_NMI_SMU_CGU_PLLERAYLOL_E"
    25403 "RBA_RESET_CPU1_TRAP_NMI_SMU_CGU_STM_E"
    25404 "RBA_RESET_CPU1_TRAP_NMI_SMU_CGU_PLLERAY_E"
    25405 "RBA_RESET_CPU1_TRAP_NMI_SMU_CGU_PLL_E"
    25406 "RBA_RESET_CPU1_TRAP_NMI_SMU_CGU_SRI_E"
    25407 "RBA_RESET_CPU1_TRAP_NMI_SMU_CGU_SPB_E"
    25408 "RBA_RESET_CPU1_TRAP_NMI_SMU_CGU_CPU0_E"
    25409 "RBA_RESET_CPU1_TRAP_NMI_SMU_SCUEVR_12UV_E"
    25410 "RBA_RESET_CPU1_TRAP_NMI_SMU_SCUEVR_12OV_E"
    25411 "RBA_RESET_CPU1_TRAP_NMI_SMU_SCUEVR_33UV_E"
    25412 "RBA_RESET_CPU1_TRAP_NMI_SMU_SCUEVR_33OV_E"
    25413 "RBA_RESET_CPU1_TRAP_NMI_SMU_SCUEVR_5UV_E"
    25414 "RBA_RESET_CPU1_TRAP_NMI_SMU_SCUEVR_5OV_E"
    25415 "RBA_RESET_CPU1_TRAP_NMI_SMU_SWDT_E"
    25416 "RBA_RESET_CPU1_TRAP_NMI_SMU_WDT0_E"
    25417 "RBA_RESET_CPU1_TRAP_NMI_SMU_WDT1_E"
    25418 "RBA_RESET_CPU1_TRAP_NMI_SMU_WDT2_E"
    25419 "RBA_RESET_CPU1_TRAP_NMI_SMU_WDT3_E"
    25420 "RBA_RESET_CPU1_TRAP_NMI_SMU_WDT4_E"
    25421 "RBA_RESET_CPU1_TRAP_NMI_SMU_WDT5_E"
    25422 "RBA_RESET_CPU1_TRAP_TCN7_UNKNOWN_E"
    28672 "RBA_RESET_CPU2_TRAP_MMU_VAF_E"
    28673 "RBA_RESET_CPU2_TRAP_MMU_VAP_E"
    28674 "RBA_RESET_CPU2_TRAP_TCN0_UNKNOWN_E"
    28675 "RBA_RESET_CPU2_TRAP_TCN1_TIN0_E"
    28676 "RBA_RESET_CPU2_TRAP_INTPROT_PRIV_E"
    28677 "RBA_RESET_CPU2_TRAP_INTPROT_MPR_E"
    28678 "RBA_RESET_CPU2_TRAP_INTPROT_MPW_E"
    28679 "RBA_RESET_CPU2_TRAP_INTPROT_MPX_E"
    28680 "RBA_RESET_CPU2_TRAP_INTPROT_MPP_E"
    28681 "RBA_RESET_CPU2_TRAP_INTPROT_MPN_E"
    28682 "RBA_RESET_CPU2_TRAP_INTPROT_GRWP_E"
    28683 "RBA_RESET_CPU2_TRAP_TCN1_UNKNOWN_E"
    28684 "RBA_RESET_CPU2_TRAP_TCN2_TIN0_E"
    28685 "RBA_RESET_CPU2_TRAP_INSTRERR_IOPC_E"
    28686 "RBA_RESET_CPU2_TRAP_INSTRERR_UOPC_E"
    28687 "RBA_RESET_CPU2_TRAP_INSTRERR_OPD_E"
    28688 "RBA_RESET_CPU2_TRAP_INSTRERR_ALN_E"
    28689 "RBA_RESET_CPU2_TRAP_INSTRERR_MEM_E"
    28690 "RBA_RESET_CPU2_TRAP_TCN2_UNKNOWN_E"
    28691 "RBA_RESET_CPU2_TRAP_TCN3_TIN0_E"
    28692 "RBA_RESET_CPU2_TRAP_CONTMANA_FCD_E"
    28693 "RBA_RESET_CPU2_TRAP_CONTMANA_CDO_E"
    28694 "RBA_RESET_CPU2_TRAP_CONTMANA_CDU_E"
    28695 "RBA_RESET_CPU2_TRAP_CONTMANA_FCU_E"
    28696 "RBA_RESET_CPU2_TRAP_CONTMANA_CSU_E"
    28697 "RBA_RESET_CPU2_TRAP_CONTMANA_CTYP_E"
    28698 "RBA_RESET_CPU2_TRAP_CONTMANA_NEST_E"
    28699 "RBA_RESET_CPU2_TRAP_TCN3_UNKNOWN_E"
    28700 "RBA_RESET_CPU2_TRAP_TCN4_TIN0_E"
    28701 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PSE_E"
    28702 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DSE_E"
    28703 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DAE_E"
    28704 "RBA_RESET_CPU2_TRAP_SYSBUSERR_CAE_E"
    28705 "RBA_RESET_CPU2_TRAP_FPU_INEXACT_E"
    28706 "RBA_RESET_CPU2_TRAP_FPU_UNRFLW_E"
    28707 "RBA_RESET_CPU2_TRAP_FPU_DIVZRO_E"
    28708 "RBA_RESET_CPU2_TRAP_FPU_OVRFLW_E"
    28709 "RBA_RESET_CPU2_TRAP_FPU_INVOPR_E"
    28710 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_UNKNOWN_E"
    28711 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IED_DMA_PARTITION_0_E"
    28712 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_T_DMA_PARTITION_0_E"
    28713 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_C_DMA_PARTITION_0_E"
    28714 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_S_DMA_PARTITION_0_E"
    28715 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BI_DMA_PARTITION_0_E"
    28716 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_UNC_DMA_PARTITION_0_E"
    28717 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_SP_DMA_PARTITION_0_E"
    28718 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BS_DMA_PARTITION_0_E"
    28719 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_ADDR_DMA_PARTITION_0_E"
    28720 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_LPB_DMA_PARTITION_0_E"
    28721 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_MTMV_DMA_PARTITION_0_E"
    28722 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IED_CPU0_DMI_NONESAFE_E"
    28723 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_T_CPU0_DMI_NONESAFE_E"
    28724 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_C_CPU0_DMI_NONESAFE_E"
    28725 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_S_CPU0_DMI_NONESAFE_E"
    28726 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BI_CPU0_DMI_NONESAFE_E"
    28727 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_UNC_CPU0_DMI_NONESAFE_E"
    28728 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_SP_CPU0_DMI_NONESAFE_E"
    28729 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BS_CPU0_DMI_NONESAFE_E"
    28730 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU0_DMI_NONESAFE_E"
    28731 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_LPB_CPU0_DMI_NONESAFE_E"
    28732 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU0_DMI_NONESAFE_E"
    28733 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IED_CPU0_DMI_SAFE_E"
    28734 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_T_CPU0_DMI_SAFE_E"
    28735 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_C_CPU0_DMI_SAFE_E"
    28736 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_S_CPU0_DMI_SAFE_E"
    28737 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BI_CPU0_DMI_SAFE_E"
    28738 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_UNC_CPU0_DMI_SAFE_E"
    28739 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_SP_CPU0_DMI_SAFE_E"
    28740 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BS_CPU0_DMI_SAFE_E"
    28741 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU0_DMI_SAFE_E"
    28742 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_LPB_CPU0_DMI_SAFE_E"
    28743 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU0_DMI_SAFE_E"
    28744 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IED_HSMCMI_HSMRMI_E"
    28745 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_T_HSMCMI_HSMRMI_E"
    28746 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_C_HSMCMI_HSMRMI_E"
    28747 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_S_HSMCMI_HSMRMI_E"
    28748 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BI_HSMCMI_HSMRMI_E"
    28749 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_UNC_HSMCMI_HSMRMI_E"
    28750 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_SP_HSMCMI_HSMRMI_E"
    28751 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BS_HSMCMI_HSMRMI_E"
    28752 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_ADDR_HSMCMI_HSMRMI_E"
    28753 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_LPB_HSMCMI_HSMRMI_E"
    28754 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_MTMV_HSMCMI_HSMRMI_E"
    28755 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IED_DMA_PARTITION_1_E"
    28756 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_T_DMA_PARTITION_1_E"
    28757 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_C_DMA_PARTITION_1_E"
    28758 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_S_DMA_PARTITION_1_E"
    28759 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BI_DMA_PARTITION_1_E"
    28760 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_UNC_DMA_PARTITION_1_E"
    28761 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_SP_DMA_PARTITION_1_E"
    28762 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BS_DMA_PARTITION_1_E"
    28763 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_ADDR_DMA_PARTITION_1_E"
    28764 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_LPB_DMA_PARTITION_1_E"
    28765 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_MTMV_DMA_PARTITION_1_E"
    28766 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IED_CPU1_DMI_NONESAFE_E"
    28767 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_T_CPU1_DMI_NONESAFE_E"
    28768 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_C_CPU1_DMI_NONESAFE_E"
    28769 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_S_CPU1_DMI_NONESAFE_E"
    28770 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BI_CPU1_DMI_NONESAFE_E"
    28771 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_UNC_CPU1_DMI_NONESAFE_E"
    28772 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_SP_CPU1_DMI_NONESAFE_E"
    28773 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BS_CPU1_DMI_NONESAFE_E"
    28774 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU1_DMI_NONESAFE_E"
    28775 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_LPB_CPU1_DMI_NONESAFE_E"
    28776 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU1_DMI_NONESAFE_E"
    28777 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IED_CPU1_DMI_SAFE_E"
    28778 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_T_CPU1_DMI_SAFE_E"
    28779 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_C_CPU1_DMI_SAFE_E"
    28780 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_S_CPU1_DMI_SAFE_E"
    28781 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BI_CPU1_DMI_SAFE_E"
    28782 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_UNC_CPU1_DMI_SAFE_E"
    28783 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_SP_CPU1_DMI_SAFE_E"
    28784 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BS_CPU1_DMI_SAFE_E"
    28785 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU1_DMI_SAFE_E"
    28786 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_LPB_CPU1_DMI_SAFE_E"
    28787 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU1_DMI_SAFE_E"
    28788 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IED_SDMMC_E"
    28789 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_T_SDMMC_E"
    28790 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_C_SDMMC_E"
    28791 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_S_SDMMC_E"
    28792 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BI_SDMMC_E"
    28793 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_UNC_SDMMC_E"
    28794 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_SP_SDMMC_E"
    28795 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BS_SDMMC_E"
    28796 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_ADDR_SDMMC_E"
    28797 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_LPB_SDMMC_E"
    28798 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_MTMV_SDMMC_E"
    28799 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IED_DMA_PARTITION_2_E"
    28800 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_T_DMA_PARTITION_2_E"
    28801 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_C_DMA_PARTITION_2_E"
    28802 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_S_DMA_PARTITION_2_E"
    28803 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BI_DMA_PARTITION_2_E"
    28804 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_UNC_DMA_PARTITION_2_E"
    28805 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_SP_DMA_PARTITION_2_E"
    28806 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BS_DMA_PARTITION_2_E"
    28807 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_ADDR_DMA_PARTITION_2_E"
    28808 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_LPB_DMA_PARTITION_2_E"
    28809 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_MTMV_DMA_PARTITION_2_E"
    28810 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IED_CPU2_DMI_NONESAFE_E"
    28811 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_T_CPU2_DMI_NONESAFE_E"
    28812 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_C_CPU2_DMI_NONESAFE_E"
    28813 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_S_CPU2_DMI_NONESAFE_E"
    28814 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BI_CPU2_DMI_NONESAFE_E"
    28815 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_UNC_CPU2_DMI_NONESAFE_E"
    28816 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_SP_CPU2_DMI_NONESAFE_E"
    28817 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BS_CPU2_DMI_NONESAFE_E"
    28818 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU2_DMI_NONESAFE_E"
    28819 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_LPB_CPU2_DMI_NONESAFE_E"
    28820 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU2_DMI_NONESAFE_E"
    28821 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IED_CPU2_DMI_SAFE_E"
    28822 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_T_CPU2_DMI_SAFE_E"
    28823 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_C_CPU2_DMI_SAFE_E"
    28824 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_S_CPU2_DMI_SAFE_E"
    28825 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BI_CPU2_DMI_SAFE_E"
    28826 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_UNC_CPU2_DMI_SAFE_E"
    28827 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_SP_CPU2_DMI_SAFE_E"
    28828 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BS_CPU2_DMI_SAFE_E"
    28829 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU2_DMI_SAFE_E"
    28830 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_LPB_CPU2_DMI_SAFE_E"
    28831 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU2_DMI_SAFE_E"
    28832 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IED_HSSL0_E"
    28833 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_T_HSSL0_E"
    28834 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_C_HSSL0_E"
    28835 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_S_HSSL0_E"
    28836 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BI_HSSL0_E"
    28837 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_UNC_HSSL0_E"
    28838 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_SP_HSSL0_E"
    28839 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BS_HSSL0_E"
    28840 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_ADDR_HSSL0_E"
    28841 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_LPB_HSSL0_E"
    28842 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_MTMV_HSSL0_E"
    28843 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IED_DMA_PARTITION_3_E"
    28844 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_T_DMA_PARTITION_3_E"
    28845 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_C_DMA_PARTITION_3_E"
    28846 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_S_DMA_PARTITION_3_E"
    28847 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BI_DMA_PARTITION_3_E"
    28848 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_UNC_DMA_PARTITION_3_E"
    28849 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_SP_DMA_PARTITION_3_E"
    28850 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BS_DMA_PARTITION_3_E"
    28851 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_ADDR_DMA_PARTITION_3_E"
    28852 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_LPB_DMA_PARTITION_3_E"
    28853 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_MTMV_DMA_PARTITION_3_E"
    28854 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IED_CPU3_DMI_NONESAFE_E"
    28855 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_T_CPU3_DMI_NONESAFE_E"
    28856 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_C_CPU3_DMI_NONESAFE_E"
    28857 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_S_CPU3_DMI_NONESAFE_E"
    28858 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BI_CPU3_DMI_NONESAFE_E"
    28859 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_UNC_CPU3_DMI_NONESAFE_E"
    28860 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_SP_CPU3_DMI_NONESAFE_E"
    28861 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BS_CPU3_DMI_NONESAFE_E"
    28862 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU3_DMI_NONESAFE_E"
    28863 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_LPB_CPU3_DMI_NONESAFE_E"
    28864 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU3_DMI_NONESAFE_E"
    28865 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IED_CPU3_DMI_SAFE_E"
    28866 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_T_CPU3_DMI_SAFE_E"
    28867 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_C_CPU3_DMI_SAFE_E"
    28868 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_S_CPU3_DMI_SAFE_E"
    28869 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BI_CPU3_DMI_SAFE_E"
    28870 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_UNC_CPU3_DMI_SAFE_E"
    28871 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_SP_CPU3_DMI_SAFE_E"
    28872 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BS_CPU3_DMI_SAFE_E"
    28873 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU3_DMI_SAFE_E"
    28874 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_LPB_CPU3_DMI_SAFE_E"
    28875 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU3_DMI_SAFE_E"
    28876 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IED_HSSL1_E"
    28877 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_T_HSSL1_E"
    28878 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_C_HSSL1_E"
    28879 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_S_HSSL1_E"
    28880 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BI_HSSL1_E"
    28881 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_UNC_HSSL1_E"
    28882 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_SP_HSSL1_E"
    28883 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BS_HSSL1_E"
    28884 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_ADDR_HSSL1_E"
    28885 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_LPB_HSSL1_E"
    28886 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_MTMV_HSSL1_E"
    28887 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IED_CPU4_DMI_NONESAFE_E"
    28888 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_T_CPU4_DMI_NONESAFE_E"
    28889 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_C_CPU4_DMI_NONESAFE_E"
    28890 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_S_CPU4_DMI_NONESAFE_E"
    28891 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BI_CPU4_DMI_NONESAFE_E"
    28892 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_UNC_CPU4_DMI_NONESAFE_E"
    28893 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_SP_CPU4_DMI_NONESAFE_E"
    28894 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BS_CPU4_DMI_NONESAFE_E"
    28895 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU4_DMI_NONESAFE_E"
    28896 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_LPB_CPU4_DMI_NONESAFE_E"
    28897 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU4_DMI_NONESAFE_E"
    28898 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IED_CPU4_DMI_SAFE_E"
    28899 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_T_CPU4_DMI_SAFE_E"
    28900 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_C_CPU4_DMI_SAFE_E"
    28901 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_S_CPU4_DMI_SAFE_E"
    28902 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BI_CPU4_DMI_SAFE_E"
    28903 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_UNC_CPU4_DMI_SAFE_E"
    28904 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_SP_CPU4_DMI_SAFE_E"
    28905 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BS_CPU4_DMI_SAFE_E"
    28906 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU4_DMI_SAFE_E"
    28907 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_LPB_CPU4_DMI_SAFE_E"
    28908 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU4_DMI_SAFE_E"
    28909 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IED_CIF1_E"
    28910 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_T_CIF1_E"
    28911 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_C_CIF1_E"
    28912 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_S_CIF1_E"
    28913 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BI_CIF1_E"
    28914 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_UNC_CIF1_E"
    28915 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_SP_CIF1_E"
    28916 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BS_CIF1_E"
    28917 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_ADDR_CIF1_E"
    28918 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_LPB_CIF1_E"
    28919 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_MTMV_CIF1_E"
    28920 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IED_CPU5_DMI_NONESAFE_E"
    28921 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_T_CPU5_DMI_NONESAFE_E"
    28922 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_C_CPU5_DMI_NONESAFE_E"
    28923 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_S_CPU5_DMI_NONESAFE_E"
    28924 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BI_CPU5_DMI_NONESAFE_E"
    28925 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_UNC_CPU5_DMI_NONESAFE_E"
    28926 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_SP_CPU5_DMI_NONESAFE_E"
    28927 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BS_CPU5_DMI_NONESAFE_E"
    28928 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU5_DMI_NONESAFE_E"
    28929 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_LPB_CPU5_DMI_NONESAFE_E"
    28930 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU5_DMI_NONESAFE_E"
    28931 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IED_CPU5_DMI_SAFE_E"
    28932 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_T_CPU5_DMI_SAFE_E"
    28933 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_C_CPU5_DMI_SAFE_E"
    28934 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_S_CPU5_DMI_SAFE_E"
    28935 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BI_CPU5_DMI_SAFE_E"
    28936 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_UNC_CPU5_DMI_SAFE_E"
    28937 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_SP_CPU5_DMI_SAFE_E"
    28938 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BS_CPU5_DMI_SAFE_E"
    28939 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU5_DMI_SAFE_E"
    28940 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_LPB_CPU5_DMI_SAFE_E"
    28941 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU5_DMI_SAFE_E"
    28942 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IED_CERBERUS_IOC32P_E"
    28943 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_T_CERBERUS_IOC32P_E"
    28944 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_C_CERBERUS_IOC32P_E"
    28945 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_S_CERBERUS_IOC32P_E"
    28946 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BI_CERBERUS_IOC32P_E"
    28947 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_UNC_CERBERUS_IOC32P_E"
    28948 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_SP_CERBERUS_IOC32P_E"
    28949 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BS_CERBERUS_IOC32P_E"
    28950 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_ADDR_CERBERUS_IOC32P_E"
    28951 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_LPB_CERBERUS_IOC32P_E"
    28952 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_MTMV_CERBERUS_IOC32P_E"
    28953 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IED_IOC32E_E"
    28954 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_T_IOC32E_E"
    28955 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_C_IOC32E_E"
    28956 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_S_IOC32E_E"
    28957 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BI_IOC32E_E"
    28958 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_UNC_IOC32E_E"
    28959 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_SP_IOC32E_E"
    28960 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BS_IOC32E_E"
    28961 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_ADDR_IOC32E_E"
    28962 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_LPB_IOC32E_E"
    28963 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_MTMV_IOC32E_E"
    28964 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IED_CPU0_PMI_PMBI_E"
    28965 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_T_CPU0_PMI_PMBI_E"
    28966 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_C_CPU0_PMI_PMBI_E"
    28967 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_S_CPU0_PMI_PMBI_E"
    28968 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BI_CPU0_PMI_PMBI_E"
    28969 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_UNC_CPU0_PMI_PMBI_E"
    28970 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_SP_CPU0_PMI_PMBI_E"
    28971 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BS_CPU0_PMI_PMBI_E"
    28972 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU0_PMI_PMBI_E"
    28973 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_LPB_CPU0_PMI_PMBI_E"
    28974 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU0_PMI_PMBI_E"
    28975 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IED_CPU1_PMI_PMBI_E"
    28976 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_T_CPU1_PMI_PMBI_E"
    28977 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_C_CPU1_PMI_PMBI_E"
    28978 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_S_CPU1_PMI_PMBI_E"
    28979 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BI_CPU1_PMI_PMBI_E"
    28980 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_UNC_CPU1_PMI_PMBI_E"
    28981 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_SP_CPU1_PMI_PMBI_E"
    28982 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BS_CPU1_PMI_PMBI_E"
    28983 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU1_PMI_PMBI_E"
    28984 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_LPB_CPU1_PMI_PMBI_E"
    28985 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU1_PMI_PMBI_E"
    28986 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IED_CPU2_PMI_PMBI_E"
    28987 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_T_CPU2_PMI_PMBI_E"
    28988 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_C_CPU2_PMI_PMBI_E"
    28989 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_S_CPU2_PMI_PMBI_E"
    28990 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BI_CPU2_PMI_PMBI_E"
    28991 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_UNC_CPU2_PMI_PMBI_E"
    28992 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_SP_CPU2_PMI_PMBI_E"
    28993 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BS_CPU2_PMI_PMBI_E"
    28994 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU2_PMI_PMBI_E"
    28995 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_LPB_CPU2_PMI_PMBI_E"
    28996 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU2_PMI_PMBI_E"
    28997 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IED_CPU3_PMI_PMBI_E"
    28998 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_T_CPU3_PMI_PMBI_E"
    28999 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_C_CPU3_PMI_PMBI_E"
    29000 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_S_CPU3_PMI_PMBI_E"
    29001 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BI_CPU3_PMI_PMBI_E"
    29002 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_UNC_CPU3_PMI_PMBI_E"
    29003 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_SP_CPU3_PMI_PMBI_E"
    29004 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BS_CPU3_PMI_PMBI_E"
    29005 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU3_PMI_PMBI_E"
    29006 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_LPB_CPU3_PMI_PMBI_E"
    29007 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU3_PMI_PMBI_E"
    29008 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IED_CPU4_PMI_PMBI_E"
    29009 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_T_CPU4_PMI_PMBI_E"
    29010 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_C_CPU4_PMI_PMBI_E"
    29011 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_S_CPU4_PMI_PMBI_E"
    29012 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BI_CPU4_PMI_PMBI_E"
    29013 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_UNC_CPU4_PMI_PMBI_E"
    29014 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_SP_CPU4_PMI_PMBI_E"
    29015 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BS_CPU4_PMI_PMBI_E"
    29016 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU4_PMI_PMBI_E"
    29017 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_LPB_CPU4_PMI_PMBI_E"
    29018 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU4_PMI_PMBI_E"
    29019 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IED_CPU5_PMI_PMBI_E"
    29020 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_T_CPU5_PMI_PMBI_E"
    29021 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_C_CPU5_PMI_PMBI_E"
    29022 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_S_CPU5_PMI_PMBI_E"
    29023 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BI_CPU5_PMI_PMBI_E"
    29024 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_UNC_CPU5_PMI_PMBI_E"
    29025 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_SP_CPU5_PMI_PMBI_E"
    29026 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BS_CPU5_PMI_PMBI_E"
    29027 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU5_PMI_PMBI_E"
    29028 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_LPB_CPU5_PMI_PMBI_E"
    29029 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU5_PMI_PMBI_E"
    29030 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IED_GETH_DMA0_E"
    29031 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_T_GETH_DMA0_E"
    29032 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_C_GETH_DMA0_E"
    29033 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_S_GETH_DMA0_E"
    29034 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BI_GETH_DMA0_E"
    29035 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_UNC_GETH_DMA0_E"
    29036 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_SP_GETH_DMA0_E"
    29037 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BS_GETH_DMA0_E"
    29038 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_ADDR_GETH_DMA0_E"
    29039 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_LPB_GETH_DMA0_E"
    29040 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_MTMV_GETH_DMA0_E"
    29041 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IED_GETH_DMA1_E"
    29042 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_T_GETH_DMA1_E"
    29043 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_C_GETH_DMA1_E"
    29044 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_S_GETH_DMA1_E"
    29045 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BI_GETH_DMA1_E"
    29046 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_UNC_GETH_DMA1_E"
    29047 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_SP_GETH_DMA1_E"
    29048 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BS_GETH_DMA1_E"
    29049 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_ADDR_GETH_DMA1_E"
    29050 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_LPB_GETH_DMA1_E"
    29051 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_MTMV_GETH_DMA1_E"
    29052 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IED_GETH_DMA2_E"
    29053 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_T_GETH_DMA2_E"
    29054 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_C_GETH_DMA2_E"
    29055 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_S_GETH_DMA2_E"
    29056 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BI_GETH_DMA2_E"
    29057 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_UNC_GETH_DMA2_E"
    29058 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_SP_GETH_DMA2_E"
    29059 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BS_GETH_DMA2_E"
    29060 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_ADDR_GETH_DMA2_E"
    29061 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_LPB_GETH_DMA2_E"
    29062 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_MTMV_GETH_DMA2_E"
    29063 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IED_GETH_DMA3_E"
    29064 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_T_GETH_DMA3_E"
    29065 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_C_GETH_DMA3_E"
    29066 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_S_GETH_DMA3_E"
    29067 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BI_GETH_DMA3_E"
    29068 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_UNC_GETH_DMA3_E"
    29069 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_SP_GETH_DMA3_E"
    29070 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BS_GETH_DMA3_E"
    29071 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_ADDR_GETH_DMA3_E"
    29072 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_LPB_GETH_DMA3_E"
    29073 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_MTMV_GETH_DMA3_E"
    29074 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IED_DAM0_E"
    29075 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_T_DAM0_E"
    29076 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_C_DAM0_E"
    29077 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_S_DAM0_E"
    29078 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BI_DAM0_E"
    29079 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_UNC_DAM0_E"
    29080 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_SP_DAM0_E"
    29081 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BS_DAM0_E"
    29082 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_ADDR_DAM0_E"
    29083 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_LPB_DAM0_E"
    29084 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_MTMV_DAM0_E"
    29085 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IED_DAM1_E"
    29086 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_T_DAM1_E"
    29087 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_C_DAM1_E"
    29088 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_S_DAM1_E"
    29089 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BI_DAM1_E"
    29090 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_UNC_DAM1_E"
    29091 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_SP_DAM1_E"
    29092 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_BS_DAM1_E"
    29093 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_ADDR_DAM1_E"
    29094 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_LPB_DAM1_E"
    29095 "RBA_RESET_CPU2_TRAP_SYSBUSERR_PIE_IE_MTMV_DAM1_E"
    29096 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_UNKNOWN_E"
    29097 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IED_DMA_PARTITION_0_E"
    29098 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_T_DMA_PARTITION_0_E"
    29099 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_C_DMA_PARTITION_0_E"
    29100 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_S_DMA_PARTITION_0_E"
    29101 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BI_DMA_PARTITION_0_E"
    29102 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_UNC_DMA_PARTITION_0_E"
    29103 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_SP_DMA_PARTITION_0_E"
    29104 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BS_DMA_PARTITION_0_E"
    29105 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_ADDR_DMA_PARTITION_0_E"
    29106 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_LPB_DMA_PARTITION_0_E"
    29107 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_MTMV_DMA_PARTITION_0_E"
    29108 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IED_CPU0_DMI_NONESAFE_E"
    29109 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_T_CPU0_DMI_NONESAFE_E"
    29110 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_C_CPU0_DMI_NONESAFE_E"
    29111 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_S_CPU0_DMI_NONESAFE_E"
    29112 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BI_CPU0_DMI_NONESAFE_E"
    29113 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_UNC_CPU0_DMI_NONESAFE_E"
    29114 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_SP_CPU0_DMI_NONESAFE_E"
    29115 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BS_CPU0_DMI_NONESAFE_E"
    29116 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU0_DMI_NONESAFE_E"
    29117 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_LPB_CPU0_DMI_NONESAFE_E"
    29118 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU0_DMI_NONESAFE_E"
    29119 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IED_CPU0_DMI_SAFE_E"
    29120 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_T_CPU0_DMI_SAFE_E"
    29121 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_C_CPU0_DMI_SAFE_E"
    29122 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_S_CPU0_DMI_SAFE_E"
    29123 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BI_CPU0_DMI_SAFE_E"
    29124 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_UNC_CPU0_DMI_SAFE_E"
    29125 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_SP_CPU0_DMI_SAFE_E"
    29126 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BS_CPU0_DMI_SAFE_E"
    29127 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU0_DMI_SAFE_E"
    29128 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_LPB_CPU0_DMI_SAFE_E"
    29129 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU0_DMI_SAFE_E"
    29130 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IED_HSMCMI_HSMRMI_E"
    29131 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_T_HSMCMI_HSMRMI_E"
    29132 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_C_HSMCMI_HSMRMI_E"
    29133 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_S_HSMCMI_HSMRMI_E"
    29134 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BI_HSMCMI_HSMRMI_E"
    29135 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_UNC_HSMCMI_HSMRMI_E"
    29136 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_SP_HSMCMI_HSMRMI_E"
    29137 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BS_HSMCMI_HSMRMI_E"
    29138 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_ADDR_HSMCMI_HSMRMI_E"
    29139 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_LPB_HSMCMI_HSMRMI_E"
    29140 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_MTMV_HSMCMI_HSMRMI_E"
    29141 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IED_DMA_PARTITION_1_E"
    29142 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_T_DMA_PARTITION_1_E"
    29143 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_C_DMA_PARTITION_1_E"
    29144 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_S_DMA_PARTITION_1_E"
    29145 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BI_DMA_PARTITION_1_E"
    29146 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_UNC_DMA_PARTITION_1_E"
    29147 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_SP_DMA_PARTITION_1_E"
    29148 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BS_DMA_PARTITION_1_E"
    29149 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_ADDR_DMA_PARTITION_1_E"
    29150 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_LPB_DMA_PARTITION_1_E"
    29151 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_MTMV_DMA_PARTITION_1_E"
    29152 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IED_CPU1_DMI_NONESAFE_E"
    29153 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_T_CPU1_DMI_NONESAFE_E"
    29154 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_C_CPU1_DMI_NONESAFE_E"
    29155 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_S_CPU1_DMI_NONESAFE_E"
    29156 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BI_CPU1_DMI_NONESAFE_E"
    29157 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_UNC_CPU1_DMI_NONESAFE_E"
    29158 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_SP_CPU1_DMI_NONESAFE_E"
    29159 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BS_CPU1_DMI_NONESAFE_E"
    29160 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU1_DMI_NONESAFE_E"
    29161 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_LPB_CPU1_DMI_NONESAFE_E"
    29162 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU1_DMI_NONESAFE_E"
    29163 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IED_CPU1_DMI_SAFE_E"
    29164 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_T_CPU1_DMI_SAFE_E"
    29165 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_C_CPU1_DMI_SAFE_E"
    29166 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_S_CPU1_DMI_SAFE_E"
    29167 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BI_CPU1_DMI_SAFE_E"
    29168 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_UNC_CPU1_DMI_SAFE_E"
    29169 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_SP_CPU1_DMI_SAFE_E"
    29170 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BS_CPU1_DMI_SAFE_E"
    29171 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU1_DMI_SAFE_E"
    29172 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_LPB_CPU1_DMI_SAFE_E"
    29173 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU1_DMI_SAFE_E"
    29174 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IED_SDMMC_E"
    29175 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_T_SDMMC_E"
    29176 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_C_SDMMC_E"
    29177 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_S_SDMMC_E"
    29178 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BI_SDMMC_E"
    29179 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_UNC_SDMMC_E"
    29180 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_SP_SDMMC_E"
    29181 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BS_SDMMC_E"
    29182 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_ADDR_SDMMC_E"
    29183 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_LPB_SDMMC_E"
    29184 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_MTMV_SDMMC_E"
    29185 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IED_DMA_PARTITION_2_E"
    29186 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_T_DMA_PARTITION_2_E"
    29187 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_C_DMA_PARTITION_2_E"
    29188 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_S_DMA_PARTITION_2_E"
    29189 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BI_DMA_PARTITION_2_E"
    29190 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_UNC_DMA_PARTITION_2_E"
    29191 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_SP_DMA_PARTITION_2_E"
    29192 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BS_DMA_PARTITION_2_E"
    29193 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_ADDR_DMA_PARTITION_2_E"
    29194 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_LPB_DMA_PARTITION_2_E"
    29195 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_MTMV_DMA_PARTITION_2_E"
    29196 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IED_CPU2_DMI_NONESAFE_E"
    29197 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_T_CPU2_DMI_NONESAFE_E"
    29198 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_C_CPU2_DMI_NONESAFE_E"
    29199 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_S_CPU2_DMI_NONESAFE_E"
    29200 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BI_CPU2_DMI_NONESAFE_E"
    29201 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_UNC_CPU2_DMI_NONESAFE_E"
    29202 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_SP_CPU2_DMI_NONESAFE_E"
    29203 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BS_CPU2_DMI_NONESAFE_E"
    29204 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU2_DMI_NONESAFE_E"
    29205 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_LPB_CPU2_DMI_NONESAFE_E"
    29206 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU2_DMI_NONESAFE_E"
    29207 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IED_CPU2_DMI_SAFE_E"
    29208 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_T_CPU2_DMI_SAFE_E"
    29209 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_C_CPU2_DMI_SAFE_E"
    29210 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_S_CPU2_DMI_SAFE_E"
    29211 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BI_CPU2_DMI_SAFE_E"
    29212 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_UNC_CPU2_DMI_SAFE_E"
    29213 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_SP_CPU2_DMI_SAFE_E"
    29214 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BS_CPU2_DMI_SAFE_E"
    29215 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU2_DMI_SAFE_E"
    29216 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_LPB_CPU2_DMI_SAFE_E"
    29217 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU2_DMI_SAFE_E"
    29218 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IED_HSSL0_E"
    29219 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_T_HSSL0_E"
    29220 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_C_HSSL0_E"
    29221 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_S_HSSL0_E"
    29222 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BI_HSSL0_E"
    29223 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_UNC_HSSL0_E"
    29224 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_SP_HSSL0_E"
    29225 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BS_HSSL0_E"
    29226 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_ADDR_HSSL0_E"
    29227 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_LPB_HSSL0_E"
    29228 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_MTMV_HSSL0_E"
    29229 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IED_DMA_PARTITION_3_E"
    29230 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_T_DMA_PARTITION_3_E"
    29231 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_C_DMA_PARTITION_3_E"
    29232 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_S_DMA_PARTITION_3_E"
    29233 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BI_DMA_PARTITION_3_E"
    29234 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_UNC_DMA_PARTITION_3_E"
    29235 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_SP_DMA_PARTITION_3_E"
    29236 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BS_DMA_PARTITION_3_E"
    29237 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_ADDR_DMA_PARTITION_3_E"
    29238 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_LPB_DMA_PARTITION_3_E"
    29239 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_MTMV_DMA_PARTITION_3_E"
    29240 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IED_CPU3_DMI_NONESAFE_E"
    29241 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_T_CPU3_DMI_NONESAFE_E"
    29242 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_C_CPU3_DMI_NONESAFE_E"
    29243 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_S_CPU3_DMI_NONESAFE_E"
    29244 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BI_CPU3_DMI_NONESAFE_E"
    29245 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_UNC_CPU3_DMI_NONESAFE_E"
    29246 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_SP_CPU3_DMI_NONESAFE_E"
    29247 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BS_CPU3_DMI_NONESAFE_E"
    29248 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU3_DMI_NONESAFE_E"
    29249 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_LPB_CPU3_DMI_NONESAFE_E"
    29250 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU3_DMI_NONESAFE_E"
    29251 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IED_CPU3_DMI_SAFE_E"
    29252 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_T_CPU3_DMI_SAFE_E"
    29253 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_C_CPU3_DMI_SAFE_E"
    29254 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_S_CPU3_DMI_SAFE_E"
    29255 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BI_CPU3_DMI_SAFE_E"
    29256 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_UNC_CPU3_DMI_SAFE_E"
    29257 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_SP_CPU3_DMI_SAFE_E"
    29258 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BS_CPU3_DMI_SAFE_E"
    29259 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU3_DMI_SAFE_E"
    29260 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_LPB_CPU3_DMI_SAFE_E"
    29261 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU3_DMI_SAFE_E"
    29262 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IED_HSSL1_E"
    29263 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_T_HSSL1_E"
    29264 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_C_HSSL1_E"
    29265 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_S_HSSL1_E"
    29266 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BI_HSSL1_E"
    29267 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_UNC_HSSL1_E"
    29268 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_SP_HSSL1_E"
    29269 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BS_HSSL1_E"
    29270 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_ADDR_HSSL1_E"
    29271 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_LPB_HSSL1_E"
    29272 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_MTMV_HSSL1_E"
    29273 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IED_CPU4_DMI_NONESAFE_E"
    29274 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_T_CPU4_DMI_NONESAFE_E"
    29275 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_C_CPU4_DMI_NONESAFE_E"
    29276 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_S_CPU4_DMI_NONESAFE_E"
    29277 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BI_CPU4_DMI_NONESAFE_E"
    29278 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_UNC_CPU4_DMI_NONESAFE_E"
    29279 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_SP_CPU4_DMI_NONESAFE_E"
    29280 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BS_CPU4_DMI_NONESAFE_E"
    29281 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU4_DMI_NONESAFE_E"
    29282 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_LPB_CPU4_DMI_NONESAFE_E"
    29283 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU4_DMI_NONESAFE_E"
    29284 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IED_CPU4_DMI_SAFE_E"
    29285 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_T_CPU4_DMI_SAFE_E"
    29286 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_C_CPU4_DMI_SAFE_E"
    29287 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_S_CPU4_DMI_SAFE_E"
    29288 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BI_CPU4_DMI_SAFE_E"
    29289 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_UNC_CPU4_DMI_SAFE_E"
    29290 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_SP_CPU4_DMI_SAFE_E"
    29291 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BS_CPU4_DMI_SAFE_E"
    29292 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU4_DMI_SAFE_E"
    29293 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_LPB_CPU4_DMI_SAFE_E"
    29294 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU4_DMI_SAFE_E"
    29295 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IED_CIF1_E"
    29296 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_T_CIF1_E"
    29297 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_C_CIF1_E"
    29298 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_S_CIF1_E"
    29299 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BI_CIF1_E"
    29300 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_UNC_CIF1_E"
    29301 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_SP_CIF1_E"
    29302 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BS_CIF1_E"
    29303 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_ADDR_CIF1_E"
    29304 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_LPB_CIF1_E"
    29305 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_MTMV_CIF1_E"
    29306 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IED_CPU5_DMI_NONESAFE_E"
    29307 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_T_CPU5_DMI_NONESAFE_E"
    29308 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_C_CPU5_DMI_NONESAFE_E"
    29309 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_S_CPU5_DMI_NONESAFE_E"
    29310 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BI_CPU5_DMI_NONESAFE_E"
    29311 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_UNC_CPU5_DMI_NONESAFE_E"
    29312 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_SP_CPU5_DMI_NONESAFE_E"
