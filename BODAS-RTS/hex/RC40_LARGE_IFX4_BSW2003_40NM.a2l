    "disable mask / Disable masks of check DFC_rbr_outK87OL"
    VALUE
    0x8080297D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK87OT_C
    "disable mask / Disable masks of check DFC_rbr_outK87OT"
    VALUE
    0x8080297E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK87SCB_C
    "disable mask / Disable masks of check DFC_rbr_outK87SCB"
    VALUE
    0x8080297F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK87SCG_C
    "disable mask / Disable masks of check DFC_rbr_outK87SCG"
    VALUE
    0x80802980
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_EventUpDownDebFault_C
    "disable mask / Disable masks of check DFC_bds_EventUpDownDebFault"
    VALUE
    0x80802981
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_DSMDummy_C
    "disable mask / Disable masks of check DFC_DSMDummy"
    VALUE
    0x80802982
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canGetDataNoBuf_C
    "disable mask / Disable masks of check DFC_rbr_canGetDataNoBuf"
    VALUE
    0x80802983
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canGetDataParam_C
    "disable mask / Disable masks of check DFC_rbr_canGetDataParam"
    VALUE
    0x80802984
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canGetDataboxNoInit_C
    "disable mask / Disable masks of check DFC_rbr_canGetDataboxNoInit"
    VALUE
    0x80802985
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canGetDataboxParam_C
    "disable mask / Disable masks of check DFC_rbr_canGetDataboxParam"
    VALUE
    0x80802986
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canGetRxBufStatusParam_C
    "disable mask / Disable masks of check DFC_rbr_canGetRxBufStatusParam"
    VALUE
    0x80802987
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canGetStatusParam_C
    "disable mask / Disable masks of check DFC_rbr_canGetStatusParam"
    VALUE
    0x80802988
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canGetTxBufStatusParam_C
    "disable mask / Disable masks of check DFC_rbr_canGetTxBufStatusParam"
    VALUE
    0x80802989
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canInitParam_C
    "disable mask / Disable masks of check DFC_rbr_canInitParam"
    VALUE
    0x8080298A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canInitRxDataboxOverlap_C
    "disable mask / Disable masks of check DFC_rbr_canInitRxDataboxOverlap"
    VALUE
    0x8080298B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canInitRxDataboxParam_C
    "disable mask / Disable masks of check DFC_rbr_canInitRxDataboxParam"
    VALUE
    0x8080298C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canInitTxDataboxParam_C
    "disable mask / Disable masks of check DFC_rbr_canInitTxDataboxParam"
    VALUE
    0x8080298D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canIpduGroupControl_C
    "disable mask / Disable masks of check DFC_rbr_canIpduGroupControl"
    VALUE
    0x8080298E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canIsDataboxFreeNoInit_C
    "disable mask / Disable masks of check DFC_rbr_canIsDataboxFreeNoInit"
    VALUE
    0x8080298F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canIsDataboxFreeParam_C
    "disable mask / Disable masks of check DFC_rbr_canIsDataboxFreeParam"
    VALUE
    0x80802990
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canIsTxEmptyParam_C
    "disable mask / Disable masks of check DFC_rbr_canIsTxEmptyParam"
    VALUE
    0x80802991
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canRegBusOffCallbInvState_C
    "disable mask / Disable masks of check DFC_rbr_canRegBusOffCallbInvState"
    VALUE
    0x80802992
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canRegBusOffCallbParam_C
    "disable mask / Disable masks of check DFC_rbr_canRegBusOffCallbParam"
    VALUE
    0x80802993
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canRegRxBufInvState_C
    "disable mask / Disable masks of check DFC_rbr_canRegRxBufInvState"
    VALUE
    0x80802994
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canRegRxBufOverlap_C
    "disable mask / Disable masks of check DFC_rbr_canRegRxBufOverlap"
    VALUE
    0x80802995
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canRegRxBufParam_C
    "disable mask / Disable masks of check DFC_rbr_canRegRxBufParam"
    VALUE
    0x80802996
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canRegRxCallbInvState_C
    "disable mask / Disable masks of check DFC_rbr_canRegRxCallbInvState"
    VALUE
    0x80802997
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canRegRxCallbParam_C
    "disable mask / Disable masks of check DFC_rbr_canRegRxCallbParam"
    VALUE
    0x80802998
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canRegRxDataboxInvNumb_C
    "disable mask / Disable masks of check DFC_rbr_canRegRxDataboxInvNumb"
    VALUE
    0x80802999
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canRegRxDataboxInvState_C
    "disable mask / Disable masks of check DFC_rbr_canRegRxDataboxInvState"
    VALUE
    0x8080299A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canRegRxDataboxOverlap_C
    "disable mask / Disable masks of check DFC_rbr_canRegRxDataboxOverlap"
    VALUE
    0x8080299B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canRegRxDataboxParam_C
    "disable mask / Disable masks of check DFC_rbr_canRegRxDataboxParam"
    VALUE
    0x8080299C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canRegTxBufInvState_C
    "disable mask / Disable masks of check DFC_rbr_canRegTxBufInvState"
    VALUE
    0x8080299D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canRegTxBufOverlap_C
    "disable mask / Disable masks of check DFC_rbr_canRegTxBufOverlap"
    VALUE
    0x8080299E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canRegTxBufParam_C
    "disable mask / Disable masks of check DFC_rbr_canRegTxBufParam"
    VALUE
    0x8080299F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canRegTxDataboxInvNumb_C
    "disable mask / Disable masks of check DFC_rbr_canRegTxDataboxInvNumb"
    VALUE
    0x808029A0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canRegTxDataboxInvState_C
    "disable mask / Disable masks of check DFC_rbr_canRegTxDataboxInvState"
    VALUE
    0x808029A1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canRegTxDataboxOverlap_C
    "disable mask / Disable masks of check DFC_rbr_canRegTxDataboxOverlap"
    VALUE
    0x808029A2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canRegTxDataboxParam_C
    "disable mask / Disable masks of check DFC_rbr_canRegTxDataboxParam"
    VALUE
    0x808029A3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canResetTxBufParam_C
    "disable mask / Disable masks of check DFC_rbr_canResetTxBufParam"
    VALUE
    0x808029A4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canSendDataBufOvfl_C
    "disable mask / Disable masks of check DFC_rbr_canSendDataBufOvfl"
    VALUE
    0x808029A5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canSendDataParam_C
    "disable mask / Disable masks of check DFC_rbr_canSendDataParam"
    VALUE
    0x808029A6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canSendDataboxNoInit_C
    "disable mask / Disable masks of check DFC_rbr_canSendDataboxNoInit"
    VALUE
    0x808029A7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canSendDataboxParam_C
    "disable mask / Disable masks of check DFC_rbr_canSendDataboxParam"
    VALUE
    0x808029A8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canSetTxCycleParam_C
    "disable mask / Disable masks of check DFC_rbr_canSetTxCycleParam"
    VALUE
    0x808029A9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canStartParam_C
    "disable mask / Disable masks of check DFC_rbr_canStartParam"
    VALUE
    0x808029AA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canStopParam_C
    "disable mask / Disable masks of check DFC_rbr_canStopParam"
    VALUE
    0x808029AB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_can_ClearIpduGroup_C
    "disable mask / Disable masks of check DFC_rbr_can_ClearIpduGroup"
    VALUE
    0x808029AC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_can_ReceiveSignal_C
    "disable mask / Disable masks of check DFC_rbr_can_ReceiveSignal"
    VALUE
    0x808029AD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_can_SendSignal_C
    "disable mask / Disable masks of check DFC_rbr_can_SendSignal"
    VALUE
    0x808029AE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_can_SetIpduGroup_C
    "disable mask / Disable masks of check DFC_rbr_can_SetIpduGroup"
    VALUE
    0x808029AF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_dsmDTCJ1939_C
    "disable mask / Disable masks of check DFC_rbr_dsmDTCJ1939"
    VALUE
    0x808029B0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_dsmDelDTCJ1939_C
    "disable mask / Disable masks of check DFC_rbr_dsmDelDTCJ1939"
    VALUE
    0x808029B1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_dsmDelErrors_C
    "disable mask / Disable masks of check DFC_rbr_dsmDelErrors"
    VALUE
    0x808029B2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_dsmGetDFES_C
    "disable mask / Disable masks of check DFC_rbr_dsmGetDFES"
    VALUE
    0x808029B3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_dsmGetDTCJ1939_C
    "disable mask / Disable masks of check DFC_rbr_dsmGetDTCJ1939"
    VALUE
    0x808029B4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_dsmGetErrors_C
    "disable mask / Disable masks of check DFC_rbr_dsmGetErrors"
    VALUE
    0x808029B5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_dsmGetNumErrors_C
    "disable mask / Disable masks of check DFC_rbr_dsmGetNumErrors"
    VALUE
    0x808029B6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_dsmInitQueueOverflow_C
    "disable mask / Disable masks of check DFC_rbr_dsmInitQueueOverflow"
    VALUE
    0x808029B7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_dsmNumDTCJ1939_C
    "disable mask / Disable masks of check DFC_rbr_dsmNumDTCJ1939"
    VALUE
    0x808029B8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_dsmTesterror_C
    "disable mask / Disable masks of check DFC_rbr_dsmTesterror"
    VALUE
    0x808029B9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_dsmUpdateDebError_C
    "disable mask / Disable masks of check DFC_rbr_dsmUpdateDebError"
    VALUE
    0x808029BA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_dsmUpdateError_C
    "disable mask / Disable masks of check DFC_rbr_dsmUpdateError"
    VALUE
    0x808029BB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_dsmgetDFCStatus_C
    "disable mask / Disable masks of check DFC_rbr_dsmgetDFCStatus"
    VALUE
    0x808029BC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_dsmtestErrorDFC_C
    "disable mask / Disable masks of check DFC_rbr_dsmtestErrorDFC"
    VALUE
    0x808029BD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inAi_C
    "disable mask / Disable masks of check DFC_rbr_inAi"
    VALUE
    0x808029BE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inAic_C
    "disable mask / Disable masks of check DFC_rbr_inAic"
    VALUE
    0x808029BF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inAicCfg_C
    "disable mask / Disable masks of check DFC_rbr_inAicCfg"
    VALUE
    0x808029C0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inAicGetStatus_C
    "disable mask / Disable masks of check DFC_rbr_inAicGetStatus"
    VALUE
    0x808029C1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inAid_C
    "disable mask / Disable masks of check DFC_rbr_inAid"
    VALUE
    0x808029C2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inAidCfg_C
    "disable mask / Disable masks of check DFC_rbr_inAidCfg"
    VALUE
    0x808029C3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inAiv_C
    "disable mask / Disable masks of check DFC_rbr_inAiv"
    VALUE
    0x808029C4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inAivCfg_C
    "disable mask / Disable masks of check DFC_rbr_inAivCfg"
    VALUE
    0x808029C5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inAivGetStatus_C
    "disable mask / Disable masks of check DFC_rbr_inAivGetStatus"
    VALUE
    0x808029C6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inDi_C
    "disable mask / Disable masks of check DFC_rbr_inDi"
    VALUE
    0x808029C7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inFi_C
    "disable mask / Disable masks of check DFC_rbr_inFi"
    VALUE
    0x808029C8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inFiCfg_C
    "disable mask / Disable masks of check DFC_rbr_inFiCfg"
    VALUE
    0x808029C9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inFiGetStatus_C
    "disable mask / Disable masks of check DFC_rbr_inFiGetStatus"
    VALUE
    0x808029CA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inFi_Buffered_C
    "disable mask / Disable masks of check DFC_rbr_inFi_Buffered"
    VALUE
    0x808029CB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inPhase_C
    "disable mask / Disable masks of check DFC_rbr_inPhase"
    VALUE
    0x808029CC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inPhaseGetStatus_C
    "disable mask / Disable masks of check DFC_rbr_inPhaseGetStatus"
    VALUE
    0x808029CD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inPhaseResetCounter_C
    "disable mask / Disable masks of check DFC_rbr_inPhaseResetCounter"
    VALUE
    0x808029CE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inRi_C
    "disable mask / Disable masks of check DFC_rbr_inRi"
    VALUE
    0x808029CF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inRiCfg_C
    "disable mask / Disable masks of check DFC_rbr_inRiCfg"
    VALUE
    0x808029D0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inRiCfgTemp_C
    "disable mask / Disable masks of check DFC_rbr_inRiCfgTemp"
    VALUE
    0x808029D1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inRiGetStatus_C
    "disable mask / Disable masks of check DFC_rbr_inRiGetStatus"
    VALUE
    0x808029D2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inRiGetTemp_C
    "disable mask / Disable masks of check DFC_rbr_inRiGetTemp"
    VALUE
    0x808029D3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inSentCopyFDFifo_C
    "disable mask / Disable masks of check DFC_rbr_inSentCopyFDFifo"
    VALUE
    0x808029D4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inSentDisable_C
    "disable mask / Disable masks of check DFC_rbr_inSentDisable"
    VALUE
    0x808029D5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inSentEnable_C
    "disable mask / Disable masks of check DFC_rbr_inSentEnable"
    VALUE
    0x808029D6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inSentGetErrorStatus_C
    "disable mask / Disable masks of check DFC_rbr_inSentGetErrorStatus"
    VALUE
    0x808029D7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inSentGetFD_C
    "disable mask / Disable masks of check DFC_rbr_inSentGetFD"
    VALUE
    0x808029D8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inSentGetSD_C
    "disable mask / Disable masks of check DFC_rbr_inSentGetSD"
    VALUE
    0x808029D9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inSentGetSDDatabox_C
    "disable mask / Disable masks of check DFC_rbr_inSentGetSDDatabox"
    VALUE
    0x808029DA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inSentGetStatus_C
    "disable mask / Disable masks of check DFC_rbr_inSentGetStatus"
    VALUE
    0x808029DB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inSentInitSDDatabox_C
    "disable mask / Disable masks of check DFC_rbr_inSentInitSDDatabox"
    VALUE
    0x808029DC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inSentRegisterCopyFDFifo_C
    "disable mask / Disable masks of check DFC_rbr_inSentRegisterCopyFDFifo"
    VALUE
    0x808029DD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inSentRegisterFDFifo_C
    "disable mask / Disable masks of check DFC_rbr_inSentRegisterFDFifo"
    VALUE
    0x808029DE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inSentRegisterSDDataboxes_C
    "disable mask / Disable masks of check DFC_rbr_inSentRegisterSDDataboxes"
    VALUE
    0x808029DF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_isobusCanRxBufferOverflow_C
    "disable mask / Disable masks of check DFC_rbr_isobusCanRxBufferOverflow"
    VALUE
    0x808029E0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_isobusGetCaAddrParam_C
    "disable mask / Disable masks of check DFC_rbr_isobusGetCaAddrParam"
    VALUE
    0x808029E1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_isobusGetDiagnosticParam_C
    "disable mask / Disable masks of check DFC_rbr_isobusGetDiagnosticParam"
    VALUE
    0x808029E2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_isobusGetRxDataboxStatusParam_C
    "disable mask / Disable masks of check DFC_rbr_isobusGetRxDataboxStatusParam"
    VALUE
    0x808029E3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_isobusGetStatusParam_C
    "disable mask / Disable masks of check DFC_rbr_isobusGetStatusParam"
    VALUE
    0x808029E4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_isobusInitCommCaMissing_C
    "disable mask / Disable masks of check DFC_rbr_isobusInitCommCaMissing"
    VALUE
    0x808029E5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_isobusInitCommParam_C
    "disable mask / Disable masks of check DFC_rbr_isobusInitCommParam"
    VALUE
    0x808029E6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_isobusInitCommState_C
    "disable mask / Disable masks of check DFC_rbr_isobusInitCommState"
    VALUE
    0x808029E7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_isobusInitDiagnosticParam_C
    "disable mask / Disable masks of check DFC_rbr_isobusInitDiagnosticParam"
    VALUE
    0x808029E8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_isobusInitFailureListParam_C
    "disable mask / Disable masks of check DFC_rbr_isobusInitFailureListParam"
    VALUE
    0x808029E9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_isobusInitRxDataboxParam_C
    "disable mask / Disable masks of check DFC_rbr_isobusInitRxDataboxParam"
    VALUE
    0x808029EA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_isobusInitTxDataboxParam_C
    "disable mask / Disable masks of check DFC_rbr_isobusInitTxDataboxParam"
    VALUE
    0x808029EB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_isobusRegRxDataboxOverlap_C
    "disable mask / Disable masks of check DFC_rbr_isobusRegRxDataboxOverlap"
    VALUE
    0x808029EC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_isobusRegRxDataboxParam_C
    "disable mask / Disable masks of check DFC_rbr_isobusRegRxDataboxParam"
    VALUE
    0x808029ED
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_isobusRegRxDataboxState_C
    "disable mask / Disable masks of check DFC_rbr_isobusRegRxDataboxState"
    VALUE
    0x808029EE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_isobusRegTxDataboxOverlap_C
    "disable mask / Disable masks of check DFC_rbr_isobusRegTxDataboxOverlap"
    VALUE
    0x808029EF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_isobusRegTxDataboxParam_C
    "disable mask / Disable masks of check DFC_rbr_isobusRegTxDataboxParam"
    VALUE
    0x808029F0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_isobusRegTxDataboxState_C
    "disable mask / Disable masks of check DFC_rbr_isobusRegTxDataboxState"
    VALUE
    0x808029F1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_isobusRegisterErrClrCallbackParam_C
    "disable mask / Disable masks of check DFC_rbr_isobusRegisterErrClrCallbackParam"
    VALUE
    0x808029F2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_isobusRegisterInstancesOverlap_C
    "disable mask / Disable masks of check DFC_rbr_isobusRegisterInstancesOverlap"
    VALUE
    0x808029F3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_isobusRegisterInstancesParam_C
    "disable mask / Disable masks of check DFC_rbr_isobusRegisterInstancesParam"
    VALUE
    0x808029F4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_isobusRegisterInstancesState_C
    "disable mask / Disable masks of check DFC_rbr_isobusRegisterInstancesState"
    VALUE
    0x808029F5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_isobusSendDataboxParam_C
    "disable mask / Disable masks of check DFC_rbr_isobusSendDataboxParam"
    VALUE
    0x808029F6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_isobusSendRequestPGNParam_C
    "disable mask / Disable masks of check DFC_rbr_isobusSendRequestPGNParam"
    VALUE
    0x808029F7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_isobusSetCaAddrCaUsed_C
    "disable mask / Disable masks of check DFC_rbr_isobusSetCaAddrCaUsed"
    VALUE
    0x808029F8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_isobusSetCaAddrComm_C
    "disable mask / Disable masks of check DFC_rbr_isobusSetCaAddrComm"
    VALUE
    0x808029F9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_isobusSetCaAddrInvCan_C
    "disable mask / Disable masks of check DFC_rbr_isobusSetCaAddrInvCan"
    VALUE
    0x808029FA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_isobusSetCaAddrParam_C
    "disable mask / Disable masks of check DFC_rbr_isobusSetCaAddrParam"
    VALUE
    0x808029FB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_isobusSetCaInfoParam_C
    "disable mask / Disable masks of check DFC_rbr_isobusSetCaInfoParam"
    VALUE
    0x808029FC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_isobusSetCaNameParam_C
    "disable mask / Disable masks of check DFC_rbr_isobusSetCaNameParam"
    VALUE
    0x808029FD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_isobusSftyCanTxErr_C
    "disable mask / Disable masks of check DFC_rbr_isobusSftyCanTxErr"
    VALUE
    0x808029FE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_lin_ReceiveSignal_C
    "disable mask / Disable masks of check DFC_rbr_lin_ReceiveSignal"
    VALUE
    0x808029FF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_lin_SendSignal_C
    "disable mask / Disable masks of check DFC_rbr_lin_SendSignal"
    VALUE
    0x80802A00
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_lin_getStatus_C
    "disable mask / Disable masks of check DFC_rbr_lin_getStatus"
    VALUE
    0x80802A01
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_lin_gotoSleep_C
    "disable mask / Disable masks of check DFC_rbr_lin_gotoSleep"
    VALUE
    0x80802A02
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_lin_scheduleRequest_C
    "disable mask / Disable masks of check DFC_rbr_lin_scheduleRequest"
    VALUE
    0x80802A03
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_lin_wakeUp_C
    "disable mask / Disable masks of check DFC_rbr_lin_wakeUp"
    VALUE
    0x80802A04
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_memFlsCfgShr_C
    "disable mask / Disable masks of check DFC_rbr_memFlsCfgShr"
    VALUE
    0x80802A05
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_memGetStatus_C
    "disable mask / Disable masks of check DFC_rbr_memGetStatus"
    VALUE
    0x80802A06
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_memMarkBlock_C
    "disable mask / Disable masks of check DFC_rbr_memMarkBlock"
    VALUE
    0x80802A07
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_memReadApi1Error_C
    "disable mask / Disable masks of check DFC_rbr_memReadApi1Error"
    VALUE
    0x80802A08
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_memReadApi2Error_C
    "disable mask / Disable masks of check DFC_rbr_memReadApi2Error"
    VALUE
    0x80802A09
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_memReadBlock_C
    "disable mask / Disable masks of check DFC_rbr_memReadBlock"
    VALUE
    0x80802A0A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_memReadCalibInputError_C
    "disable mask / Disable masks of check DFC_rbr_memReadCalibInputError"
    VALUE
    0x80802A0B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_memReadCalibOuputError_C
    "disable mask / Disable masks of check DFC_rbr_memReadCalibOuputError"
    VALUE
    0x80802A0C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_memReadSystemError_C
    "disable mask / Disable masks of check DFC_rbr_memReadSystemError"
    VALUE
    0x80802A0D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_memWriteBlock_C
    "disable mask / Disable masks of check DFC_rbr_memWriteBlock"
    VALUE
    0x80802A0E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_moOV_FirstConstADC_C
    "disable mask / Disable masks of check DFC_rbr_moOV_FirstConstADC"
    VALUE
    0x80802A0F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_moOV_SecondConstADC_C
    "disable mask / Disable masks of check DFC_rbr_moOV_SecondConstADC"
    VALUE
    0x80802A10
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_moUV_FirstConstADC_C
    "disable mask / Disable masks of check DFC_rbr_moUV_FirstConstADC"
    VALUE
    0x80802A11
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_moUV_SecondConstADC_C
    "disable mask / Disable masks of check DFC_rbr_moUV_SecondConstADC"
    VALUE
    0x80802A12
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_INH_C
    "disable mask / Disable masks of check DFC_rbr_mo_INH"
    VALUE
    0x80802A13
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_INHLatch_C
    "disable mask / Disable masks of check DFC_rbr_mo_INHLatch"
    VALUE
    0x80802A14
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_adcPDD_fail_C
    "disable mask / Disable masks of check DFC_rbr_mo_adcPDD_fail"
    VALUE
    0x80802A15
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_memoryProtection_err_C
    "disable mask / Disable masks of check DFC_rbr_mo_memoryProtection_err"
    VALUE
    0x80802A16
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA02OC_C
    "disable mask / Disable masks of check DFC_rbr_outA02OC"
    VALUE
    0x80802A17
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA02Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outA02Unintended"
    VALUE
    0x80802A18
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA03OC_C
    "disable mask / Disable masks of check DFC_rbr_outA03OC"
    VALUE
    0x80802A19
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA03Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outA03Unintended"
    VALUE
    0x80802A1A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA04OC_C
    "disable mask / Disable masks of check DFC_rbr_outA04OC"
    VALUE
    0x80802A1B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA04Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outA04Unintended"
    VALUE
    0x80802A1C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA05OC_C
    "disable mask / Disable masks of check DFC_rbr_outA05OC"
    VALUE
    0x80802A1D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA05Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outA05Unintended"
    VALUE
    0x80802A1E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA07OC_C
    "disable mask / Disable masks of check DFC_rbr_outA07OC"
    VALUE
    0x80802A1F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA07Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outA07Unintended"
    VALUE
    0x80802A20
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA08OC_C
    "disable mask / Disable masks of check DFC_rbr_outA08OC"
    VALUE
    0x80802A21
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA08Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outA08Unintended"
    VALUE
    0x80802A22
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA09OC_C
    "disable mask / Disable masks of check DFC_rbr_outA09OC"
    VALUE
    0x80802A23
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA09Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outA09Unintended"
    VALUE
    0x80802A24
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA10OC_C
    "disable mask / Disable masks of check DFC_rbr_outA10OC"
    VALUE
    0x80802A25
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA10Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outA10Unintended"
    VALUE
    0x80802A26
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA17OC_C
    "disable mask / Disable masks of check DFC_rbr_outA17OC"
    VALUE
    0x80802A27
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA17Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outA17Unintended"
    VALUE
    0x80802A28
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA18OC_C
    "disable mask / Disable masks of check DFC_rbr_outA18OC"
    VALUE
    0x80802A29
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA18Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outA18Unintended"
    VALUE
    0x80802A2A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA19OC_C
    "disable mask / Disable masks of check DFC_rbr_outA19OC"
    VALUE
    0x80802A2B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA19Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outA19Unintended"
    VALUE
    0x80802A2C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA20OC_C
    "disable mask / Disable masks of check DFC_rbr_outA20OC"
    VALUE
    0x80802A2D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA20Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outA20Unintended"
    VALUE
    0x80802A2E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA31OC_C
    "disable mask / Disable masks of check DFC_rbr_outA31OC"
    VALUE
    0x80802A2F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA31Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outA31Unintended"
    VALUE
    0x80802A30
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA32OC_C
    "disable mask / Disable masks of check DFC_rbr_outA32OC"
    VALUE
    0x80802A31
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA32Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outA32Unintended"
    VALUE
    0x80802A32
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA33OC_C
    "disable mask / Disable masks of check DFC_rbr_outA33OC"
    VALUE
    0x80802A33
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA33Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outA33Unintended"
    VALUE
    0x80802A34
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA34OC_C
    "disable mask / Disable masks of check DFC_rbr_outA34OC"
    VALUE
    0x80802A35
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA34Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outA34Unintended"
    VALUE
    0x80802A36
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA35OC_C
    "disable mask / Disable masks of check DFC_rbr_outA35OC"
    VALUE
    0x80802A37
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA35Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outA35Unintended"
    VALUE
    0x80802A38
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA46OC_C
    "disable mask / Disable masks of check DFC_rbr_outA46OC"
    VALUE
    0x80802A39
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA46Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outA46Unintended"
    VALUE
    0x80802A3A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA47OC_C
    "disable mask / Disable masks of check DFC_rbr_outA47OC"
    VALUE
    0x80802A3B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA47Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outA47Unintended"
    VALUE
    0x80802A3C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA48OC_C
    "disable mask / Disable masks of check DFC_rbr_outA48OC"
    VALUE
    0x80802A3D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA48Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outA48Unintended"
    VALUE
    0x80802A3E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA51OC_C
    "disable mask / Disable masks of check DFC_rbr_outA51OC"
    VALUE
    0x80802A3F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA51Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outA51Unintended"
    VALUE
    0x80802A40
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA52OC_C
    "disable mask / Disable masks of check DFC_rbr_outA52OC"
    VALUE
    0x80802A41
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA52Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outA52Unintended"
    VALUE
    0x80802A42
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA53OC_C
    "disable mask / Disable masks of check DFC_rbr_outA53OC"
    VALUE
    0x80802A43
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA53Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outA53Unintended"
    VALUE
    0x80802A44
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA54OC_C
    "disable mask / Disable masks of check DFC_rbr_outA54OC"
    VALUE
    0x80802A45
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA54Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outA54Unintended"
    VALUE
    0x80802A46
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outAov_C
    "disable mask / Disable masks of check DFC_rbr_outAov"
    VALUE
    0x80802A47
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outAovCfg_C
    "disable mask / Disable masks of check DFC_rbr_outAovCfg"
    VALUE
    0x80802A48
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outAovCfgPI_C
    "disable mask / Disable masks of check DFC_rbr_outAovCfgPI"
    VALUE
    0x80802A49
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outAovGetStatus_C
    "disable mask / Disable masks of check DFC_rbr_outAovGetStatus"
    VALUE
    0x80802A4A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outAovGetVoltage_C
    "disable mask / Disable masks of check DFC_rbr_outAovGetVoltage"
    VALUE
    0x80802A4B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outAovResetError_C
    "disable mask / Disable masks of check DFC_rbr_outAovResetError"
    VALUE
    0x80802A4C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outDo_C
    "disable mask / Disable masks of check DFC_rbr_outDo"
    VALUE
    0x80802A4D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outDoCfgPwrLs_C
    "disable mask / Disable masks of check DFC_rbr_outDoCfgPwrLs"
    VALUE
    0x80802A4E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outDoDisable_C
    "disable mask / Disable masks of check DFC_rbr_outDoDisable"
    VALUE
    0x80802A4F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outDoGetCurrent_C
    "disable mask / Disable masks of check DFC_rbr_outDoGetCurrent"
    VALUE
    0x80802A50
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outDoGetStatus_C
    "disable mask / Disable masks of check DFC_rbr_outDoGetStatus"
    VALUE
    0x80802A51
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outDoResetError_C
    "disable mask / Disable masks of check DFC_rbr_outDoResetError"
    VALUE
    0x80802A52
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK07OC_C
    "disable mask / Disable masks of check DFC_rbr_outK07OC"
    VALUE
    0x80802A53
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK07Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outK07Unintended"
    VALUE
    0x80802A54
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK08OC_C
    "disable mask / Disable masks of check DFC_rbr_outK08OC"
    VALUE
    0x80802A55
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK08Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outK08Unintended"
    VALUE
    0x80802A56
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK09OC_C
    "disable mask / Disable masks of check DFC_rbr_outK09OC"
    VALUE
    0x80802A57
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK09Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outK09Unintended"
    VALUE
    0x80802A58
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK12OC_C
    "disable mask / Disable masks of check DFC_rbr_outK12OC"
    VALUE
    0x80802A59
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK12Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outK12Unintended"
    VALUE
    0x80802A5A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK13OC_C
    "disable mask / Disable masks of check DFC_rbr_outK13OC"
    VALUE
    0x80802A5B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK13Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outK13Unintended"
    VALUE
    0x80802A5C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK14OC_C
    "disable mask / Disable masks of check DFC_rbr_outK14OC"
    VALUE
    0x80802A5D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK14Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outK14Unintended"
    VALUE
    0x80802A5E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK15OC_C
    "disable mask / Disable masks of check DFC_rbr_outK15OC"
    VALUE
    0x80802A5F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK15Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outK15Unintended"
    VALUE
    0x80802A60
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK16OC_C
    "disable mask / Disable masks of check DFC_rbr_outK16OC"
    VALUE
    0x80802A61
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK16Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outK16Unintended"
    VALUE
    0x80802A62
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK17OC_C
    "disable mask / Disable masks of check DFC_rbr_outK17OC"
    VALUE
    0x80802A63
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK17Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outK17Unintended"
    VALUE
    0x80802A64
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK29OC_C
    "disable mask / Disable masks of check DFC_rbr_outK29OC"
    VALUE
    0x80802A65
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK29Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outK29Unintended"
    VALUE
    0x80802A66
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK51OC_C
    "disable mask / Disable masks of check DFC_rbr_outK51OC"
    VALUE
    0x80802A67
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK51Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outK51Unintended"
    VALUE
    0x80802A68
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK73OC_C
    "disable mask / Disable masks of check DFC_rbr_outK73OC"
    VALUE
    0x80802A69
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK73Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outK73Unintended"
    VALUE
    0x80802A6A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outPo_C
    "disable mask / Disable masks of check DFC_rbr_outPo"
    VALUE
    0x80802A6B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outPoCfg_C
    "disable mask / Disable masks of check DFC_rbr_outPoCfg"
    VALUE
    0x80802A6C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outPoCfgPeriod_C
    "disable mask / Disable masks of check DFC_rbr_outPoCfgPeriod"
    VALUE
    0x80802A6D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outPoCfgPwrLs_C
    "disable mask / Disable masks of check DFC_rbr_outPoCfgPwrLs"
    VALUE
    0x80802A6E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outPoDisable_C
    "disable mask / Disable masks of check DFC_rbr_outPoDisable"
    VALUE
    0x80802A6F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outPoGetCurrent_C
    "disable mask / Disable masks of check DFC_rbr_outPoGetCurrent"
    VALUE
    0x80802A70
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outPoGetStatus_C
    "disable mask / Disable masks of check DFC_rbr_outPoGetStatus"
    VALUE
    0x80802A71
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outPoResetError_C
    "disable mask / Disable masks of check DFC_rbr_outPoResetError"
    VALUE
    0x80802A72
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outPoc_C
    "disable mask / Disable masks of check DFC_rbr_outPoc"
    VALUE
    0x80802A73
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outPocCfg_C
    "disable mask / Disable masks of check DFC_rbr_outPocCfg"
    VALUE
    0x80802A74
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outPocCfgDither_C
    "disable mask / Disable masks of check DFC_rbr_outPocCfgDither"
    VALUE
    0x80802A75
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outPocCfgPI_C
    "disable mask / Disable masks of check DFC_rbr_outPocCfgPI"
    VALUE
    0x80802A76
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outPod_C
    "disable mask / Disable masks of check DFC_rbr_outPod"
    VALUE
    0x80802A77
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outPodCfg_C
    "disable mask / Disable masks of check DFC_rbr_outPodCfg"
    VALUE
    0x80802A78
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outPodCfgPeriod_C
    "disable mask / Disable masks of check DFC_rbr_outPodCfgPeriod"
    VALUE
    0x80802A79
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_rsmFfiApiCallErr_C
    "disable mask / Disable masks of check DFC_rbr_rsmFfiApiCallErr"
    VALUE
    0x80802A7A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safout_C
    "disable mask / Disable masks of check DFC_rbr_safout"
    VALUE
    0x80802A7B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutCfg_C
    "disable mask / Disable masks of check DFC_rbr_safoutCfg"
    VALUE
    0x80802A7C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl1_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl1"
    VALUE
    0x80802A7D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl10_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl10"
    VALUE
    0x80802A7E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl10Dev_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl10Dev"
    VALUE
    0x80802A7F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl10OR_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl10OR"
    VALUE
    0x80802A80
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl11_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl11"
    VALUE
    0x80802A81
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl11Dev_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl11Dev"
    VALUE
    0x80802A82
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl11OR_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl11OR"
    VALUE
    0x80802A83
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl12_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl12"
    VALUE
    0x80802A84
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl12Dev_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl12Dev"
    VALUE
    0x80802A85
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl12OR_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl12OR"
    VALUE
    0x80802A86
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl13_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl13"
    VALUE
    0x80802A87
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl13Dev_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl13Dev"
    VALUE
    0x80802A88
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl13OR_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl13OR"
    VALUE
    0x80802A89
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl14_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl14"
    VALUE
    0x80802A8A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl14Dev_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl14Dev"
    VALUE
    0x80802A8B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl14OR_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl14OR"
    VALUE
    0x80802A8C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl15_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl15"
    VALUE
    0x80802A8D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl15Dev_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl15Dev"
    VALUE
    0x80802A8E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl15OR_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl15OR"
    VALUE
    0x80802A8F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl16_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl16"
    VALUE
    0x80802A90
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl16Dev_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl16Dev"
    VALUE
    0x80802A91
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl16OR_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl16OR"
    VALUE
    0x80802A92
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl17_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl17"
    VALUE
    0x80802A93
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl17Dev_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl17Dev"
    VALUE
    0x80802A94
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl17OR_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl17OR"
    VALUE
    0x80802A95
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl18_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl18"
    VALUE
    0x80802A96
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl18Dev_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl18Dev"
    VALUE
    0x80802A97
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl18OR_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl18OR"
    VALUE
    0x80802A98
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl1Dev_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl1Dev"
    VALUE
    0x80802A99
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl1OR_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl1OR"
    VALUE
    0x80802A9A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl2_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl2"
    VALUE
    0x80802A9B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl2Dev_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl2Dev"
    VALUE
    0x80802A9C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl2OR_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl2OR"
    VALUE
    0x80802A9D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl3_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl3"
    VALUE
    0x80802A9E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl3Dev_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl3Dev"
    VALUE
    0x80802A9F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl3OR_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl3OR"
    VALUE
    0x80802AA0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl4_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl4"
    VALUE
    0x80802AA1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl4Dev_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl4Dev"
    VALUE
    0x80802AA2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl4OR_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl4OR"
    VALUE
    0x80802AA3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl5_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl5"
    VALUE
    0x80802AA4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl5Dev_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl5Dev"
    VALUE
    0x80802AA5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl5OR_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl5OR"
    VALUE
    0x80802AA6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl6_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl6"
    VALUE
    0x80802AA7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl6Dev_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl6Dev"
    VALUE
    0x80802AA8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl6OR_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl6OR"
    VALUE
    0x80802AA9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl7_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl7"
    VALUE
    0x80802AAA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl7Dev_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl7Dev"
    VALUE
    0x80802AAB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl7OR_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl7OR"
    VALUE
    0x80802AAC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl8_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl8"
    VALUE
    0x80802AAD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl8Dev_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl8Dev"
    VALUE
    0x80802AAE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl8OR_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl8OR"
    VALUE
    0x80802AAF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl9_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl9"
    VALUE
    0x80802AB0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl9Dev_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl9Dev"
    VALUE
    0x80802AB1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl9OR_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl9OR"
    VALUE
    0x80802AB2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutDevError_C
    "disable mask / Disable masks of check DFC_rbr_safoutDevError"
    VALUE
    0x80802AB3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutGetStatus_C
    "disable mask / Disable masks of check DFC_rbr_safoutGetStatus"
    VALUE
    0x80802AB4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutIgnoreError_C
    "disable mask / Disable masks of check DFC_rbr_safoutIgnoreError"
    VALUE
    0x80802AB5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutResetError_C
    "disable mask / Disable masks of check DFC_rbr_safoutResetError"
    VALUE
    0x80802AB6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutUnlock_C
    "disable mask / Disable masks of check DFC_rbr_safoutUnlock"
    VALUE
    0x80802AB7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safout_cfgDiag_C
    "disable mask / Disable masks of check DFC_rbr_safout_cfgDiag"
    VALUE
    0x80802AB8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_secAccessDenied_RC_C
    "disable mask / Disable masks of check DFC_rbr_secAccessDenied_RC"
    VALUE
    0x80802AB9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_secAccessDenied_WDBI_C
    "disable mask / Disable masks of check DFC_rbr_secAccessDenied_WDBI"
    VALUE
    0x80802ABA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_secEvalRespKey_C
    "disable mask / Disable masks of check DFC_rbr_secEvalRespKey"
    VALUE
    0x80802ABB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_secFlashingFailure_C
    "disable mask / Disable masks of check DFC_rbr_secFlashingFailure"
    VALUE
    0x80802ABC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_secGetLevel_C
    "disable mask / Disable masks of check DFC_rbr_secGetLevel"
    VALUE
    0x80802ABD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_secGetRnd_C
    "disable mask / Disable masks of check DFC_rbr_secGetRnd"
    VALUE
    0x80802ABE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_secGetSeed_C
    "disable mask / Disable masks of check DFC_rbr_secGetSeed"
    VALUE
    0x80802ABF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_secInvalidPassword_C
    "disable mask / Disable masks of check DFC_rbr_secInvalidPassword"
    VALUE
    0x80802AC0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_secIsRequestAllowed_C
    "disable mask / Disable masks of check DFC_rbr_secIsRequestAllowed"
    VALUE
    0x80802AC1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_secResetLevel_C
    "disable mask / Disable masks of check DFC_rbr_secResetLevel"
    VALUE
    0x80802AC2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_secSaveSecret_C
    "disable mask / Disable masks of check DFC_rbr_secSaveSecret"
    VALUE
    0x80802AC3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_secSetLevel_C
    "disable mask / Disable masks of check DFC_rbr_secSetLevel"
    VALUE
    0x80802AC4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_sysAit_C
    "disable mask / Disable masks of check DFC_rbr_sysAit"
    VALUE
    0x80802AC5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_sysAiv_C
    "disable mask / Disable masks of check DFC_rbr_sysAiv"
    VALUE
    0x80802AC6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_sysDi_C
    "disable mask / Disable masks of check DFC_rbr_sysDi"
    VALUE
    0x80802AC7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_sysDo_C
    "disable mask / Disable masks of check DFC_rbr_sysDo"
    VALUE
    0x80802AC8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_sysGetVss_C
    "disable mask / Disable masks of check DFC_rbr_sysGetVss"
    VALUE
    0x80802AC9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_sysInit_C
    "disable mask / Disable masks of check DFC_rbr_sysInit"
    VALUE
    0x80802ACA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_sysOperHrIntegrityErr_C
    "disable mask / Disable masks of check DFC_rbr_sysOperHrIntegrityErr"
    VALUE
    0x80802ACB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_sysOperHrsSaturated_C
    "disable mask / Disable masks of check DFC_rbr_sysOperHrsSaturated"
    VALUE
    0x80802ACC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_sysSetVss_C
    "disable mask / Disable masks of check DFC_rbr_sysSetVss"
    VALUE
    0x80802ACD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_sys_coreload_C
    "disable mask / Disable masks of check DFC_rbr_sys_coreload"
    VALUE
    0x80802ACE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_sys_taskload_C
    "disable mask / Disable masks of check DFC_rbr_sys_taskload"
    VALUE
    0x80802ACF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_OV_VSS1_C
    "disable mask / Disable masks of check DFC_rbr_mo_OV_VSS1"
    VALUE
    0x80802AD0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_OV_VSS2_C
    "disable mask / Disable masks of check DFC_rbr_mo_OV_VSS2"
    VALUE
    0x80802AD1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_UV_VSS1_C
    "disable mask / Disable masks of check DFC_rbr_mo_UV_VSS1"
    VALUE
    0x80802AD2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_UV_VSS2_C
    "disable mask / Disable masks of check DFC_rbr_mo_UV_VSS2"
    VALUE
    0x80802AD3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_CANSM_E_BUS_OFF_NETWORK_0_C
    "disable mask / Disable masks of check DFC_CANSM_E_BUS_OFF_NETWORK_0"
    VALUE
    0x80802AD4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_CANSM_E_BUS_OFF_NETWORK_1_C
    "disable mask / Disable masks of check DFC_CANSM_E_BUS_OFF_NETWORK_1"
    VALUE
    0x80802AD5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_CANSM_E_BUS_OFF_NETWORK_2_C
    "disable mask / Disable masks of check DFC_CANSM_E_BUS_OFF_NETWORK_2"
    VALUE
    0x80802AD6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_CANSM_E_BUS_OFF_NETWORK_3_C
    "disable mask / Disable masks of check DFC_CANSM_E_BUS_OFF_NETWORK_3"
    VALUE
    0x80802AD7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_CANTRCV_E_NO_TRCV_CONTROL_0_C
    "disable mask / Disable masks of check DFC_CANTRCV_E_NO_TRCV_CONTROL_0"
    VALUE
    0x80802AD8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_CAN_E_TIMEOUT_C
    "disable mask / Disable masks of check DFC_CAN_E_TIMEOUT"
    VALUE
    0x80802AD9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_COMM_E_NET_START_IND_CHANNEL_0_C
    "disable mask / Disable masks of check DFC_COMM_E_NET_START_IND_CHANNEL_0"
    VALUE
    0x80802ADA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_COMM_E_NET_START_IND_CHANNEL_1_C
    "disable mask / Disable masks of check DFC_COMM_E_NET_START_IND_CHANNEL_1"
    VALUE
    0x80802ADB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_COMM_E_NET_START_IND_CHANNEL_2_C
    "disable mask / Disable masks of check DFC_COMM_E_NET_START_IND_CHANNEL_2"
    VALUE
    0x80802ADC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_COMM_E_NET_START_IND_CHANNEL_3_C
    "disable mask / Disable masks of check DFC_COMM_E_NET_START_IND_CHANNEL_3"
    VALUE
    0x80802ADD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_COMM_E_NET_START_IND_CHANNEL_4_C
    "disable mask / Disable masks of check DFC_COMM_E_NET_START_IND_CHANNEL_4"
    VALUE
    0x80802ADE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_COMM_E_NET_START_IND_CHANNEL_5_C
    "disable mask / Disable masks of check DFC_COMM_E_NET_START_IND_CHANNEL_5"
    VALUE
    0x80802ADF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_LIN_E_TIMEOUT_C
    "disable mask / Disable masks of check DFC_LIN_E_TIMEOUT"
    VALUE
    0x80802AE0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rba_MultiStackTrace_Threshold_C
    "disable mask / Disable masks of check DFC_rba_MultiStackTrace_Threshold"
    VALUE
    0x80802AE1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_ETH_E_ACCESS_0_C
    "disable mask / Disable masks of check DFC_ETH_E_ACCESS_0"
    VALUE
    0x80802AE2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_RBA_IOEXTLIB_KEEPALIVE_DRV_C
    "disable mask / Disable masks of check DFC_RBA_IOEXTLIB_KEEPALIVE_DRV"
    VALUE
    0x80802AE3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_RBA_IOEXTLIB_KEEPALIVE_INI_C
    "disable mask / Disable masks of check DFC_RBA_IOEXTLIB_KEEPALIVE_INI"
    VALUE
    0x80802AE4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rba_MRly_Diag_Stk_Event_C
    "disable mask / Disable masks of check DFC_rba_MRly_Diag_Stk_Event"
    VALUE
    0x80802AE5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rba_MemDiagExtd_MemReadSngErr_C
    "disable mask / Disable masks of check DFC_rba_MemDiagExtd_MemReadSngErr"
    VALUE
    0x80802AE6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rba_MemDiag_MemReadErr_C
    "disable mask / Disable masks of check DFC_rba_MemDiag_MemReadErr"
    VALUE
    0x80802AE7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rba_MemDiag_MemWrErr_C
    "disable mask / Disable masks of check DFC_rba_MemDiag_MemWrErr"
    VALUE
    0x80802AE8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rba_SyC_IrrSwOffTrigEngRun_Event_C
    "disable mask / Disable masks of check DFC_rba_SyC_IrrSwOffTrigEngRun_Event"
    VALUE
    0x80802AE9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rba_T15_Diag_ComInVld_Event_C
    "disable mask / Disable masks of check DFC_rba_T15_Diag_ComInVld_Event"
    VALUE
    0x80802AEA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rba_T15_Diag_ComOff_HwOn_Event_C
    "disable mask / Disable masks of check DFC_rba_T15_Diag_ComOff_HwOn_Event"
    VALUE
    0x80802AEB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rba_T15_Diag_ComOn_HwOff_Event_C
    "disable mask / Disable masks of check DFC_rba_T15_Diag_ComOn_HwOff_Event"
    VALUE
    0x80802AEC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM0_0_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM0_0"
    VALUE
    0x80802AED
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM0_1_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM0_1"
    VALUE
    0x80802AEE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM0_10_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM0_10"
    VALUE
    0x80802AEF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM0_11_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM0_11"
    VALUE
    0x80802AF0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM0_13_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM0_13"
    VALUE
    0x80802AF1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM0_14_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM0_14"
    VALUE
    0x80802AF2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM0_2_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM0_2"
    VALUE
    0x80802AF3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM0_22_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM0_22"
    VALUE
    0x80802AF4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM0_23_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM0_23"
    VALUE
    0x80802AF5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM0_4_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM0_4"
    VALUE
    0x80802AF6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM0_5_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM0_5"
    VALUE
    0x80802AF7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM0_7_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM0_7"
    VALUE
    0x80802AF8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM0_8_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM0_8"
    VALUE
    0x80802AF9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM10_16_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM10_16"
    VALUE
    0x80802AFA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM10_17_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM10_17"
    VALUE
    0x80802AFB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM10_21_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM10_21"
    VALUE
    0x80802AFC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM11_0_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM11_0"
    VALUE
    0x80802AFD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM11_1_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM11_1"
    VALUE
    0x80802AFE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM11_2_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM11_2"
    VALUE
    0x80802AFF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM11_3_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM11_3"
    VALUE
    0x80802B00
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM11_4_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM11_4"
    VALUE
    0x80802B01
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM11_5_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM11_5"
    VALUE
    0x80802B02
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM11_8_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM11_8"
    VALUE
    0x80802B03
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM11_9_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM11_9"
    VALUE
    0x80802B04
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM1_0_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM1_0"
    VALUE
    0x80802B05
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM1_1_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM1_1"
    VALUE
    0x80802B06
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM1_10_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM1_10"
    VALUE
    0x80802B07
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM1_11_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM1_11"
    VALUE
    0x80802B08
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM1_13_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM1_13"
    VALUE
    0x80802B09
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM1_14_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM1_14"
    VALUE
    0x80802B0A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM1_2_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM1_2"
    VALUE
    0x80802B0B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM1_22_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM1_22"
    VALUE
    0x80802B0C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM1_23_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM1_23"
    VALUE
    0x80802B0D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM1_4_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM1_4"
    VALUE
    0x80802B0E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM1_5_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM1_5"
    VALUE
    0x80802B0F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM1_7_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM1_7"
    VALUE
    0x80802B10
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM1_8_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM1_8"
    VALUE
    0x80802B11
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM21_0_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM21_0"
    VALUE
    0x80802B12
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM21_16_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM21_16"
    VALUE
    0x80802B13
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM21_3_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM21_3"
    VALUE
    0x80802B14
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM2_1_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM2_1"
    VALUE
    0x80802B15
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM2_10_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM2_10"
    VALUE
    0x80802B16
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM2_11_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM2_11"
    VALUE
    0x80802B17
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM2_13_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM2_13"
    VALUE
    0x80802B18
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM2_14_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM2_14"
    VALUE
    0x80802B19
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM2_2_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM2_2"
    VALUE
    0x80802B1A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM2_22_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM2_22"
    VALUE
    0x80802B1B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM2_23_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM2_23"
    VALUE
    0x80802B1C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM2_4_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM2_4"
    VALUE
    0x80802B1D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM2_5_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM2_5"
    VALUE
    0x80802B1E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM2_7_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM2_7"
    VALUE
    0x80802B1F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM2_8_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM2_8"
    VALUE
    0x80802B20
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM3_1_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM3_1"
    VALUE
    0x80802B21
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM3_10_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM3_10"
    VALUE
    0x80802B22
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM3_11_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM3_11"
    VALUE
    0x80802B23
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM3_13_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM3_13"
    VALUE
    0x80802B24
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM3_14_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM3_14"
    VALUE
    0x80802B25
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM3_2_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM3_2"
    VALUE
    0x80802B26
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM3_22_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM3_22"
    VALUE
    0x80802B27
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM3_23_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM3_23"
    VALUE
    0x80802B28
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM3_4_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM3_4"
    VALUE
    0x80802B29
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM3_5_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM3_5"
    VALUE
    0x80802B2A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM3_7_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM3_7"
    VALUE
    0x80802B2B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM3_8_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM3_8"
    VALUE
    0x80802B2C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM6_0_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM6_0"
    VALUE
    0x80802B2D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM6_11_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM6_11"
    VALUE
    0x80802B2E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM6_12_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM6_12"
    VALUE
    0x80802B2F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM6_14_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM6_14"
    VALUE
    0x80802B30
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM6_15_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM6_15"
    VALUE
    0x80802B31
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM6_17_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM6_17"
    VALUE
    0x80802B32
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM6_18_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM6_18"
    VALUE
    0x80802B33
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM6_2_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM6_2"
    VALUE
    0x80802B34
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM6_20_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM6_20"
    VALUE
    0x80802B35
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM6_21_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM6_21"
    VALUE
    0x80802B36
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM6_25_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM6_25"
    VALUE
    0x80802B37
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM6_4_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM6_4"
    VALUE
    0x80802B38
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM6_5_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM6_5"
    VALUE
    0x80802B39
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM6_7_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM6_7"
    VALUE
    0x80802B3A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM6_8_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM6_8"
    VALUE
    0x80802B3B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM7_1_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM7_1"
    VALUE
    0x80802B3C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM7_12_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM7_12"
    VALUE
    0x80802B3D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM7_13_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM7_13"
    VALUE
    0x80802B3E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM7_14_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM7_14"
    VALUE
    0x80802B3F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM7_15_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM7_15"
    VALUE
    0x80802B40
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM7_16_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM7_16"
    VALUE
    0x80802B41
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM7_17_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM7_17"
    VALUE
    0x80802B42
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM7_2_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM7_2"
    VALUE
    0x80802B43
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM7_20_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM7_20"
    VALUE
    0x80802B44
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM7_25_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM7_25"
    VALUE
    0x80802B45
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM7_26_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM7_26"
    VALUE
    0x80802B46
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM7_28_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM7_28"
    VALUE
    0x80802B47
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM7_29_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM7_29"
    VALUE
    0x80802B48
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM7_30_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM7_30"
    VALUE
    0x80802B49
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM7_31_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM7_31"
    VALUE
    0x80802B4A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM8_0_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM8_0"
    VALUE
    0x80802B4B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM8_1_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM8_1"
    VALUE
    0x80802B4C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM8_10_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM8_10"
    VALUE
    0x80802B4D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM8_11_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM8_11"
    VALUE
    0x80802B4E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM8_12_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM8_12"
    VALUE
    0x80802B4F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM8_13_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM8_13"
    VALUE
    0x80802B50
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM8_16_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM8_16"
    VALUE
    0x80802B51
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM8_18_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM8_18"
    VALUE
    0x80802B52
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM8_2_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM8_2"
    VALUE
    0x80802B53
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM8_3_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM8_3"
    VALUE
    0x80802B54
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM8_30_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM8_30"
    VALUE
    0x80802B55
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM8_31_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM8_31"
    VALUE
    0x80802B56
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM8_4_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM8_4"
    VALUE
    0x80802B57
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM9_0_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM9_0"
    VALUE
    0x80802B58
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM9_1_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM9_1"
    VALUE
    0x80802B59
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM9_15_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM9_15"
    VALUE
    0x80802B5A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM9_3_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM9_3"
    VALUE
    0x80802B5B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MoCSOPICO_C
    "disable mask / Disable masks of check DFC_MoCSOPICO"
    VALUE
    0x80802B5C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MoFVarPostBldSel_C
    "disable mask / Disable masks of check DFC_MoFVarPostBldSel"
    VALUE
    0x80802B5D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MoSysCtrlReIni_C
    "disable mask / Disable masks of check DFC_MoSysCtrlReIni"
    VALUE
    0x80802B5E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MoXEMMHwLTMCUFW_C
    "disable mask / Disable masks of check DFC_MoXEMMHwLTMCUFW"
    VALUE
    0x80802B5F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MoXEMMHwLTMonBIST_C
    "disable mask / Disable masks of check DFC_MoXEMMHwLTMonBIST"
    VALUE
    0x80802B60
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MoXEMMHwLTRegMonTest_C
    "disable mask / Disable masks of check DFC_MoXEMMHwLTRegMonTest"
    VALUE
    0x80802B61
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MoXEMMHwLTStbySMUAlvTest_C
    "disable mask / Disable masks of check DFC_MoXEMMHwLTStbySMUAlvTest"
    VALUE
    0x80802B62
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MoXEMMHwLTTempSens_C
    "disable mask / Disable masks of check DFC_MoXEMMHwLTTempSens"
    VALUE
    0x80802B63
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MoXEMMHwLTUCBCfg_C
    "disable mask / Disable masks of check DFC_MoXEMMHwLTUCBCfg"
    VALUE
    0x80802B64
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_OCWDAABEActv_C
    "disable mask / Disable masks of check DFC_OCWDAABEActv"
    VALUE
    0x80802B65
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_OCWDACom_C
    "disable mask / Disable masks of check DFC_OCWDACom"
    VALUE
    0x80802B66
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_OCWDAErrPin_C
    "disable mask / Disable masks of check DFC_OCWDAErrPin"
    VALUE
    0x80802B67
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_SWReset_0_C
    "disable mask / Disable masks of check DFC_SWReset_0"
    VALUE
    0x80802B68
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_SWReset_1_C
    "disable mask / Disable masks of check DFC_SWReset_1"
    VALUE
    0x80802B69
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_SWReset_2_C
    "disable mask / Disable masks of check DFC_SWReset_2"
    VALUE
    0x80802B6A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDebFault1_C
    "disable mask / Disable masks of check DFC_bds_NoDebFault1"
    VALUE
    0x80802B6B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_Unused_C
    "AUTOSAR: Functional unit of DTC / Check DFC_Unused"
    VALUE
    0x808068D4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    READ_ONLY

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_TimeInRowDebFault_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_TimeInRowDebFault"
    VALUE
    0x808068D5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_EventInRowDebFault_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_EventInRowDebFault"
    VALUE
    0x808068D6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_DevLibBattUHi_C
    "AUTOSAR: Functional unit of DTC / Check DFC_DevLibBattUHi"
    VALUE
    0x808068D7
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_DevLibBattULo_C
    "AUTOSAR: Functional unit of DTC / Check DFC_DevLibBattULo"
    VALUE
    0x808068D8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_TimeUpDownDebFault_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_TimeUpDownDebFault"
    VALUE
    0x808068D9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA13OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA13OR"
    VALUE
    0x808068DA
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA13SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA13SCB"
    VALUE
    0x808068DB
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA13SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA13SCG"
    VALUE
    0x808068DC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA14OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA14OR"
    VALUE
    0x808068DD
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA14SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA14SCB"
    VALUE
    0x808068DE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA14SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA14SCG"
    VALUE
    0x808068DF
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA21OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA21OR"
    VALUE
    0x808068E0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA21SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA21SCB"
    VALUE
    0x808068E1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA21SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA21SCG"
    VALUE
    0x808068E2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA22OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA22OR"
    VALUE
    0x808068E3
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA22SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA22SCB"
    VALUE
    0x808068E4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA22SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA22SCG"
    VALUE
    0x808068E5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA23OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA23OR"
    VALUE
    0x808068E6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA23SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA23SCB"
    VALUE
    0x808068E7
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA23SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA23SCG"
    VALUE
    0x808068E8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA24OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA24OR"
    VALUE
    0x808068E9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA24SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA24SCB"
    VALUE
    0x808068EA
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA24SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA24SCG"
    VALUE
    0x808068EB
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA25OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA25OR"
    VALUE
    0x808068EC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA25SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA25SCB"
    VALUE
    0x808068ED
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA25SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA25SCG"
    VALUE
    0x808068EE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA26OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA26OR"
    VALUE
    0x808068EF
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA26SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA26SCB"
    VALUE
    0x808068F0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA26SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA26SCG"
    VALUE
    0x808068F1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA27OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA27OR"
    VALUE
    0x808068F2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA27SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA27SCB"
    VALUE
    0x808068F3
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA27SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA27SCG"
    VALUE
    0x808068F4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA28OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA28OR"
    VALUE
    0x808068F5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA28SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA28SCB"
    VALUE
    0x808068F6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA28SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA28SCG"
    VALUE
    0x808068F7
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA29OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA29OR"
    VALUE
    0x808068F8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA29SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA29SCB"
    VALUE
    0x808068F9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA29SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA29SCG"
    VALUE
    0x808068FA
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA36AicSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA36AicSCB"
    VALUE
    0x808068FB
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA36AicSCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA36AicSCG"
    VALUE
    0x808068FC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA36OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA36OR"
    VALUE
    0x808068FD
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA36SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA36SCB"
    VALUE
    0x808068FE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA36SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA36SCG"
    VALUE
    0x808068FF
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA36ShuntSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA36ShuntSCB"
    VALUE
    0x80806900
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA37AicSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA37AicSCB"
    VALUE
    0x80806901
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA37AicSCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA37AicSCG"
    VALUE
    0x80806902
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA37OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA37OR"
    VALUE
    0x80806903
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA37SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA37SCB"
    VALUE
    0x80806904
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA37SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA37SCG"
    VALUE
    0x80806905
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA37ShuntSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA37ShuntSCB"
    VALUE
    0x80806906
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA38AicSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA38AicSCB"
    VALUE
    0x80806907
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA38AicSCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA38AicSCG"
    VALUE
    0x80806908
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA38OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA38OR"
    VALUE
    0x80806909
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA38SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA38SCB"
    VALUE
    0x8080690A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA38SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA38SCG"
    VALUE
    0x8080690B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA38ShuntSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA38ShuntSCB"
    VALUE
    0x8080690C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA39AicSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA39AicSCB"
    VALUE
    0x8080690D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA39AicSCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA39AicSCG"
    VALUE
    0x8080690E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA39OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA39OR"
    VALUE
    0x8080690F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA39SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA39SCB"
    VALUE
    0x80806910
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA39SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA39SCG"
    VALUE
    0x80806911
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA39ShuntSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA39ShuntSCB"
    VALUE
    0x80806912
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA40OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA40OR"
    VALUE
    0x80806913
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA40SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA40SCB"
    VALUE
    0x80806914
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA40SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA40SCG"
    VALUE
    0x80806915
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA41OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA41OR"
    VALUE
    0x80806916
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA41SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA41SCB"
    VALUE
    0x80806917
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA41SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA41SCG"
    VALUE
    0x80806918
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA42OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA42OR"
    VALUE
    0x80806919
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA42SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA42SCB"
    VALUE
    0x8080691A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA42SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA42SCG"
    VALUE
    0x8080691B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA43AicSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA43AicSCB"
    VALUE
    0x8080691C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA43AicSCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA43AicSCG"
    VALUE
    0x8080691D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA43OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA43OR"
    VALUE
    0x8080691E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA43SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA43SCB"
    VALUE
    0x8080691F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA43SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA43SCG"
    VALUE
    0x80806920
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA43ShuntSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA43ShuntSCB"
    VALUE
    0x80806921
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA44OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA44OL"
    VALUE
    0x80806922
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA44SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA44SCB"
    VALUE
    0x80806923
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA44SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA44SCG"
    VALUE
    0x80806924
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA57OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA57OR"
    VALUE
    0x80806925
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA57SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA57SCB"
    VALUE
    0x80806926
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA57SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA57SCG"
    VALUE
    0x80806927
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA59OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA59OL"
    VALUE
    0x80806928
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA59SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA59SCB"
    VALUE
    0x80806929
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA59SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA59SCG"
    VALUE
    0x8080692A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK10OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK10OR"
    VALUE
    0x8080692B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK10SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK10SCB"
    VALUE
    0x8080692C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK10SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK10SCG"
    VALUE
    0x8080692D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK11OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK11OR"
    VALUE
    0x8080692E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK11SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK11SCB"
    VALUE
    0x8080692F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK11SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK11SCG"
    VALUE
    0x80806930
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK30AicSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK30AicSCB"
    VALUE
    0x80806931
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK30AicSCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK30AicSCG"
    VALUE
    0x80806932
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK30OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK30OR"
    VALUE
    0x80806933
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK30SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK30SCB"
    VALUE
    0x80806934
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK30SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK30SCG"
    VALUE
    0x80806935
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK30ShuntSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK30ShuntSCB"
    VALUE
    0x80806936
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK31OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK31OR"
    VALUE
    0x80806937
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK31SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK31SCB"
    VALUE
    0x80806938
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK31SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK31SCG"
    VALUE
    0x80806939
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK32OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK32OR"
    VALUE
    0x8080693A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK32SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK32SCB"
    VALUE
    0x8080693B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK32SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK32SCG"
    VALUE
    0x8080693C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK33OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK33OR"
    VALUE
    0x8080693D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK33SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK33SCB"
    VALUE
    0x8080693E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK33SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK33SCG"
    VALUE
    0x8080693F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK34OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK34OR"
    VALUE
    0x80806940
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK34SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK34SCB"
    VALUE
    0x80806941
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK34SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK34SCG"
    VALUE
    0x80806942
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK35OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK35OR"
    VALUE
    0x80806943
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK35SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK35SCB"
    VALUE
    0x80806944
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK35SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK35SCG"
    VALUE
    0x80806945
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK36OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK36OR"
    VALUE
    0x80806946
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK36SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK36SCB"
    VALUE
    0x80806947
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK36SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK36SCG"
    VALUE
    0x80806948
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK37AicSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK37AicSCB"
    VALUE
    0x80806949
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK37AicSCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK37AicSCG"
    VALUE
    0x8080694A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK37OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK37OR"
    VALUE
    0x8080694B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK37SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK37SCB"
    VALUE
    0x8080694C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK37SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK37SCG"
    VALUE
    0x8080694D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK37ShuntSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK37ShuntSCB"
    VALUE
    0x8080694E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK38AicSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK38AicSCB"
    VALUE
    0x8080694F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK38AicSCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK38AicSCG"
    VALUE
    0x80806950
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK38OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK38OR"
    VALUE
    0x80806951
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK38SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK38SCB"
    VALUE
    0x80806952
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK38SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK38SCG"
    VALUE
    0x80806953
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK38ShuntSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK38ShuntSCB"
    VALUE
    0x80806954
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK39AicSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK39AicSCB"
    VALUE
    0x80806955
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK39AicSCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK39AicSCG"
    VALUE
    0x80806956
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK39OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK39OR"
    VALUE
    0x80806957
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK39SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK39SCB"
    VALUE
    0x80806958
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK39SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK39SCG"
    VALUE
    0x80806959
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK39ShuntSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK39ShuntSCB"
    VALUE
    0x8080695A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK40AicSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK40AicSCB"
    VALUE
    0x8080695B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK40AicSCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK40AicSCG"
    VALUE
    0x8080695C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK40OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK40OR"
    VALUE
    0x8080695D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK40SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK40SCB"
    VALUE
    0x8080695E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK40SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK40SCG"
    VALUE
    0x8080695F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK40ShuntSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK40ShuntSCB"
    VALUE
    0x80806960
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK41AicSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK41AicSCB"
    VALUE
    0x80806961
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK41AicSCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK41AicSCG"
    VALUE
    0x80806962
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK41OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK41OR"
    VALUE
    0x80806963
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK41SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK41SCB"
    VALUE
    0x80806964
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK41SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK41SCG"
    VALUE
    0x80806965
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK41ShuntSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK41ShuntSCB"
    VALUE
    0x80806966
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK42AicSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK42AicSCB"
    VALUE
    0x80806967
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK42AicSCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK42AicSCG"
    VALUE
    0x80806968
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK42OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK42OR"
    VALUE
    0x80806969
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK42SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK42SCB"
    VALUE
    0x8080696A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK42SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK42SCG"
    VALUE
    0x8080696B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK42ShuntSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK42ShuntSCB"
    VALUE
    0x8080696C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK43OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK43OR"
    VALUE
    0x8080696D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK43SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK43SCB"
    VALUE
    0x8080696E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK43SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK43SCG"
    VALUE
    0x8080696F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK44AicSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK44AicSCB"
    VALUE
    0x80806970
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK44AicSCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK44AicSCG"
    VALUE
    0x80806971
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK44OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK44OR"
    VALUE
    0x80806972
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK44SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK44SCB"
    VALUE
    0x80806973
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK44SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK44SCG"
    VALUE
    0x80806974
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK44ShuntSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK44ShuntSCB"
    VALUE
    0x80806975
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK45AicSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK45AicSCB"
    VALUE
    0x80806976
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK45AicSCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK45AicSCG"
    VALUE
    0x80806977
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK45OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK45OR"
    VALUE
    0x80806978
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK45SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK45SCB"
    VALUE
    0x80806979
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK45SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK45SCG"
    VALUE
    0x8080697A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK45ShuntSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK45ShuntSCB"
    VALUE
    0x8080697B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK52OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK52OR"
    VALUE
    0x8080697C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK52SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK52SCB"
    VALUE
    0x8080697D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK52SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK52SCG"
    VALUE
    0x8080697E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK53OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK53OR"
    VALUE
    0x8080697F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK53SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK53SCB"
    VALUE
    0x80806980
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK53SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK53SCG"
    VALUE
    0x80806981
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK54AicSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK54AicSCB"
    VALUE
    0x80806982
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK54AicSCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK54AicSCG"
    VALUE
    0x80806983
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK54OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK54OR"
    VALUE
    0x80806984
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK54SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK54SCB"
    VALUE
    0x80806985
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK54SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK54SCG"
    VALUE
    0x80806986
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK54ShuntSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK54ShuntSCB"
    VALUE
    0x80806987
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK55AicSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK55AicSCB"
    VALUE
    0x80806988
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK55AicSCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK55AicSCG"
    VALUE
    0x80806989
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK55OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK55OR"
    VALUE
    0x8080698A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK55SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK55SCB"
    VALUE
    0x8080698B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK55SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK55SCG"
    VALUE
    0x8080698C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK55ShuntSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK55ShuntSCB"
    VALUE
    0x8080698D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK56OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK56OR"
    VALUE
    0x8080698E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK56SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK56SCB"
    VALUE
    0x8080698F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK56SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK56SCG"
    VALUE
    0x80806990
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK57OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK57OR"
    VALUE
    0x80806991
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK57SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK57SCB"
    VALUE
    0x80806992
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK57SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK57SCG"
    VALUE
    0x80806993
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK58OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK58OR"
    VALUE
    0x80806994
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK58SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK58SCB"
    VALUE
    0x80806995
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK58SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK58SCG"
    VALUE
    0x80806996
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK59OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK59OR"
    VALUE
    0x80806997
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK59SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK59SCB"
    VALUE
    0x80806998
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK59SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK59SCG"
    VALUE
    0x80806999
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK60OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK60OR"
    VALUE
    0x8080699A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK60SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK60SCB"
    VALUE
    0x8080699B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK60SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK60SCG"
    VALUE
    0x8080699C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK61AicSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK61AicSCB"
    VALUE
    0x8080699D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK61AicSCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK61AicSCG"
    VALUE
    0x8080699E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK61OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK61OR"
    VALUE
    0x8080699F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK61SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK61SCB"
    VALUE
    0x808069A0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK61SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK61SCG"
    VALUE
    0x808069A1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK61ShuntSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK61ShuntSCB"
    VALUE
    0x808069A2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK62OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK62OR"
    VALUE
    0x808069A3
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK62SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK62SCB"
    VALUE
    0x808069A4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK62SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK62SCG"
    VALUE
    0x808069A5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK63AicSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK63AicSCB"
    VALUE
    0x808069A6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK63AicSCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK63AicSCG"
    VALUE
    0x808069A7
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK63OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK63OR"
    VALUE
    0x808069A8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK63SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK63SCB"
    VALUE
    0x808069A9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK63SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK63SCG"
    VALUE
    0x808069AA
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK63ShuntSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK63ShuntSCB"
    VALUE
    0x808069AB
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK64AicSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK64AicSCB"
    VALUE
    0x808069AC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK64AicSCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK64AicSCG"
    VALUE
    0x808069AD
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK64OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK64OR"
    VALUE
    0x808069AE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK64SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK64SCB"
    VALUE
    0x808069AF
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK64SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK64SCG"
    VALUE
    0x808069B0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK64ShuntSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK64ShuntSCB"
    VALUE
    0x808069B1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK65AicSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK65AicSCB"
    VALUE
    0x808069B2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK65AicSCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK65AicSCG"
    VALUE
    0x808069B3
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK65OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK65OR"
    VALUE
    0x808069B4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK65SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK65SCB"
    VALUE
    0x808069B5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK65SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK65SCG"
    VALUE
    0x808069B6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK65ShuntSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK65ShuntSCB"
    VALUE
    0x808069B7
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK74OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK74OR"
    VALUE
    0x808069B8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK74SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK74SCB"
    VALUE
    0x808069B9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK74SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK74SCG"
    VALUE
    0x808069BA
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK75OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK75OR"
    VALUE
    0x808069BB
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK75SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK75SCB"
    VALUE
    0x808069BC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK75SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK75SCG"
    VALUE
    0x808069BD
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK76OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK76OR"
    VALUE
    0x808069BE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK76SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK76SCB"
    VALUE
    0x808069BF
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK76SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK76SCG"
    VALUE
    0x808069C0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK77OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK77OR"
    VALUE
    0x808069C1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK77SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK77SCB"
    VALUE
    0x808069C2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK77SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK77SCG"
    VALUE
    0x808069C3
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK78OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK78OR"
    VALUE
    0x808069C4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK78SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK78SCB"
    VALUE
    0x808069C5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK78SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK78SCG"
    VALUE
    0x808069C6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_DvUBAT_FWs_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_DvUBAT_FWs"
    VALUE
    0x808069C7
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_OVErr_VPR6_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_OVErr_VPR6"
    VALUE
    0x808069C8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_OVWarn_VPR6_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_OVWarn_VPR6"
    VALUE
    0x808069C9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3"
    VALUE
    0x808069CA
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2"
    VALUE
    0x808069CB
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_OV_UBAT_MON_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_OV_UBAT_MON"
    VALUE
    0x808069CC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_OV_UBRM24_FLEXIN_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_OV_UBRM24_FLEXIN"
    VALUE
    0x808069CD
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_OV_UBRM24_LOADS_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_OV_UBRM24_LOADS"
    VALUE
    0x808069CE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_OV_UBRM24_MON_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_OV_UBRM24_MON"
    VALUE
    0x808069CF
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_OV_VDD5_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_OV_VDD5"
    VALUE
    0x808069D0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_OV_VDD5_IN_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_OV_VDD5_IN"
    VALUE
    0x808069D1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_OV_VPR6_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_OV_VPR6"
    VALUE
    0x808069D2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_OV_VSS3_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_OV_VSS3"
    VALUE
    0x808069D3
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_OV_VSS4_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_OV_VSS4"
    VALUE
    0x808069D4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_Temp1_HTErr_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_Temp1_HTErr"
    VALUE
    0x808069D5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_Temp1_HTWarn_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_Temp1_HTWarn"
    VALUE
    0x808069D6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_Temp2_HTErr_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_Temp2_HTErr"
    VALUE
    0x808069D7
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_Temp2_HTWarn_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_Temp2_HTWarn"
    VALUE
    0x808069D8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3"
    VALUE
    0x808069D9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2"
    VALUE
    0x808069DA
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_UV_VDD5_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_UV_VDD5"
    VALUE
    0x808069DB
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_UV_VDD5_IN_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_UV_VDD5_IN"
    VALUE
    0x808069DC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_UV_VPR6_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_UV_VPR6"
    VALUE
    0x808069DD
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_UV_VSS3_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_UV_VSS3"
    VALUE
    0x808069DE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_UV_VSS4_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_UV_VSS4"
    VALUE
    0x808069DF
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA01OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA01OL"
    VALUE
    0x808069E0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA01OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA01OT"
    VALUE
    0x808069E1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA01SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA01SCB"
    VALUE
    0x808069E2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA01SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA01SCG"
    VALUE
    0x808069E3
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA02OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA02OL"
    VALUE
    0x808069E4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA02OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA02OR"
    VALUE
    0x808069E5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA02OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA02OT"
    VALUE
    0x808069E6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA02SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA02SCB"
    VALUE
    0x808069E7
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA02SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA02SCG"
    VALUE
    0x808069E8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA03OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA03OL"
    VALUE
    0x808069E9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA03OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA03OT"
    VALUE
    0x808069EA
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA03SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA03SCB"
    VALUE
    0x808069EB
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA03SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA03SCG"
    VALUE
    0x808069EC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA04OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA04OL"
    VALUE
    0x808069ED
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA04OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA04OT"
    VALUE
    0x808069EE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA04SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA04SCB"
    VALUE
    0x808069EF
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA04SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA04SCG"
    VALUE
    0x808069F0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA05OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA05OL"
    VALUE
    0x808069F1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA05OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA05OR"
    VALUE
    0x808069F2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA05OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA05OT"
    VALUE
    0x808069F3
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA05SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA05SCB"
    VALUE
    0x808069F4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA05SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA05SCG"
    VALUE
    0x808069F5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA06OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA06OL"
    VALUE
    0x808069F6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA06OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA06OR"
    VALUE
    0x808069F7
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA06OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA06OT"
    VALUE
    0x808069F8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA06SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA06SCB"
    VALUE
    0x808069F9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA06SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA06SCG"
    VALUE
    0x808069FA
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA07OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA07OL"
    VALUE
    0x808069FB
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA07OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA07OT"
    VALUE
    0x808069FC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA07SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA07SCB"
    VALUE
    0x808069FD
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA07SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA07SCG"
    VALUE
    0x808069FE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA08OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA08OL"
    VALUE
    0x808069FF
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA08OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA08OT"
    VALUE
    0x80806A00
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA08SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA08SCB"
    VALUE
    0x80806A01
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA08SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA08SCG"
    VALUE
    0x80806A02
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA09OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA09OL"
    VALUE
    0x80806A03
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA09OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA09OR"
    VALUE
    0x80806A04
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA09OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA09OT"
    VALUE
    0x80806A05
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA09SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA09SCB"
    VALUE
    0x80806A06
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA09SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA09SCG"
    VALUE
    0x80806A07
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA10OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA10OL"
    VALUE
    0x80806A08
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA10OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA10OT"
    VALUE
    0x80806A09
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA10SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA10SCB"
    VALUE
    0x80806A0A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA10SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA10SCG"
    VALUE
    0x80806A0B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA11OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA11OL"
    VALUE
    0x80806A0C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA11OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA11OT"
    VALUE
    0x80806A0D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA11SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA11SCB"
    VALUE
    0x80806A0E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA11SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA11SCG"
    VALUE
    0x80806A0F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA12OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA12OR"
    VALUE
    0x80806A10
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA12SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA12SCB"
    VALUE
    0x80806A11
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA12SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA12SCG"
    VALUE
    0x80806A12
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA16OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA16OL"
    VALUE
    0x80806A13
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA16OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA16OT"
    VALUE
    0x80806A14
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA16SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA16SCB"
    VALUE
    0x80806A15
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA16SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA16SCG"
    VALUE
    0x80806A16
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA17OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA17OL"
    VALUE
    0x80806A17
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA17OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA17OR"
    VALUE
    0x80806A18
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA17OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA17OT"
    VALUE
    0x80806A19
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA17SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA17SCB"
    VALUE
    0x80806A1A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA17SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA17SCG"
    VALUE
    0x80806A1B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA18OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA18OL"
    VALUE
    0x80806A1C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA18OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA18OT"
    VALUE
    0x80806A1D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA18SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA18SCB"
    VALUE
    0x80806A1E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA18SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA18SCG"
    VALUE
    0x80806A1F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA19OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA19OL"
    VALUE
    0x80806A20
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA19OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA19OR"
    VALUE
    0x80806A21
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA19OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA19OT"
    VALUE
    0x80806A22
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA19SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA19SCB"
    VALUE
    0x80806A23
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA19SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA19SCG"
    VALUE
    0x80806A24
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA20OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA20OL"
    VALUE
    0x80806A25
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA20OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA20OR"
    VALUE
    0x80806A26
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA20OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA20OT"
    VALUE
    0x80806A27
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA20SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA20SCB"
    VALUE
    0x80806A28
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA20SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA20SCG"
    VALUE
    0x80806A29
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA31OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA31OL"
    VALUE
    0x80806A2A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA31OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA31OR"
    VALUE
    0x80806A2B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA31OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA31OT"
    VALUE
    0x80806A2C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA31SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA31SCB"
    VALUE
    0x80806A2D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA31SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA31SCG"
    VALUE
    0x80806A2E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA32OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA32OL"
    VALUE
    0x80806A2F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA32OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA32OR"
    VALUE
    0x80806A30
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA32OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA32OT"
    VALUE
    0x80806A31
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA32SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA32SCB"
    VALUE
    0x80806A32
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA32SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA32SCG"
    VALUE
    0x80806A33
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA33OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA33OL"
    VALUE
    0x80806A34
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA33OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA33OR"
    VALUE
    0x80806A35
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA33OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA33OT"
    VALUE
    0x80806A36
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA33SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA33SCB"
    VALUE
    0x80806A37
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA33SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA33SCG"
    VALUE
    0x80806A38
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA34OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA34OL"
    VALUE
    0x80806A39
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA34OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA34OR"
    VALUE
    0x80806A3A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA34OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA34OT"
    VALUE
    0x80806A3B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA34SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA34SCB"
    VALUE
    0x80806A3C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA34SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA34SCG"
    VALUE
    0x80806A3D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA35OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA35OL"
    VALUE
    0x80806A3E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA35OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA35OR"
    VALUE
    0x80806A3F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA35OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA35OT"
    VALUE
    0x80806A40
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA35SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA35SCB"
    VALUE
    0x80806A41
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA35SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA35SCG"
    VALUE
    0x80806A42
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA46OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA46OL"
    VALUE
    0x80806A43
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA46OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA46OR"
    VALUE
    0x80806A44
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA46OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA46OT"
    VALUE
    0x80806A45
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA46SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA46SCB"
    VALUE
    0x80806A46
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA46SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA46SCG"
    VALUE
    0x80806A47
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA47OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA47OL"
    VALUE
    0x80806A48
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA47OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA47OR"
    VALUE
    0x80806A49
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA47OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA47OT"
    VALUE
    0x80806A4A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA47SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA47SCB"
    VALUE
    0x80806A4B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA47SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA47SCG"
    VALUE
    0x80806A4C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA48OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA48OL"
    VALUE
    0x80806A4D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA48OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA48OR"
    VALUE
    0x80806A4E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA48OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA48OT"
    VALUE
    0x80806A4F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA48SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA48SCB"
    VALUE
    0x80806A50
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA48SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA48SCG"
    VALUE
    0x80806A51
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA49OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA49OL"
    VALUE
    0x80806A52
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA49OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA49OT"
    VALUE
    0x80806A53
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA49SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA49SCB"
    VALUE
    0x80806A54
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA49SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA49SCG"
    VALUE
    0x80806A55
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA50OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA50OL"
    VALUE
    0x80806A56
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA50OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA50OT"
    VALUE
    0x80806A57
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA50SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA50SCB"
    VALUE
    0x80806A58
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA50SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA50SCG"
    VALUE
    0x80806A59
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA51OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA51OL"
    VALUE
    0x80806A5A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA51OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA51OR"
    VALUE
    0x80806A5B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA51OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA51OT"
    VALUE
    0x80806A5C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA51SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA51SCB"
    VALUE
    0x80806A5D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA51SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA51SCG"
    VALUE
    0x80806A5E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA52OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA52OL"
    VALUE
    0x80806A5F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA52OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA52OR"
    VALUE
    0x80806A60
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA52OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA52OT"
    VALUE
    0x80806A61
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA52SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA52SCB"
    VALUE
    0x80806A62
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA52SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA52SCG"
    VALUE
    0x80806A63
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA53OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA53OL"
    VALUE
    0x80806A64
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA53OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA53OR"
    VALUE
    0x80806A65
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA53OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA53OT"
    VALUE
    0x80806A66
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA53SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA53SCB"
    VALUE
    0x80806A67
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA53SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA53SCG"
    VALUE
    0x80806A68
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA54OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA54OL"
    VALUE
    0x80806A69
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA54OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA54OR"
    VALUE
    0x80806A6A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA54OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA54OT"
    VALUE
    0x80806A6B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA54SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA54SCB"
    VALUE
    0x80806A6C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA54SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA54SCG"
    VALUE
    0x80806A6D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA55OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA55OL"
    VALUE
    0x80806A6E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA55OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA55OT"
    VALUE
    0x80806A6F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA55SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA55SCB"
    VALUE
    0x80806A70
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA55SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA55SCG"
    VALUE
    0x80806A71
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA56OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA56OL"
    VALUE
    0x80806A72
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA56OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA56OT"
    VALUE
    0x80806A73
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA56SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA56SCB"
    VALUE
    0x80806A74
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA56SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA56SCG"
    VALUE
    0x80806A75
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA58OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA58OL"
    VALUE
    0x80806A76
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA58OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA58OT"
    VALUE
    0x80806A77
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA58SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA58SCB"
    VALUE
    0x80806A78
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA58SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA58SCG"
    VALUE
    0x80806A79
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK07OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK07OL"
    VALUE
    0x80806A7A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK07OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK07OR"
    VALUE
    0x80806A7B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK07OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK07OT"
    VALUE
    0x80806A7C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK07SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK07SCB"
    VALUE
    0x80806A7D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK07SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK07SCG"
    VALUE
    0x80806A7E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK08OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK08OL"
    VALUE
    0x80806A7F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK08OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK08OR"
    VALUE
    0x80806A80
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK08OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK08OT"
    VALUE
    0x80806A81
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK08SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK08SCB"
    VALUE
    0x80806A82
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK08SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK08SCG"
    VALUE
    0x80806A83
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK09OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK09OL"
    VALUE
    0x80806A84
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK09OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK09OR"
    VALUE
    0x80806A85
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK09OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK09OT"
    VALUE
    0x80806A86
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK09SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK09SCB"
    VALUE
    0x80806A87
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK09SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK09SCG"
    VALUE
    0x80806A88
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK12OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK12OL"
    VALUE
    0x80806A89
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK12OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK12OT"
    VALUE
    0x80806A8A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK12SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK12SCB"
    VALUE
    0x80806A8B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK12SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK12SCG"
    VALUE
    0x80806A8C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK13OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK13OL"
    VALUE
    0x80806A8D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK13OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK13OT"
    VALUE
    0x80806A8E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK13SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK13SCB"
    VALUE
    0x80806A8F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK13SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK13SCG"
    VALUE
    0x80806A90
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK14OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK14OL"
    VALUE
    0x80806A91
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK14OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK14OR"
    VALUE
    0x80806A92
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK14OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK14OT"
    VALUE
    0x80806A93
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK14SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK14SCB"
    VALUE
    0x80806A94
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK14SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK14SCG"
    VALUE
    0x80806A95
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK15OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK15OL"
    VALUE
    0x80806A96
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK15OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK15OR"
    VALUE
    0x80806A97
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK15OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK15OT"
    VALUE
    0x80806A98
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK15SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK15SCB"
    VALUE
    0x80806A99
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK15SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK15SCG"
    VALUE
    0x80806A9A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK16OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK16OL"
    VALUE
    0x80806A9B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK16OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK16OR"
    VALUE
    0x80806A9C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK16OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK16OT"
    VALUE
    0x80806A9D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK16SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK16SCB"
    VALUE
    0x80806A9E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK16SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK16SCG"
    VALUE
    0x80806A9F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK17OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK17OL"
    VALUE
    0x80806AA0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK17OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK17OR"
    VALUE
    0x80806AA1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK17OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK17OT"
    VALUE
    0x80806AA2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK17SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK17SCB"
    VALUE
    0x80806AA3
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK17SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK17SCG"
    VALUE
    0x80806AA4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK25OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK25OR"
    VALUE
    0x80806AA5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK25SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK25SCB"
    VALUE
    0x80806AA6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK25SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK25SCG"
    VALUE
    0x80806AA7
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK29OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK29OL"
    VALUE
    0x80806AA8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK29OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK29OR"
    VALUE
    0x80806AA9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK29OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK29OT"
    VALUE
    0x80806AAA
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK29SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK29SCB"
    VALUE
    0x80806AAB
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK29SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK29SCG"
    VALUE
    0x80806AAC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK51OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK51OL"
    VALUE
    0x80806AAD
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK51OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK51OT"
    VALUE
    0x80806AAE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK51SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK51SCB"
    VALUE
    0x80806AAF
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK51SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK51SCG"
    VALUE
    0x80806AB0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK62OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK62OR"
    VALUE
    0x80806AB1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK62SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK62SCB"
    VALUE
    0x80806AB2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK62SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK62SCG"
    VALUE
    0x80806AB3
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK73OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK73OL"
    VALUE
    0x80806AB4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK73OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK73OR"
    VALUE
    0x80806AB5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK73OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK73OT"
    VALUE
    0x80806AB6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK73SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK73SCB"
    VALUE
    0x80806AB7
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK73SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK73SCG"
    VALUE
    0x80806AB8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK80OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK80OL"
    VALUE
    0x80806AB9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK80OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK80OT"
    VALUE
    0x80806ABA
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK80SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK80SCB"
    VALUE
    0x80806ABB
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK80SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK80SCG"
    VALUE
    0x80806ABC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK81OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK81OL"
    VALUE
    0x80806ABD
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK81OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK81OT"
    VALUE
    0x80806ABE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK81SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK81SCB"
    VALUE
    0x80806ABF
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK81SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK81SCG"
    VALUE
    0x80806AC0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK82OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK82OL"
    VALUE
    0x80806AC1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK82OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK82OT"
    VALUE
    0x80806AC2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK82SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK82SCB"
    VALUE
    0x80806AC3
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK82SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK82SCG"
    VALUE
    0x80806AC4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK83OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK83OL"
    VALUE
    0x80806AC5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK83OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK83OT"
    VALUE
    0x80806AC6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK83SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK83SCB"
    VALUE
    0x80806AC7
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK83SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK83SCG"
    VALUE
    0x80806AC8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK84OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK84OL"
    VALUE
    0x80806AC9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK84OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK84OT"
    VALUE
    0x80806ACA
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK84SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK84SCB"
    VALUE
    0x80806ACB
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK84SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK84SCG"
    VALUE
    0x80806ACC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK85OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK85OL"
    VALUE
    0x80806ACD
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK85OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK85OT"
    VALUE
    0x80806ACE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK85SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK85SCB"
    VALUE
    0x80806ACF
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK85SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK85SCG"
    VALUE
    0x80806AD0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK86OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK86OL"
    VALUE
    0x80806AD1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK86OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK86OT"
    VALUE
    0x80806AD2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK86SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK86SCB"
    VALUE
    0x80806AD3
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK86SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK86SCG"
    VALUE
    0x80806AD4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK87OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK87OL"
    VALUE
    0x80806AD5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK87OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK87OT"
    VALUE
    0x80806AD6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK87SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK87SCB"
    VALUE
    0x80806AD7
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK87SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK87SCG"
    VALUE
    0x80806AD8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_EventUpDownDebFault_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_EventUpDownDebFault"
    VALUE
    0x80806AD9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_DSMDummy_C
    "AUTOSAR: Functional unit of DTC / Check DFC_DSMDummy"
    VALUE
    0x80806ADA
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canGetDataNoBuf_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canGetDataNoBuf"
    VALUE
    0x80806ADB
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canGetDataParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canGetDataParam"
    VALUE
    0x80806ADC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canGetDataboxNoInit_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canGetDataboxNoInit"
    VALUE
    0x80806ADD
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canGetDataboxParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canGetDataboxParam"
    VALUE
    0x80806ADE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canGetRxBufStatusParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canGetRxBufStatusParam"
    VALUE
    0x80806ADF
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canGetStatusParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canGetStatusParam"
    VALUE
    0x80806AE0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canGetTxBufStatusParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canGetTxBufStatusParam"
    VALUE
    0x80806AE1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canInitParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canInitParam"
    VALUE
    0x80806AE2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canInitRxDataboxOverlap_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canInitRxDataboxOverlap"
    VALUE
    0x80806AE3
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canInitRxDataboxParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canInitRxDataboxParam"
    VALUE
    0x80806AE4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canInitTxDataboxParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canInitTxDataboxParam"
    VALUE
    0x80806AE5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canIpduGroupControl_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canIpduGroupControl"
    VALUE
    0x80806AE6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canIsDataboxFreeNoInit_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canIsDataboxFreeNoInit"
    VALUE
    0x80806AE7
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canIsDataboxFreeParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canIsDataboxFreeParam"
    VALUE
    0x80806AE8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canIsTxEmptyParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canIsTxEmptyParam"
    VALUE
    0x80806AE9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canRegBusOffCallbInvState_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canRegBusOffCallbInvState"
    VALUE
    0x80806AEA
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canRegBusOffCallbParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canRegBusOffCallbParam"
    VALUE
    0x80806AEB
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canRegRxBufInvState_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canRegRxBufInvState"
    VALUE
    0x80806AEC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canRegRxBufOverlap_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canRegRxBufOverlap"
    VALUE
    0x80806AED
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canRegRxBufParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canRegRxBufParam"
    VALUE
    0x80806AEE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canRegRxCallbInvState_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canRegRxCallbInvState"
    VALUE
    0x80806AEF
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canRegRxCallbParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canRegRxCallbParam"
    VALUE
    0x80806AF0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canRegRxDataboxInvNumb_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canRegRxDataboxInvNumb"
    VALUE
    0x80806AF1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canRegRxDataboxInvState_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canRegRxDataboxInvState"
    VALUE
    0x80806AF2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canRegRxDataboxOverlap_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canRegRxDataboxOverlap"
    VALUE
    0x80806AF3
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canRegRxDataboxParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canRegRxDataboxParam"
    VALUE
    0x80806AF4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canRegTxBufInvState_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canRegTxBufInvState"
    VALUE
    0x80806AF5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canRegTxBufOverlap_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canRegTxBufOverlap"
    VALUE
    0x80806AF6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canRegTxBufParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canRegTxBufParam"
    VALUE
    0x80806AF7
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canRegTxDataboxInvNumb_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canRegTxDataboxInvNumb"
    VALUE
    0x80806AF8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canRegTxDataboxInvState_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canRegTxDataboxInvState"
    VALUE
    0x80806AF9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canRegTxDataboxOverlap_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canRegTxDataboxOverlap"
    VALUE
    0x80806AFA
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canRegTxDataboxParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canRegTxDataboxParam"
    VALUE
    0x80806AFB
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canResetTxBufParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canResetTxBufParam"
    VALUE
    0x80806AFC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canSendDataBufOvfl_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canSendDataBufOvfl"
    VALUE
    0x80806AFD
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canSendDataParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canSendDataParam"
    VALUE
    0x80806AFE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canSendDataboxNoInit_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canSendDataboxNoInit"
    VALUE
    0x80806AFF
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canSendDataboxParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canSendDataboxParam"
    VALUE
    0x80806B00
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canSetTxCycleParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canSetTxCycleParam"
    VALUE
    0x80806B01
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canStartParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canStartParam"
    VALUE
    0x80806B02
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canStopParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canStopParam"
    VALUE
    0x80806B03
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_can_ClearIpduGroup_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_can_ClearIpduGroup"
    VALUE
    0x80806B04
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_can_ReceiveSignal_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_can_ReceiveSignal"
    VALUE
    0x80806B05
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_can_SendSignal_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_can_SendSignal"
    VALUE
    0x80806B06
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_can_SetIpduGroup_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_can_SetIpduGroup"
    VALUE
    0x80806B07
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_dsmDTCJ1939_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_dsmDTCJ1939"
    VALUE
    0x80806B08
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_dsmDelDTCJ1939_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_dsmDelDTCJ1939"
    VALUE
    0x80806B09
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_dsmDelErrors_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_dsmDelErrors"
    VALUE
    0x80806B0A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_dsmGetDFES_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_dsmGetDFES"
    VALUE
    0x80806B0B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_dsmGetDTCJ1939_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_dsmGetDTCJ1939"
    VALUE
    0x80806B0C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_dsmGetErrors_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_dsmGetErrors"
    VALUE
    0x80806B0D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_dsmGetNumErrors_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_dsmGetNumErrors"
    VALUE
    0x80806B0E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_dsmInitQueueOverflow_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_dsmInitQueueOverflow"
    VALUE
    0x80806B0F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_dsmNumDTCJ1939_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_dsmNumDTCJ1939"
    VALUE
    0x80806B10
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_dsmTesterror_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_dsmTesterror"
    VALUE
    0x80806B11
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_dsmUpdateDebError_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_dsmUpdateDebError"
    VALUE
    0x80806B12
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_dsmUpdateError_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_dsmUpdateError"
    VALUE
    0x80806B13
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_dsmgetDFCStatus_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_dsmgetDFCStatus"
    VALUE
    0x80806B14
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_dsmtestErrorDFC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_dsmtestErrorDFC"
    VALUE
    0x80806B15
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inAi_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inAi"
    VALUE
    0x80806B16
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inAic_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inAic"
    VALUE
    0x80806B17
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inAicCfg_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inAicCfg"
    VALUE
    0x80806B18
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inAicGetStatus_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inAicGetStatus"
    VALUE
    0x80806B19
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inAid_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inAid"
    VALUE
    0x80806B1A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inAidCfg_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inAidCfg"
    VALUE
    0x80806B1B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inAiv_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inAiv"
    VALUE
    0x80806B1C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inAivCfg_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inAivCfg"
    VALUE
    0x80806B1D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inAivGetStatus_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inAivGetStatus"
    VALUE
    0x80806B1E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inDi_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inDi"
    VALUE
    0x80806B1F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inFi_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inFi"
    VALUE
    0x80806B20
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inFiCfg_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inFiCfg"
    VALUE
    0x80806B21
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inFiGetStatus_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inFiGetStatus"
    VALUE
    0x80806B22
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inFi_Buffered_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inFi_Buffered"
    VALUE
    0x80806B23
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inPhase_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inPhase"
    VALUE
    0x80806B24
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inPhaseGetStatus_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inPhaseGetStatus"
    VALUE
    0x80806B25
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inPhaseResetCounter_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inPhaseResetCounter"
    VALUE
    0x80806B26
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inRi_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inRi"
    VALUE
    0x80806B27
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inRiCfg_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inRiCfg"
    VALUE
    0x80806B28
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inRiCfgTemp_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inRiCfgTemp"
    VALUE
    0x80806B29
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inRiGetStatus_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inRiGetStatus"
    VALUE
    0x80806B2A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inRiGetTemp_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inRiGetTemp"
    VALUE
    0x80806B2B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inSentCopyFDFifo_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inSentCopyFDFifo"
    VALUE
    0x80806B2C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inSentDisable_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inSentDisable"
    VALUE
    0x80806B2D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inSentEnable_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inSentEnable"
    VALUE
    0x80806B2E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inSentGetErrorStatus_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inSentGetErrorStatus"
    VALUE
    0x80806B2F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inSentGetFD_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inSentGetFD"
    VALUE
    0x80806B30
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inSentGetSD_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inSentGetSD"
    VALUE
    0x80806B31
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inSentGetSDDatabox_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inSentGetSDDatabox"
    VALUE
    0x80806B32
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inSentGetStatus_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inSentGetStatus"
    VALUE
    0x80806B33
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inSentInitSDDatabox_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inSentInitSDDatabox"
    VALUE
    0x80806B34
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inSentRegisterCopyFDFifo_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inSentRegisterCopyFDFifo"
    VALUE
    0x80806B35
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inSentRegisterFDFifo_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inSentRegisterFDFifo"
    VALUE
    0x80806B36
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inSentRegisterSDDataboxes_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inSentRegisterSDDataboxes"
    VALUE
    0x80806B37
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_isobusCanRxBufferOverflow_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_isobusCanRxBufferOverflow"
    VALUE
    0x80806B38
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_isobusGetCaAddrParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_isobusGetCaAddrParam"
    VALUE
    0x80806B39
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_isobusGetDiagnosticParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_isobusGetDiagnosticParam"
    VALUE
    0x80806B3A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_isobusGetRxDataboxStatusParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_isobusGetRxDataboxStatusParam"
    VALUE
    0x80806B3B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_isobusGetStatusParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_isobusGetStatusParam"
    VALUE
    0x80806B3C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_isobusInitCommCaMissing_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_isobusInitCommCaMissing"
    VALUE
    0x80806B3D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_isobusInitCommParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_isobusInitCommParam"
    VALUE
    0x80806B3E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_isobusInitCommState_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_isobusInitCommState"
    VALUE
    0x80806B3F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_isobusInitDiagnosticParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_isobusInitDiagnosticParam"
    VALUE
    0x80806B40
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_isobusInitFailureListParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_isobusInitFailureListParam"
    VALUE
    0x80806B41
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_isobusInitRxDataboxParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_isobusInitRxDataboxParam"
    VALUE
    0x80806B42
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_isobusInitTxDataboxParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_isobusInitTxDataboxParam"
    VALUE
    0x80806B43
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_isobusRegRxDataboxOverlap_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_isobusRegRxDataboxOverlap"
    VALUE
    0x80806B44
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_isobusRegRxDataboxParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_isobusRegRxDataboxParam"
    VALUE
    0x80806B45
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_isobusRegRxDataboxState_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_isobusRegRxDataboxState"
    VALUE
    0x80806B46
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_isobusRegTxDataboxOverlap_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_isobusRegTxDataboxOverlap"
    VALUE
    0x80806B47
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_isobusRegTxDataboxParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_isobusRegTxDataboxParam"
    VALUE
    0x80806B48
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_isobusRegTxDataboxState_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_isobusRegTxDataboxState"
    VALUE
    0x80806B49
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_isobusRegisterErrClrCallbackParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_isobusRegisterErrClrCallbackParam"
    VALUE
    0x80806B4A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_isobusRegisterInstancesOverlap_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_isobusRegisterInstancesOverlap"
    VALUE
    0x80806B4B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_isobusRegisterInstancesParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_isobusRegisterInstancesParam"
    VALUE
    0x80806B4C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_isobusRegisterInstancesState_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_isobusRegisterInstancesState"
    VALUE
    0x80806B4D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_isobusSendDataboxParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_isobusSendDataboxParam"
    VALUE
    0x80806B4E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_isobusSendRequestPGNParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_isobusSendRequestPGNParam"
    VALUE
    0x80806B4F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_isobusSetCaAddrCaUsed_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_isobusSetCaAddrCaUsed"
    VALUE
    0x80806B50
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_isobusSetCaAddrComm_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_isobusSetCaAddrComm"
    VALUE
    0x80806B51
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_isobusSetCaAddrInvCan_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_isobusSetCaAddrInvCan"
    VALUE
    0x80806B52
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_isobusSetCaAddrParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_isobusSetCaAddrParam"
    VALUE
    0x80806B53
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_isobusSetCaInfoParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_isobusSetCaInfoParam"
    VALUE
    0x80806B54
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_isobusSetCaNameParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_isobusSetCaNameParam"
    VALUE
    0x80806B55
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_isobusSftyCanTxErr_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_isobusSftyCanTxErr"
    VALUE
    0x80806B56
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_lin_ReceiveSignal_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_lin_ReceiveSignal"
    VALUE
    0x80806B57
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_lin_SendSignal_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_lin_SendSignal"
    VALUE
    0x80806B58
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_lin_getStatus_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_lin_getStatus"
    VALUE
    0x80806B59
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_lin_gotoSleep_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_lin_gotoSleep"
    VALUE
    0x80806B5A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_lin_scheduleRequest_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_lin_scheduleRequest"
    VALUE
    0x80806B5B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_lin_wakeUp_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_lin_wakeUp"
    VALUE
    0x80806B5C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_memFlsCfgShr_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_memFlsCfgShr"
    VALUE
    0x80806B5D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_memGetStatus_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_memGetStatus"
    VALUE
    0x80806B5E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_memMarkBlock_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_memMarkBlock"
    VALUE
    0x80806B5F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_memReadApi1Error_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_memReadApi1Error"
    VALUE
    0x80806B60
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_memReadApi2Error_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_memReadApi2Error"
    VALUE
    0x80806B61
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_memReadBlock_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_memReadBlock"
    VALUE
    0x80806B62
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_memReadCalibInputError_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_memReadCalibInputError"
    VALUE
    0x80806B63
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_memReadCalibOuputError_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_memReadCalibOuputError"
    VALUE
    0x80806B64
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_memReadSystemError_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_memReadSystemError"
    VALUE
    0x80806B65
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_memWriteBlock_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_memWriteBlock"
    VALUE
    0x80806B66
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_moOV_FirstConstADC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_moOV_FirstConstADC"
    VALUE
    0x80806B67
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_moOV_SecondConstADC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_moOV_SecondConstADC"
    VALUE
    0x80806B68
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_moUV_FirstConstADC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_moUV_FirstConstADC"
    VALUE
    0x80806B69
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_moUV_SecondConstADC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_moUV_SecondConstADC"
    VALUE
    0x80806B6A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_INH_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_INH"
    VALUE
    0x80806B6B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_INHLatch_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_INHLatch"
    VALUE
    0x80806B6C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_adcPDD_fail_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_adcPDD_fail"
    VALUE
    0x80806B6D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_memoryProtection_err_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_memoryProtection_err"
    VALUE
    0x80806B6E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA02OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA02OC"
    VALUE
    0x80806B6F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA02Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA02Unintended"
    VALUE
    0x80806B70
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA03OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA03OC"
    VALUE
    0x80806B71
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA03Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA03Unintended"
    VALUE
    0x80806B72
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA04OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA04OC"
    VALUE
    0x80806B73
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA04Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA04Unintended"
    VALUE
    0x80806B74
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA05OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA05OC"
    VALUE
    0x80806B75
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA05Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA05Unintended"
    VALUE
    0x80806B76
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA07OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA07OC"
    VALUE
    0x80806B77
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA07Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA07Unintended"
    VALUE
    0x80806B78
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA08OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA08OC"
    VALUE
    0x80806B79
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA08Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA08Unintended"
    VALUE
    0x80806B7A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA09OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA09OC"
    VALUE
    0x80806B7B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA09Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA09Unintended"
    VALUE
    0x80806B7C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA10OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA10OC"
    VALUE
    0x80806B7D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA10Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA10Unintended"
    VALUE
    0x80806B7E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA17OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA17OC"
    VALUE
    0x80806B7F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA17Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA17Unintended"
    VALUE
    0x80806B80
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA18OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA18OC"
    VALUE
    0x80806B81
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA18Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA18Unintended"
    VALUE
    0x80806B82
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA19OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA19OC"
    VALUE
    0x80806B83
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA19Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA19Unintended"
    VALUE
    0x80806B84
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA20OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA20OC"
    VALUE
    0x80806B85
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA20Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA20Unintended"
    VALUE
    0x80806B86
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA31OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA31OC"
    VALUE
    0x80806B87
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA31Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA31Unintended"
    VALUE
    0x80806B88
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA32OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA32OC"
    VALUE
    0x80806B89
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA32Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA32Unintended"
    VALUE
    0x80806B8A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA33OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA33OC"
    VALUE
    0x80806B8B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA33Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA33Unintended"
    VALUE
    0x80806B8C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA34OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA34OC"
    VALUE
    0x80806B8D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA34Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA34Unintended"
    VALUE
    0x80806B8E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA35OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA35OC"
    VALUE
    0x80806B8F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA35Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA35Unintended"
    VALUE
    0x80806B90
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA46OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA46OC"
    VALUE
    0x80806B91
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA46Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA46Unintended"
    VALUE
    0x80806B92
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA47OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA47OC"
    VALUE
    0x80806B93
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA47Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA47Unintended"
    VALUE
    0x80806B94
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA48OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA48OC"
    VALUE
    0x80806B95
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA48Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA48Unintended"
    VALUE
    0x80806B96
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA51OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA51OC"
    VALUE
    0x80806B97
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA51Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA51Unintended"
    VALUE
    0x80806B98
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA52OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA52OC"
    VALUE
    0x80806B99
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA52Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA52Unintended"
    VALUE
    0x80806B9A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA53OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA53OC"
    VALUE
    0x80806B9B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA53Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA53Unintended"
    VALUE
    0x80806B9C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA54OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA54OC"
    VALUE
    0x80806B9D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA54Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA54Unintended"
    VALUE
    0x80806B9E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outAov_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outAov"
    VALUE
    0x80806B9F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outAovCfg_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outAovCfg"
    VALUE
    0x80806BA0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outAovCfgPI_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outAovCfgPI"
    VALUE
    0x80806BA1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outAovGetStatus_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outAovGetStatus"
    VALUE
    0x80806BA2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outAovGetVoltage_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outAovGetVoltage"
    VALUE
    0x80806BA3
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outAovResetError_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outAovResetError"
    VALUE
    0x80806BA4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outDo_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outDo"
    VALUE
    0x80806BA5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outDoCfgPwrLs_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outDoCfgPwrLs"
    VALUE
    0x80806BA6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outDoDisable_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outDoDisable"
    VALUE
    0x80806BA7
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outDoGetCurrent_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outDoGetCurrent"
    VALUE
    0x80806BA8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outDoGetStatus_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outDoGetStatus"
    VALUE
    0x80806BA9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outDoResetError_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outDoResetError"
    VALUE
    0x80806BAA
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK07OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK07OC"
    VALUE
    0x80806BAB
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK07Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK07Unintended"
    VALUE
    0x80806BAC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK08OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK08OC"
    VALUE
    0x80806BAD
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK08Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK08Unintended"
    VALUE
    0x80806BAE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK09OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK09OC"
    VALUE
    0x80806BAF
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK09Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK09Unintended"
    VALUE
    0x80806BB0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK12OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK12OC"
    VALUE
    0x80806BB1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK12Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK12Unintended"
    VALUE
    0x80806BB2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK13OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK13OC"
    VALUE
    0x80806BB3
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK13Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK13Unintended"
    VALUE
    0x80806BB4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK14OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK14OC"
    VALUE
    0x80806BB5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK14Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK14Unintended"
    VALUE
    0x80806BB6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK15OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK15OC"
    VALUE
    0x80806BB7
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK15Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK15Unintended"
    VALUE
    0x80806BB8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK16OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK16OC"
    VALUE
    0x80806BB9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK16Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK16Unintended"
    VALUE
    0x80806BBA
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK17OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK17OC"
    VALUE
    0x80806BBB
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK17Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK17Unintended"
    VALUE
    0x80806BBC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK29OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK29OC"
    VALUE
    0x80806BBD
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK29Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK29Unintended"
    VALUE
    0x80806BBE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK51OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK51OC"
    VALUE
    0x80806BBF
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK51Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK51Unintended"
    VALUE
    0x80806BC0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK73OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK73OC"
    VALUE
    0x80806BC1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK73Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK73Unintended"
    VALUE
    0x80806BC2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outPo_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outPo"
    VALUE
    0x80806BC3
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outPoCfg_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outPoCfg"
    VALUE
    0x80806BC4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outPoCfgPeriod_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outPoCfgPeriod"
    VALUE
    0x80806BC5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outPoCfgPwrLs_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outPoCfgPwrLs"
    VALUE
    0x80806BC6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outPoDisable_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outPoDisable"
    VALUE
    0x80806BC7
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outPoGetCurrent_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outPoGetCurrent"
    VALUE
    0x80806BC8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outPoGetStatus_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outPoGetStatus"
    VALUE
    0x80806BC9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outPoResetError_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outPoResetError"
    VALUE
    0x80806BCA
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outPoc_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outPoc"
    VALUE
    0x80806BCB
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outPocCfg_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outPocCfg"
    VALUE
    0x80806BCC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outPocCfgDither_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outPocCfgDither"
    VALUE
    0x80806BCD
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outPocCfgPI_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outPocCfgPI"
    VALUE
    0x80806BCE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outPod_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outPod"
    VALUE
    0x80806BCF
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outPodCfg_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outPodCfg"
    VALUE
    0x80806BD0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outPodCfgPeriod_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outPodCfgPeriod"
    VALUE
    0x80806BD1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_rsmFfiApiCallErr_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_rsmFfiApiCallErr"
    VALUE
    0x80806BD2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safout_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safout"
    VALUE
    0x80806BD3
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutCfg_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutCfg"
    VALUE
    0x80806BD4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl1_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl1"
    VALUE
    0x80806BD5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl10_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl10"
    VALUE
    0x80806BD6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl10Dev_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl10Dev"
    VALUE
    0x80806BD7
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl10OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl10OR"
    VALUE
    0x80806BD8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl11_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl11"
    VALUE
    0x80806BD9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl11Dev_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl11Dev"
    VALUE
    0x80806BDA
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl11OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl11OR"
    VALUE
    0x80806BDB
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl12_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl12"
    VALUE
    0x80806BDC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl12Dev_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl12Dev"
    VALUE
    0x80806BDD
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl12OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl12OR"
    VALUE
    0x80806BDE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl13_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl13"
    VALUE
    0x80806BDF
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl13Dev_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl13Dev"
    VALUE
    0x80806BE0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl13OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl13OR"
    VALUE
    0x80806BE1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl14_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl14"
    VALUE
    0x80806BE2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl14Dev_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl14Dev"
    VALUE
    0x80806BE3
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl14OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl14OR"
    VALUE
    0x80806BE4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl15_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl15"
    VALUE
    0x80806BE5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl15Dev_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl15Dev"
    VALUE
    0x80806BE6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl15OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl15OR"
    VALUE
    0x80806BE7
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl16_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl16"
    VALUE
    0x80806BE8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl16Dev_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl16Dev"
    VALUE
    0x80806BE9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl16OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl16OR"
    VALUE
    0x80806BEA
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl17_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl17"
    VALUE
    0x80806BEB
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl17Dev_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl17Dev"
    VALUE
    0x80806BEC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl17OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl17OR"
    VALUE
    0x80806BED
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl18_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl18"
    VALUE
    0x80806BEE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl18Dev_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl18Dev"
    VALUE
    0x80806BEF
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl18OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl18OR"
    VALUE
    0x80806BF0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl1Dev_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl1Dev"
    VALUE
    0x80806BF1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl1OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl1OR"
    VALUE
    0x80806BF2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl2_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl2"
    VALUE
    0x80806BF3
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl2Dev_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl2Dev"
    VALUE
    0x80806BF4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl2OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl2OR"
    VALUE
    0x80806BF5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl3_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl3"
    VALUE
    0x80806BF6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl3Dev_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl3Dev"
    VALUE
    0x80806BF7
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl3OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl3OR"
    VALUE
    0x80806BF8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl4_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl4"
    VALUE
    0x80806BF9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl4Dev_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl4Dev"
    VALUE
    0x80806BFA
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl4OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl4OR"
    VALUE
    0x80806BFB
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl5_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl5"
    VALUE
    0x80806BFC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl5Dev_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl5Dev"
    VALUE
    0x80806BFD
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl5OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl5OR"
    VALUE
    0x80806BFE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl6_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl6"
    VALUE
    0x80806BFF
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl6Dev_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl6Dev"
    VALUE
    0x80806C00
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl6OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl6OR"
    VALUE
    0x80806C01
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl7_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl7"
    VALUE
    0x80806C02
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl7Dev_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl7Dev"
    VALUE
    0x80806C03
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl7OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl7OR"
    VALUE
    0x80806C04
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl8_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl8"
    VALUE
    0x80806C05
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl8Dev_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl8Dev"
    VALUE
    0x80806C06
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl8OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl8OR"
    VALUE
    0x80806C07
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl9_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl9"
    VALUE
    0x80806C08
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl9Dev_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl9Dev"
    VALUE
    0x80806C09
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl9OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl9OR"
    VALUE
    0x80806C0A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutDevError_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutDevError"
    VALUE
    0x80806C0B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutGetStatus_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutGetStatus"
    VALUE
    0x80806C0C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutIgnoreError_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutIgnoreError"
    VALUE
    0x80806C0D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutResetError_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutResetError"
    VALUE
    0x80806C0E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutUnlock_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutUnlock"
    VALUE
    0x80806C0F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safout_cfgDiag_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safout_cfgDiag"
    VALUE
    0x80806C10
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_secAccessDenied_RC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_secAccessDenied_RC"
    VALUE
    0x80806C11
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_secAccessDenied_WDBI_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_secAccessDenied_WDBI"
    VALUE
    0x80806C12
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_secEvalRespKey_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_secEvalRespKey"
    VALUE
    0x80806C13
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_secFlashingFailure_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_secFlashingFailure"
    VALUE
    0x80806C14
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_secGetLevel_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_secGetLevel"
    VALUE
    0x80806C15
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_secGetRnd_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_secGetRnd"
    VALUE
    0x80806C16
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_secGetSeed_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_secGetSeed"
    VALUE
    0x80806C17
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_secInvalidPassword_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_secInvalidPassword"
    VALUE
    0x80806C18
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_secIsRequestAllowed_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_secIsRequestAllowed"
    VALUE
    0x80806C19
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_secResetLevel_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_secResetLevel"
    VALUE
    0x80806C1A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_secSaveSecret_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_secSaveSecret"
    VALUE
    0x80806C1B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_secSetLevel_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_secSetLevel"
    VALUE
    0x80806C1C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_sysAit_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_sysAit"
    VALUE
    0x80806C1D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_sysAiv_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_sysAiv"
    VALUE
    0x80806C1E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_sysDi_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_sysDi"
    VALUE
    0x80806C1F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_sysDo_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_sysDo"
    VALUE
    0x80806C20
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_sysGetVss_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_sysGetVss"
    VALUE
    0x80806C21
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_sysInit_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_sysInit"
    VALUE
    0x80806C22
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_sysOperHrIntegrityErr_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_sysOperHrIntegrityErr"
    VALUE
    0x80806C23
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_sysOperHrsSaturated_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_sysOperHrsSaturated"
    VALUE
    0x80806C24
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_sysSetVss_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_sysSetVss"
    VALUE
    0x80806C25
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_sys_coreload_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_sys_coreload"
    VALUE
    0x80806C26
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_sys_taskload_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_sys_taskload"
    VALUE
    0x80806C27
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_OV_VSS1_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_OV_VSS1"
    VALUE
    0x80806C28
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_OV_VSS2_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_OV_VSS2"
    VALUE
    0x80806C29
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_UV_VSS1_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_UV_VSS1"
    VALUE
    0x80806C2A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_UV_VSS2_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_UV_VSS2"
    VALUE
    0x80806C2B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_CANSM_E_BUS_OFF_NETWORK_0_C
    "AUTOSAR: Functional unit of DTC / Check DFC_CANSM_E_BUS_OFF_NETWORK_0"
    VALUE
    0x80806C2C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_CANSM_E_BUS_OFF_NETWORK_1_C
    "AUTOSAR: Functional unit of DTC / Check DFC_CANSM_E_BUS_OFF_NETWORK_1"
    VALUE
    0x80806C2D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_CANSM_E_BUS_OFF_NETWORK_2_C
    "AUTOSAR: Functional unit of DTC / Check DFC_CANSM_E_BUS_OFF_NETWORK_2"
    VALUE
    0x80806C2E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_CANSM_E_BUS_OFF_NETWORK_3_C
    "AUTOSAR: Functional unit of DTC / Check DFC_CANSM_E_BUS_OFF_NETWORK_3"
    VALUE
    0x80806C2F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_CANTRCV_E_NO_TRCV_CONTROL_0_C
    "AUTOSAR: Functional unit of DTC / Check DFC_CANTRCV_E_NO_TRCV_CONTROL_0"
    VALUE
    0x80806C30
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_CAN_E_TIMEOUT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_CAN_E_TIMEOUT"
    VALUE
    0x80806C31
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_COMM_E_NET_START_IND_CHANNEL_0_C
    "AUTOSAR: Functional unit of DTC / Check DFC_COMM_E_NET_START_IND_CHANNEL_0"
    VALUE
    0x80806C32
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_COMM_E_NET_START_IND_CHANNEL_1_C
    "AUTOSAR: Functional unit of DTC / Check DFC_COMM_E_NET_START_IND_CHANNEL_1"
    VALUE
    0x80806C33
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_COMM_E_NET_START_IND_CHANNEL_2_C
    "AUTOSAR: Functional unit of DTC / Check DFC_COMM_E_NET_START_IND_CHANNEL_2"
    VALUE
    0x80806C34
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_COMM_E_NET_START_IND_CHANNEL_3_C
    "AUTOSAR: Functional unit of DTC / Check DFC_COMM_E_NET_START_IND_CHANNEL_3"
    VALUE
    0x80806C35
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_COMM_E_NET_START_IND_CHANNEL_4_C
    "AUTOSAR: Functional unit of DTC / Check DFC_COMM_E_NET_START_IND_CHANNEL_4"
    VALUE
    0x80806C36
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_COMM_E_NET_START_IND_CHANNEL_5_C
    "AUTOSAR: Functional unit of DTC / Check DFC_COMM_E_NET_START_IND_CHANNEL_5"
    VALUE
    0x80806C37
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_LIN_E_TIMEOUT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_LIN_E_TIMEOUT"
    VALUE
    0x80806C38
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rba_MultiStackTrace_Threshold_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rba_MultiStackTrace_Threshold"
    VALUE
    0x80806C39
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_ETH_E_ACCESS_0_C
    "AUTOSAR: Functional unit of DTC / Check DFC_ETH_E_ACCESS_0"
    VALUE
    0x80806C3A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_RBA_IOEXTLIB_KEEPALIVE_DRV_C
    "AUTOSAR: Functional unit of DTC / Check DFC_RBA_IOEXTLIB_KEEPALIVE_DRV"
    VALUE
    0x80806C3B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_RBA_IOEXTLIB_KEEPALIVE_INI_C
    "AUTOSAR: Functional unit of DTC / Check DFC_RBA_IOEXTLIB_KEEPALIVE_INI"
    VALUE
    0x80806C3C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rba_MRly_Diag_Stk_Event_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rba_MRly_Diag_Stk_Event"
    VALUE
    0x80806C3D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rba_MemDiagExtd_MemReadSngErr_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rba_MemDiagExtd_MemReadSngErr"
    VALUE
    0x80806C3E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rba_MemDiag_MemReadErr_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rba_MemDiag_MemReadErr"
    VALUE
    0x80806C3F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rba_MemDiag_MemWrErr_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rba_MemDiag_MemWrErr"
    VALUE
    0x80806C40
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rba_SyC_IrrSwOffTrigEngRun_Event_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rba_SyC_IrrSwOffTrigEngRun_Event"
    VALUE
    0x80806C41
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rba_T15_Diag_ComInVld_Event_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rba_T15_Diag_ComInVld_Event"
    VALUE
    0x80806C42
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rba_T15_Diag_ComOff_HwOn_Event_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rba_T15_Diag_ComOff_HwOn_Event"
    VALUE
    0x80806C43
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rba_T15_Diag_ComOn_HwOff_Event_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rba_T15_Diag_ComOn_HwOff_Event"
    VALUE
    0x80806C44
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM0_0_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM0_0"
    VALUE
    0x80806C45
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM0_1_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM0_1"
    VALUE
    0x80806C46
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM0_10_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM0_10"
    VALUE
    0x80806C47
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM0_11_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM0_11"
    VALUE
    0x80806C48
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM0_13_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM0_13"
    VALUE
    0x80806C49
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM0_14_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM0_14"
    VALUE
    0x80806C4A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM0_2_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM0_2"
    VALUE
    0x80806C4B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM0_22_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM0_22"
    VALUE
    0x80806C4C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM0_23_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM0_23"
    VALUE
    0x80806C4D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM0_4_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM0_4"
    VALUE
    0x80806C4E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM0_5_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM0_5"
    VALUE
    0x80806C4F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM0_7_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM0_7"
    VALUE
    0x80806C50
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM0_8_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM0_8"
    VALUE
    0x80806C51
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM10_16_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM10_16"
    VALUE
    0x80806C52
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM10_17_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM10_17"
    VALUE
    0x80806C53
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM10_21_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM10_21"
    VALUE
    0x80806C54
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM11_0_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM11_0"
    VALUE
    0x80806C55
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM11_1_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM11_1"
    VALUE
    0x80806C56
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM11_2_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM11_2"
    VALUE
    0x80806C57
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM11_3_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM11_3"
    VALUE
    0x80806C58
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM11_4_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM11_4"
    VALUE
    0x80806C59
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM11_5_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM11_5"
    VALUE
    0x80806C5A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM11_8_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM11_8"
    VALUE
    0x80806C5B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM11_9_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM11_9"
    VALUE
    0x80806C5C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM1_0_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM1_0"
    VALUE
    0x80806C5D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM1_1_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM1_1"
    VALUE
    0x80806C5E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM1_10_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM1_10"
    VALUE
    0x80806C5F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM1_11_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM1_11"
    VALUE
    0x80806C60
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM1_13_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM1_13"
    VALUE
    0x80806C61
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM1_14_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM1_14"
    VALUE
    0x80806C62
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM1_2_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM1_2"
    VALUE
    0x80806C63
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM1_22_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM1_22"
    VALUE
    0x80806C64
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM1_23_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM1_23"
    VALUE
    0x80806C65
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM1_4_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM1_4"
    VALUE
    0x80806C66
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM1_5_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM1_5"
    VALUE
    0x80806C67
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM1_7_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM1_7"
    VALUE
    0x80806C68
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM1_8_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM1_8"
    VALUE
    0x80806C69
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM21_0_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM21_0"
    VALUE
    0x80806C6A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM21_16_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM21_16"
    VALUE
    0x80806C6B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM21_3_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM21_3"
    VALUE
    0x80806C6C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM2_1_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM2_1"
    VALUE
    0x80806C6D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM2_10_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM2_10"
    VALUE
    0x80806C6E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM2_11_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM2_11"
    VALUE
    0x80806C6F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM2_13_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM2_13"
    VALUE
    0x80806C70
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM2_14_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM2_14"
    VALUE
    0x80806C71
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM2_2_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM2_2"
    VALUE
    0x80806C72
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM2_22_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM2_22"
    VALUE
    0x80806C73
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM2_23_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM2_23"
    VALUE
    0x80806C74
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM2_4_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM2_4"
    VALUE
    0x80806C75
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM2_5_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM2_5"
    VALUE
    0x80806C76
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM2_7_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM2_7"
    VALUE
    0x80806C77
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM2_8_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM2_8"
    VALUE
    0x80806C78
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM3_1_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM3_1"
    VALUE
    0x80806C79
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM3_10_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM3_10"
    VALUE
    0x80806C7A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM3_11_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM3_11"
    VALUE
    0x80806C7B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM3_13_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM3_13"
    VALUE
    0x80806C7C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM3_14_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM3_14"
    VALUE
    0x80806C7D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM3_2_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM3_2"
    VALUE
    0x80806C7E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM3_22_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM3_22"
    VALUE
    0x80806C7F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM3_23_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM3_23"
    VALUE
    0x80806C80
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM3_4_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM3_4"
    VALUE
    0x80806C81
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM3_5_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM3_5"
    VALUE
    0x80806C82
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM3_7_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM3_7"
    VALUE
    0x80806C83
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM3_8_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM3_8"
    VALUE
    0x80806C84
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM6_0_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM6_0"
    VALUE
    0x80806C85
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM6_11_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM6_11"
    VALUE
    0x80806C86
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM6_12_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM6_12"
    VALUE
    0x80806C87
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM6_14_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM6_14"
    VALUE
    0x80806C88
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM6_15_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM6_15"
    VALUE
    0x80806C89
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM6_17_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM6_17"
    VALUE
    0x80806C8A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM6_18_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM6_18"
    VALUE
    0x80806C8B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM6_2_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM6_2"
    VALUE
    0x80806C8C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM6_20_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM6_20"
    VALUE
    0x80806C8D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM6_21_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM6_21"
    VALUE
    0x80806C8E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM6_25_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM6_25"
    VALUE
    0x80806C8F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM6_4_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM6_4"
    VALUE
    0x80806C90
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM6_5_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM6_5"
    VALUE
    0x80806C91
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM6_7_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM6_7"
    VALUE
    0x80806C92
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM6_8_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM6_8"
    VALUE
    0x80806C93
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM7_1_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM7_1"
    VALUE
    0x80806C94
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM7_12_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM7_12"
    VALUE
    0x80806C95
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM7_13_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM7_13"
    VALUE
    0x80806C96
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM7_14_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM7_14"
    VALUE
    0x80806C97
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM7_15_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM7_15"
    VALUE
    0x80806C98
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM7_16_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM7_16"
    VALUE
    0x80806C99
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM7_17_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM7_17"
    VALUE
    0x80806C9A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM7_2_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM7_2"
    VALUE
    0x80806C9B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM7_20_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM7_20"
    VALUE
    0x80806C9C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM7_25_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM7_25"
    VALUE
    0x80806C9D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM7_26_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM7_26"
    VALUE
    0x80806C9E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM7_28_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM7_28"
    VALUE
    0x80806C9F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM7_29_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM7_29"
    VALUE
    0x80806CA0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM7_30_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM7_30"
    VALUE
    0x80806CA1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM7_31_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM7_31"
    VALUE
    0x80806CA2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM8_0_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM8_0"
    VALUE
    0x80806CA3
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM8_1_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM8_1"
    VALUE
    0x80806CA4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM8_10_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM8_10"
    VALUE
    0x80806CA5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM8_11_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM8_11"
    VALUE
    0x80806CA6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM8_12_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM8_12"
    VALUE
    0x80806CA7
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM8_13_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM8_13"
    VALUE
    0x80806CA8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM8_16_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM8_16"
    VALUE
    0x80806CA9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM8_18_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM8_18"
    VALUE
    0x80806CAA
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM8_2_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM8_2"
    VALUE
    0x80806CAB
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM8_3_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM8_3"
    VALUE
    0x80806CAC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM8_30_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM8_30"
    VALUE
    0x80806CAD
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM8_31_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM8_31"
    VALUE
    0x80806CAE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM8_4_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM8_4"
    VALUE
    0x80806CAF
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM9_0_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM9_0"
    VALUE
    0x80806CB0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM9_1_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM9_1"
    VALUE
    0x80806CB1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM9_15_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM9_15"
    VALUE
    0x80806CB2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM9_3_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM9_3"
    VALUE
    0x80806CB3
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MoCSOPICO_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MoCSOPICO"
    VALUE
    0x80806CB4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MoFVarPostBldSel_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MoFVarPostBldSel"
    VALUE
    0x80806CB5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MoSysCtrlReIni_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MoSysCtrlReIni"
    VALUE
    0x80806CB6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MoXEMMHwLTMCUFW_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MoXEMMHwLTMCUFW"
    VALUE
    0x80806CB7
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MoXEMMHwLTMonBIST_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MoXEMMHwLTMonBIST"
    VALUE
    0x80806CB8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MoXEMMHwLTRegMonTest_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MoXEMMHwLTRegMonTest"
    VALUE
    0x80806CB9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MoXEMMHwLTStbySMUAlvTest_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MoXEMMHwLTStbySMUAlvTest"
    VALUE
    0x80806CBA
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MoXEMMHwLTTempSens_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MoXEMMHwLTTempSens"
    VALUE
    0x80806CBB
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MoXEMMHwLTUCBCfg_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MoXEMMHwLTUCBCfg"
    VALUE
    0x80806CBC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_OCWDAABEActv_C
    "AUTOSAR: Functional unit of DTC / Check DFC_OCWDAABEActv"
    VALUE
    0x80806CBD
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_OCWDACom_C
    "AUTOSAR: Functional unit of DTC / Check DFC_OCWDACom"
    VALUE
    0x80806CBE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_OCWDAErrPin_C
    "AUTOSAR: Functional unit of DTC / Check DFC_OCWDAErrPin"
    VALUE
    0x80806CBF
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_SWReset_0_C
    "AUTOSAR: Functional unit of DTC / Check DFC_SWReset_0"
    VALUE
    0x80806CC0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_SWReset_1_C
    "AUTOSAR: Functional unit of DTC / Check DFC_SWReset_1"
    VALUE
    0x80806CC1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_SWReset_2_C
    "AUTOSAR: Functional unit of DTC / Check DFC_SWReset_2"
    VALUE
    0x80806CC2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDebFault1_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDebFault1"
    VALUE
    0x80806CC3
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_Unused_C
    "AUTOSAR: Matching DTC group / Check DFC_Unused"
    VALUE
    0x808064A8
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    READ_ONLY

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_TimeInRowDebFault_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_TimeInRowDebFault"
    VALUE
    0x808064A9
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_EventInRowDebFault_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_EventInRowDebFault"
    VALUE
    0x808064AA
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_DevLibBattUHi_C
    "AUTOSAR: Matching DTC group / Check DFC_DevLibBattUHi"
    VALUE
    0x808064AB
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_DevLibBattULo_C
    "AUTOSAR: Matching DTC group / Check DFC_DevLibBattULo"
    VALUE
    0x808064AC
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_TimeUpDownDebFault_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_TimeUpDownDebFault"
    VALUE
    0x808064AD
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA13OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA13OR"
    VALUE
    0x808064AE
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA13SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA13SCB"
    VALUE
    0x808064AF
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA13SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA13SCG"
    VALUE
    0x808064B0
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA14OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA14OR"
    VALUE
    0x808064B1
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA14SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA14SCB"
    VALUE
    0x808064B2
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA14SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA14SCG"
    VALUE
    0x808064B3
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA21OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA21OR"
    VALUE
    0x808064B4
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA21SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA21SCB"
    VALUE
    0x808064B5
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA21SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA21SCG"
    VALUE
    0x808064B6
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA22OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA22OR"
    VALUE
    0x808064B7
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA22SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA22SCB"
    VALUE
    0x808064B8
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA22SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA22SCG"
    VALUE
    0x808064B9
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA23OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA23OR"
    VALUE
    0x808064BA
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA23SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA23SCB"
    VALUE
    0x808064BB
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA23SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA23SCG"
    VALUE
    0x808064BC
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA24OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA24OR"
    VALUE
    0x808064BD
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA24SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA24SCB"
    VALUE
    0x808064BE
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA24SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA24SCG"
    VALUE
    0x808064BF
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA25OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA25OR"
    VALUE
    0x808064C0
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA25SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA25SCB"
    VALUE
    0x808064C1
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA25SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA25SCG"
    VALUE
    0x808064C2
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA26OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA26OR"
    VALUE
    0x808064C3
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA26SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA26SCB"
    VALUE
    0x808064C4
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA26SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA26SCG"
    VALUE
    0x808064C5
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA27OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA27OR"
    VALUE
    0x808064C6
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA27SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA27SCB"
    VALUE
    0x808064C7
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA27SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA27SCG"
    VALUE
    0x808064C8
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA28OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA28OR"
    VALUE
    0x808064C9
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA28SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA28SCB"
    VALUE
    0x808064CA
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA28SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA28SCG"
    VALUE
    0x808064CB
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA29OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA29OR"
    VALUE
    0x808064CC
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA29SCB_C
