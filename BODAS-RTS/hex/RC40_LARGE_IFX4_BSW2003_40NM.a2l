    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD38

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA08OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA08OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD3C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA08SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA08SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD40

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA08SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA08SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD44

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA09OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA09OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD48

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA09OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA09OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD4C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA09OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA09OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD50

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA09SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA09SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD54

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA09SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA09SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD58

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA10OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA10OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD5C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA10OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA10OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD60

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA10SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA10SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD64

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA10SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA10SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD68

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA11OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA11OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD6C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA11OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA11OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD70

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA11SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA11SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD74

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA11SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA11SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD78

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA12OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA12OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD7C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA12SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA12SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD80

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA12SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA12SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD84

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA16OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA16OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD88

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA16OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA16OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD8C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA16SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA16SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD90

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA16SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA16SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD94

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA17OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA17OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD98

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA17OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA17OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD9C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA17OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA17OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ADA0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA17SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA17SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ADA4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA17SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA17SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ADA8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA18OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA18OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ADAC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA18OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA18OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ADB0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA18SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA18SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ADB4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA18SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA18SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ADB8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA19OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA19OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ADBC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA19OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA19OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ADC0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA19OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA19OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ADC4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA19SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA19SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ADC8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA19SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA19SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ADCC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA20OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA20OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ADD0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA20OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA20OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ADD4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA20OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA20OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ADD8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA20SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA20SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ADDC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA20SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA20SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ADE0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA31OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA31OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ADE4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA31OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA31OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ADE8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA31OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA31OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ADEC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA31SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA31SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ADF0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA31SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA31SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ADF4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA32OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA32OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ADF8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA32OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA32OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ADFC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA32OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA32OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE00

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA32SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA32SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE04

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA32SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA32SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE08

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA33OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA33OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE0C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA33OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA33OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE10

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA33OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA33OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE14

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA33SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA33SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE18

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA33SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA33SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE1C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA34OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA34OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE20

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA34OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA34OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE24

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA34OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA34OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE28

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA34SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA34SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE2C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA34SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA34SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE30

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA35OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA35OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE34

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA35OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA35OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE38

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA35OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA35OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE3C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA35SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA35SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE40

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA35SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA35SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE44

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA46OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA46OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE48

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA46OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA46OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE4C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA46OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA46OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE50

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA46SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA46SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE54

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA46SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA46SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE58

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA47OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA47OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE5C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA47OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA47OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE60

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA47OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA47OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE64

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA47SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA47SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE68

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA47SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA47SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE6C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA48OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA48OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE70

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA48OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA48OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE74

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA48OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA48OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE78

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA48SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA48SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE7C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA48SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA48SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE80

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA49OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA49OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE84

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA49OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA49OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE88

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA49SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA49SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE8C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA49SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA49SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE90

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA50OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA50OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE94

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA50OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA50OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE98

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA50SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA50SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE9C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA50SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA50SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AEA0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA51OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA51OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AEA4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA51OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA51OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AEA8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA51OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA51OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AEAC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA51SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA51SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AEB0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA51SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA51SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AEB4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA52OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA52OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AEB8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA52OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA52OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AEBC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA52OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA52OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AEC0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA52SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA52SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AEC4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA52SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA52SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AEC8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA53OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA53OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AECC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA53OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA53OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AED0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA53OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA53OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AED4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA53SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA53SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AED8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA53SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA53SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AEDC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA54OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA54OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AEE0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA54OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA54OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AEE4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA54OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA54OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AEE8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA54SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA54SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AEEC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA54SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA54SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AEF0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA55OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA55OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AEF4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA55OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA55OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AEF8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA55SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA55SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AEFC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA55SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA55SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF00

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA56OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA56OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF04

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA56OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA56OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF08

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA56SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA56SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF0C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA56SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA56SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF10

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA58OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA58OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF14

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA58OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA58OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF18

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA58SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA58SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF1C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA58SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA58SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF20

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK07OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK07OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF24

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK07OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK07OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF28

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK07OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK07OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF2C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK07SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK07SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF30

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK07SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK07SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF34

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK08OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK08OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF38

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK08OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK08OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF3C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK08OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK08OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF40

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK08SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK08SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF44

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK08SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK08SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF48

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK09OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK09OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF4C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK09OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK09OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF50

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK09OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK09OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF54

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK09SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK09SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF58

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK09SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK09SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF5C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK12OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK12OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF60

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK12OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK12OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF64

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK12SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK12SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF68

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK12SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK12SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF6C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK13OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK13OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF70

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK13OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK13OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF74

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK13SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK13SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF78

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK13SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK13SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF7C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK14OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK14OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF80

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK14OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK14OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF84

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK14OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK14OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF88

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK14SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK14SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF8C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK14SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK14SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF90

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK15OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK15OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF94

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK15OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK15OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF98

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK15OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK15OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF9C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK15SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK15SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AFA0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK15SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK15SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AFA4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK16OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK16OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AFA8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK16OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK16OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AFAC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK16OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK16OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AFB0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK16SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK16SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AFB4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK16SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK16SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AFB8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK17OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK17OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AFBC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK17OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK17OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AFC0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK17OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK17OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AFC4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK17SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK17SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AFC8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK17SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK17SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AFCC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK25OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK25OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AFD0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK25SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK25SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AFD4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK25SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK25SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AFD8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK29OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK29OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AFDC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK29OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK29OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AFE0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK29OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK29OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AFE4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK29SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK29SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AFE8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK29SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK29SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AFEC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK51OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK51OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AFF0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK51OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK51OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AFF4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK51SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK51SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AFF8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK51SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK51SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AFFC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK62OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK62OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000B000

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK62SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK62SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000B004

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK62SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK62SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000B008

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK73OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK73OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000B00C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK73OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK73OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000B010

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK73OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK73OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000B014

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK73SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK73SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000B018

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK73SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK73SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000B01C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK80OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK80OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000B020

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK80OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK80OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000B024

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK80SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK80SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000B028

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK80SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK80SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000B02C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK81OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK81OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000B030

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK81OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK81OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000B034

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK81SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK81SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000B038

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK81SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK81SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000B03C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK82OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK82OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000B040

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK82OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK82OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000B044

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK82SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK82SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000B048

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK82SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK82SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000B04C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK83OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK83OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000B050

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK83OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK83OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000B054

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK83SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK83SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000B058

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK83SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK83SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000B05C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK84OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK84OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000B060

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK84OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK84OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000B064

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK84SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK84SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000B068

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK84SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK84SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000B06C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK85OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK85OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000B070

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK85OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK85OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000B074

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK85SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK85SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000B078

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK85SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK85SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000B07C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK86OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK86OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000B080

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK86OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK86OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000B084

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK86SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK86SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000B088

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK86SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK86SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000B08C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK87OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK87OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000B090

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK87OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK87OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000B094

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK87SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK87SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000B098

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK87SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK87SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000B09C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_EventUpDownDebFault
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_EventUpDownDebFault"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000B0A0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_stLstRprtEve.DFC_rbr_mo_OV_VSS1
    "Monitoring state / Monitoring state of DFC_rbr_mo_OV_VSS1"
    UBYTE
    DDRC_LstRprtEve_VERB
    1
    100
    0.00
    255.000000000

    
    FORMAT "%13.9"
    
    ECU_ADDRESS 0x6000D153

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_stLstRprtEve.DFC_rbr_mo_OV_VSS2
    "Monitoring state / Monitoring state of DFC_rbr_mo_OV_VSS2"
    UBYTE
    DDRC_LstRprtEve_VERB
    1
    100
    0.00
    255.000000000

    
    FORMAT "%13.9"
    
    ECU_ADDRESS 0x6000D154

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_stLstRprtEve.DFC_rbr_mo_UV_VSS1
    "Monitoring state / Monitoring state of DFC_rbr_mo_UV_VSS1"
    UBYTE
    DDRC_LstRprtEve_VERB
    1
    100
    0.00
    255.000000000

    
    FORMAT "%13.9"
    
    ECU_ADDRESS 0x6000D155

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_stLstRprtEve.DFC_rbr_mo_UV_VSS2
    "Monitoring state / Monitoring state of DFC_rbr_mo_UV_VSS2"
    UBYTE
    DDRC_LstRprtEve_VERB
    1
    100
    0.00
    255.000000000

    
    FORMAT "%13.9"
    
    ECU_ADDRESS 0x6000D156

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_stLstRprtEve.DFC_CANSM_E_BUS_OFF_NETWORK_0
    "Monitoring state / Monitoring state of DFC_CANSM_E_BUS_OFF_NETWORK_0"
    UBYTE
    DDRC_LstRprtEve_VERB
    1
    100
    0.00
    255.000000000

    
    FORMAT "%13.9"
    
    ECU_ADDRESS 0x6000D157

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_stLstRprtEve.DFC_CANSM_E_BUS_OFF_NETWORK_1
    "Monitoring state / Monitoring state of DFC_CANSM_E_BUS_OFF_NETWORK_1"
    UBYTE
    DDRC_LstRprtEve_VERB
    1
    100
    0.00
    255.000000000

    
    FORMAT "%13.9"
    
    ECU_ADDRESS 0x6000D158

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_stLstRprtEve.DFC_CANSM_E_BUS_OFF_NETWORK_2
    "Monitoring state / Monitoring state of DFC_CANSM_E_BUS_OFF_NETWORK_2"
    UBYTE
    DDRC_LstRprtEve_VERB
    1
    100
    0.00
    255.000000000

    
    FORMAT "%13.9"
    
    ECU_ADDRESS 0x6000D159

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_stLstRprtEve.DFC_CANSM_E_BUS_OFF_NETWORK_3
    "Monitoring state / Monitoring state of DFC_CANSM_E_BUS_OFF_NETWORK_3"
    UBYTE
    DDRC_LstRprtEve_VERB
    1
    100
    0.00
    255.000000000

    
    FORMAT "%13.9"
    
    ECU_ADDRESS 0x6000D15A

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_stLstRprtEve.DFC_CANTRCV_E_NO_TRCV_CONTROL_0
    "Monitoring state / Monitoring state of DFC_CANTRCV_E_NO_TRCV_CONTROL_0"
    UBYTE
    DDRC_LstRprtEve_VERB
    1
    100
    0.00
    255.000000000

    
    FORMAT "%13.9"
    
    ECU_ADDRESS 0x6000D15B

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_stLstRprtEve.DFC_CAN_E_TIMEOUT
    "Monitoring state / Monitoring state of DFC_CAN_E_TIMEOUT"
    UBYTE
    DDRC_LstRprtEve_VERB
    1
    100
    0.00
    255.000000000

    
    FORMAT "%13.9"
    
    ECU_ADDRESS 0x6000D15C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_stLstRprtEve.DFC_COMM_E_NET_START_IND_CHANNEL_0
    "Monitoring state / Monitoring state of DFC_COMM_E_NET_START_IND_CHANNEL_0"
    UBYTE
    DDRC_LstRprtEve_VERB
    1
    100
    0.00
    255.000000000

    
    FORMAT "%13.9"
    
    ECU_ADDRESS 0x6000D15D

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_stLstRprtEve.DFC_COMM_E_NET_START_IND_CHANNEL_1
    "Monitoring state / Monitoring state of DFC_COMM_E_NET_START_IND_CHANNEL_1"
    UBYTE
    DDRC_LstRprtEve_VERB
    1
    100
    0.00
    255.000000000

    
    FORMAT "%13.9"
    
    ECU_ADDRESS 0x6000D15E

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_stLstRprtEve.DFC_COMM_E_NET_START_IND_CHANNEL_2
    "Monitoring state / Monitoring state of DFC_COMM_E_NET_START_IND_CHANNEL_2"
    UBYTE
    DDRC_LstRprtEve_VERB
    1
    100
    0.00
    255.000000000

    
    FORMAT "%13.9"
    
    ECU_ADDRESS 0x6000D15F

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_stLstRprtEve.DFC_COMM_E_NET_START_IND_CHANNEL_3
    "Monitoring state / Monitoring state of DFC_COMM_E_NET_START_IND_CHANNEL_3"
    UBYTE
    DDRC_LstRprtEve_VERB
    1
    100
    0.00
    255.000000000

    
    FORMAT "%13.9"
    
    ECU_ADDRESS 0x6000D160

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_stLstRprtEve.DFC_COMM_E_NET_START_IND_CHANNEL_4
    "Monitoring state / Monitoring state of DFC_COMM_E_NET_START_IND_CHANNEL_4"
    UBYTE
    DDRC_LstRprtEve_VERB
    1
    100
    0.00
    255.000000000

    
    FORMAT "%13.9"
    
    ECU_ADDRESS 0x6000D161

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_stLstRprtEve.DFC_COMM_E_NET_START_IND_CHANNEL_5
    "Monitoring state / Monitoring state of DFC_COMM_E_NET_START_IND_CHANNEL_5"
    UBYTE
    DDRC_LstRprtEve_VERB
    1
    100
    0.00
    255.000000000

    
    FORMAT "%13.9"
    
    ECU_ADDRESS 0x6000D162

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_stLstRprtEve.DFC_LIN_E_TIMEOUT
    "Monitoring state / Monitoring state of DFC_LIN_E_TIMEOUT"
    UBYTE
    DDRC_LstRprtEve_VERB
    1
    100
    0.00
    255.000000000

    
    FORMAT "%13.9"
    
    ECU_ADDRESS 0x6000D163

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_stLstRprtEve.DFC_rba_MultiStackTrace_Threshold
    "Monitoring state / Monitoring state of DFC_rba_MultiStackTrace_Threshold"
    UBYTE
    DDRC_LstRprtEve_VERB
    1
    100
    0.00
    255.000000000

    
    FORMAT "%13.9"
    
    ECU_ADDRESS 0x6000D164

/end MEASUREMENT

/begin MEASUREMENT

    DELib_idxArrSnsr
    "e_:SW Version of DELib calibration data:_e;d_:SW Version der Applikationsdaten:_d"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    MATRIX_DIM 8  
    ECU_ADDRESS 0x6000B54E

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    DELib_numVar_mp
    "SW Version variant of DELibPackage (110 = DELibPackage_1.1.0)"
    UWORD
    OneToOne
    1
    100
    0.
    65535.

    
    FORMAT "%10.0"
    
    ECU_ADDRESS 0x6000B5E8

/end MEASUREMENT

/begin MEASUREMENT

    DELib_num_mp
    "e_:SW Version of DELibPackage (1110 = DELibPackage.1.11.0):_e;d_:SW Version der DELibPackage 1110 = DELibPackage.1.11.0):_d"
    UWORD
    OneToOne
    1
    100
    0.
    65535.

    
    FORMAT "%10.0"
    
    ECU_ADDRESS 0x6000B5E6

/end MEASUREMENT

/begin MEASUREMENT

    DELib_stArrSnsr
    "e_:SW Version of DELib calibration data:_e;d_:SW Version der Applikationsdaten:_d"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    MATRIX_DIM 8  
    ECU_ADDRESS 0x6000C758

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    DELib_stFirstPreDrvOverCopy
    "status of First Pre Drive over copy"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C757

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    DELib_xArrSnsr
    "e_:Array to hold float values of sensors:_e;d_:SW Version der Applikationsdaten:_d"
    FLOAT32_IEEE
    OneToOne
    1
    100
    -1.00000000E+037
    1.00000000E+037

    
    FORMAT "%13.3"
    MATRIX_DIM 8  
    ECU_ADDRESS 0x600033A4

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Dem_BswErrorBufferWriteCounter
    "Write access counter"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x70009D4C

/end MEASUREMENT

/begin MEASUREMENT

    Dem_BswErrorBufferWriteIndex
    "Write index for pre init buffer"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x70009D4E

/end MEASUREMENT

/begin MEASUREMENT

    Dem_disableEventStatusUpdateGroup
    "Bit encoded DTCGroups disabled for EventStatusUpdate"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x7000B004

/end MEASUREMENT

/begin MEASUREMENT

    Dem_DTCFltForFltDetnCntr
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    MATRIX_DIM 2  
    ECU_ADDRESS 0x7000B007

/end MEASUREMENT

/begin MEASUREMENT

    Dem_DTCFltFormat
    "DTCFormat parameter of current Dem_SetDTCFilter() request"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    MATRIX_DIM 2  
    ECU_ADDRESS 0x7000B00F

/end MEASUREMENT

/begin MEASUREMENT

    Dem_DTCFltOrigin
    "DTCOrigin parameter of current Dem_SetDTCFilter() request"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    MATRIX_DIM 2  
    ECU_ADDRESS 0x70009BBC

/end MEASUREMENT

/begin MEASUREMENT

    Dem_DTCFltProcCnt
    "Number of DTCs found to current Dem_SetDTCFilter() request"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    MATRIX_DIM 2  
    ECU_ADDRESS 0x70009BC8

/end MEASUREMENT

/begin MEASUREMENT

    Dem_DTCFltProcIdx
    "Loop index for asynchron Dem_SetDTCFilter() processing"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    MATRIX_DIM 2  
    ECU_ADDRESS 0x70009BCC

/end MEASUREMENT

/begin MEASUREMENT

    Dem_DTCFltRecFormat
    "DTCFormat parameter of current Dem_SetFreezeFrameRecordFilter() request"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    MATRIX_DIM 2  
    ECU_ADDRESS 0x7000B009

/end MEASUREMENT

/begin MEASUREMENT

    Dem_DTCFltRecRsltIdx
    "Index variable for incremental GetNextFilteredRecord output"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    MATRIX_DIM 2  
    ECU_ADDRESS 0x70009BC0

/end MEASUREMENT

/begin MEASUREMENT

    Dem_DTCFltRsltIdx
    "Index variable for incremental GetNextFilteredDTCxxx output"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    MATRIX_DIM 2  
    ECU_ADDRESS 0x70009BC4

/end MEASUREMENT

/begin MEASUREMENT

    Dem_DTCFltSeverity
    "DTCSeverity parameter of current Dem_SetDTCFilter() request"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    MATRIX_DIM 2  
    ECU_ADDRESS 0x7000B00B

/end MEASUREMENT

/begin MEASUREMENT

    Dem_DTCFltSt
    "Current state of Dem_SetDTCFilter() processing"
    UBYTE
    Dem_DTCFltSt_Verb
    1
    100
    0.00
    5.00000000000

    
    FORMAT "%13.11"
    MATRIX_DIM 2  
    ECU_ADDRESS 0x7000B005

/end MEASUREMENT

/begin MEASUREMENT

    Dem_DTCFltStatusMask
    "DTCStatusMask parameter of current Dem_SetDTCFilter() request"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    MATRIX_DIM 2  
    ECU_ADDRESS 0x7000B011

/end MEASUREMENT

/begin MEASUREMENT

    Dem_DTCFltWithSev
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    MATRIX_DIM 2  
    ECU_ADDRESS 0x7000B00D

/end MEASUREMENT

/begin MEASUREMENT

    Dem_PTOSt
    "Current PTO active status reported to Dem"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x7000B0AE

/end MEASUREMENT

/begin MEASUREMENT

    Dem_stInit
    "Initialization state of Dem"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x7000B0CD

/end MEASUREMENT

/begin MEASUREMENT

    DevLib_stDigOutErr_mp
    "Measuring point that contains the error information received from HWE for the digital out signal selected by DevLib_DigOutDbgSig_C"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x7003017C

/end MEASUREMENT

/begin MEASUREMENT

    DevLib_stDigOutPrevTst_mp
    "Measuring point for the previous test result for the digital out signal selected by DevLib_DigOutDbgSig_C"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x700302EC

/end MEASUREMENT

/begin MEASUREMENT

    DevLib_stDigOutTstImp_mp
    "Measuring point for the frequency of the test impulse sent to the digital out powerstage selected by DevLib_DigOutDbgSig_C"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x700303A5

/end MEASUREMENT

/begin MEASUREMENT

    DevLib_stPWMOutErr_mp
    "Measuring point that contains the error information received from HWE for the PWM out signal selected by DevLib_PWMOutDbgSig_C"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x70030178

/end MEASUREMENT

/begin MEASUREMENT

    DevLib_stPWMOutPrevTst_mp
    "Measuring point for the previous test result for the PWM out signal selected by DevLib_PWMOutDbgSig_C"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x700302EA

/end MEASUREMENT

/begin MEASUREMENT

    DevLib_stPWMOutTstImp_mp
    "Measuring point for the frequency of the test impulse sent to the PWM out powerstage selected by DevLib_PWMOutDbgSig_C"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x700303A4

/end MEASUREMENT

/begin MEASUREMENT

    DevLib_stPwrStgEnaCond
    "Device Library - state of powerstage enabling conditions"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B54A

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    DFC_lenMaxCllsn
    "Measurement longest DFC Kollision"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x60037C88

/end MEASUREMENT

/begin MEASUREMENT

    DFC_nrCllsnClear
    "Number of DFC collisions at fcmclear"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x70002AA4

/end MEASUREMENT

/begin MEASUREMENT

    DFC_nrCllsnReInit
    "Number of DFC collisions at reInit"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x70002AA0

/end MEASUREMENT

/begin MEASUREMENT

    DFC_nrCllsnReport
    "Number of DFC collisions at report"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x70002A9C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_numDfcMaxCllsn
    "DFC which encountered the longest collision"
    UWORD
    DFCDFP_Verb
    1
    100
    0.00
    1009.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x60037C86

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_Unused
    "Status of DFC / "
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F1E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_TimeInRowDebFault
    "Status of DFC / Status of diagnostic fault check DFC_bds_TimeInRowDebFault"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F1F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_EventInRowDebFault
    "Status of DFC / Status of diagnostic fault check DFC_bds_EventInRowDebFault"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F20

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_DevLibBattUHi
    "Status of DFC / Status of diagnostic fault check DFC_DevLibBattUHi"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F21

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_DevLibBattULo
    "Status of DFC / Status of diagnostic fault check DFC_DevLibBattULo"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F22

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_TimeUpDownDebFault
    "Status of DFC / Status of diagnostic fault check DFC_bds_TimeUpDownDebFault"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F23

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA13OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA13OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F24

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA13SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA13SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F25

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA13SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA13SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F26

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA14OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA14OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F27

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA14SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA14SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F28

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA14SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA14SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F29

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA21OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA21OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F2A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA21SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA21SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F2B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA21SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA21SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F2C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA22OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA22OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F2D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA22SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA22SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F2E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA22SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA22SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F2F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA23OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA23OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F30

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA23SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA23SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F31

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA23SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA23SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F32

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA24OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA24OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F33

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA24SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA24SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F34

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA24SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA24SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F35

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA25OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA25OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F36

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA25SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA25SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F37

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA25SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA25SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F38

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA26OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA26OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F39

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA26SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA26SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F3A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA26SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA26SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F3B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA27OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA27OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F3C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA27SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA27SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F3D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA27SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA27SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F3E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA28OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA28OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F3F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA28SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA28SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F40

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA28SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA28SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F41

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA29OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA29OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F42

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA29SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA29SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F43

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA29SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA29SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F44

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA36AicSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA36AicSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F45

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA36AicSCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA36AicSCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F46

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA36OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA36OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F47

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA36SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA36SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F48

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA36SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA36SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F49

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA36ShuntSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA36ShuntSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F4A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA37AicSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA37AicSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F4B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA37AicSCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA37AicSCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F4C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA37OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA37OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F4D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA37SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA37SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F4E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA37SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA37SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F4F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA37ShuntSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA37ShuntSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F50

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA38AicSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA38AicSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F51

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA38AicSCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA38AicSCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F52

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA38OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA38OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F53

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA38SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA38SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F54

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA38SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA38SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F55

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA38ShuntSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA38ShuntSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F56

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA39AicSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA39AicSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F57

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA39AicSCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA39AicSCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F58

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA39OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA39OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F59

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA39SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA39SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F5A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA39SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA39SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F5B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA39ShuntSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA39ShuntSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F5C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA40OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA40OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F5D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA40SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA40SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F5E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA40SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA40SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F5F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA41OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA41OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F60

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA41SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA41SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F61

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA41SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA41SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F62

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA42OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA42OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F63

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA42SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA42SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F64

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA42SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA42SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F65

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA43AicSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA43AicSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F66

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA43AicSCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA43AicSCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F67

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA43OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA43OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F68

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA43SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA43SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F69

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA43SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA43SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F6A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA43ShuntSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA43ShuntSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F6B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA44OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA44OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F6C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA44SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA44SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F6D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA44SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA44SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F6E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA57OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA57OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F6F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA57SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA57SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F70

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA57SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA57SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F71

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA59OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA59OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F72

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA59SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA59SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F73

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA59SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA59SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F74

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK10OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK10OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F75

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK10SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK10SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F76

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK10SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK10SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F77

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK11OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK11OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F78

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK11SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK11SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F79

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK11SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK11SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F7A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK30AicSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK30AicSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F7B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK30AicSCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK30AicSCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F7C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK30OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK30OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F7D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK30SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK30SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F7E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK30SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK30SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F7F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK30ShuntSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK30ShuntSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F80

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK31OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK31OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F81

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK31SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK31SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F82

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK31SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK31SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F83

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK32OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK32OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F84

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK32SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK32SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F85

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK32SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK32SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F86

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK33OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK33OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F87

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK33SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK33SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F88

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK33SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK33SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F89

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK34OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK34OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F8A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK34SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK34SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F8B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK34SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK34SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F8C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK35OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK35OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F8D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK35SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK35SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F8E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK35SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK35SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F8F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK36OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK36OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F90

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK36SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK36SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F91

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK36SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK36SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F92

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK37AicSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK37AicSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F93

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK37AicSCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK37AicSCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F94

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK37OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK37OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F95

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK37SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK37SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F96

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK37SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK37SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F97

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK37ShuntSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK37ShuntSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F98

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK38AicSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK38AicSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F99

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK38AicSCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK38AicSCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F9A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK38OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK38OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F9B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK38SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK38SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F9C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK38SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK38SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F9D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK38ShuntSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK38ShuntSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F9E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK39AicSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK39AicSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F9F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK39AicSCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK39AicSCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FA0

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK39OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK39OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FA1

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK39SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK39SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FA2

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK39SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK39SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FA3

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK39ShuntSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK39ShuntSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FA4

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK40AicSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK40AicSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FA5

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK40AicSCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK40AicSCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FA6

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK40OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK40OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FA7

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK40SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK40SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FA8

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK40SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK40SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FA9

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK40ShuntSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK40ShuntSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FAA

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK41AicSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK41AicSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FAB

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK41AicSCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK41AicSCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FAC

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK41OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK41OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FAD

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK41SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK41SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FAE

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK41SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK41SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FAF

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK41ShuntSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK41ShuntSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FB0

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK42AicSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK42AicSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FB1

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK42AicSCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK42AicSCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FB2

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK42OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK42OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FB3

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK42SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK42SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FB4

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK42SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK42SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FB5

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK42ShuntSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK42ShuntSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FB6

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK43OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK43OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FB7

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK43SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK43SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FB8

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK43SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK43SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FB9

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK44AicSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK44AicSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FBA

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK44AicSCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK44AicSCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FBB

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK44OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK44OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FBC

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK44SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK44SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FBD

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK44SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK44SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FBE

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK44ShuntSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK44ShuntSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FBF

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK45AicSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK45AicSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FC0

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK45AicSCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK45AicSCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FC1

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK45OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK45OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FC2

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK45SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK45SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FC3

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK45SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK45SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FC4

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK45ShuntSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK45ShuntSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FC5

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK52OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK52OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FC6

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK52SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK52SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FC7

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK52SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK52SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FC8

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK53OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK53OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FC9

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK53SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK53SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FCA

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK53SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK53SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FCB

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK54AicSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK54AicSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FCC

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK54AicSCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK54AicSCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FCD

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK54OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK54OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FCE

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK54SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK54SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FCF

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK54SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK54SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FD0

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK54ShuntSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK54ShuntSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FD1

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK55AicSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK55AicSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FD2

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK55AicSCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK55AicSCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FD3

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK55OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK55OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FD4

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK55SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK55SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FD5

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK55SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK55SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FD6

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK55ShuntSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK55ShuntSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FD7

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK56OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK56OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FD8

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK56SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK56SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FD9

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK56SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK56SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FDA

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK57OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK57OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FDB

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK57SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK57SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FDC

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK57SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK57SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FDD

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK58OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK58OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FDE

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK58SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK58SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FDF

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK58SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK58SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FE0

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK59OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK59OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FE1

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK59SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK59SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FE2

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK59SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK59SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FE3

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK60OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK60OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FE4

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK60SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK60SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FE5

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK60SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK60SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FE6

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK61AicSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK61AicSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FE7

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK61AicSCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK61AicSCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FE8

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK61OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK61OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FE9

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK61SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK61SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FEA

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK61SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK61SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FEB

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK61ShuntSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK61ShuntSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FEC

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK62OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK62OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FED

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK62SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK62SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FEE

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK62SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK62SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FEF

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK63AicSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK63AicSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FF0

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK63AicSCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK63AicSCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FF1

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK63OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK63OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FF2

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK63SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK63SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FF3

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK63SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK63SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FF4

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK63ShuntSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK63ShuntSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FF5

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK64AicSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK64AicSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FF6

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK64AicSCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK64AicSCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FF7

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK64OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK64OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FF8

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK64SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK64SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FF9

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK64SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK64SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FFA

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK64ShuntSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK64ShuntSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FFB

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK65AicSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK65AicSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FFC

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK65AicSCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK65AicSCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FFD

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK65OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK65OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FFE

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK65SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK65SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FFF

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK65SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK65SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037000

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK65ShuntSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK65ShuntSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037001

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK74OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK74OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037002

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK74SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK74SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037003

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK74SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK74SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037004

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK75OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK75OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037005

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK75SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK75SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037006

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK75SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK75SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037007

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK76OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK76OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037008

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK76SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK76SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037009

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK76SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK76SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003700A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK77OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK77OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003700B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK77SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK77SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003700C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK77SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK77SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003700D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK78OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK78OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003700E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK78SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK78SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003700F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK78SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK78SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037010

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_DvUBAT_FWs
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_DvUBAT_FWs"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037011

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_OVErr_VPR6
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_OVErr_VPR6"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037012

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_OVWarn_VPR6
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_OVWarn_VPR6"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037013

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037014

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037015

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_OV_UBAT_MON
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_OV_UBAT_MON"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037016

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_OV_UBRM24_FLEXIN
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_OV_UBRM24_FLEXIN"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037017

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_OV_UBRM24_LOADS
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_OV_UBRM24_LOADS"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037018

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_OV_UBRM24_MON
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_OV_UBRM24_MON"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037019

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_OV_VDD5
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_OV_VDD5"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003701A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_OV_VDD5_IN
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_OV_VDD5_IN"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003701B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_OV_VPR6
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_OV_VPR6"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003701C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_OV_VSS3
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_OV_VSS3"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003701D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_OV_VSS4
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_OV_VSS4"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003701E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_Temp1_HTErr
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_Temp1_HTErr"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003701F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_Temp1_HTWarn
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_Temp1_HTWarn"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037020

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_Temp2_HTErr
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_Temp2_HTErr"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037021

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_Temp2_HTWarn
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_Temp2_HTWarn"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037022

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037023

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037024

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_UV_VDD5
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_UV_VDD5"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037025

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_UV_VDD5_IN
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_UV_VDD5_IN"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037026

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_UV_VPR6
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_UV_VPR6"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037027

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_UV_VSS3
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_UV_VSS3"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037028

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_UV_VSS4
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_UV_VSS4"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037029

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA01OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA01OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003702A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA01OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA01OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003702B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA01SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA01SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003702C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA01SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA01SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003702D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA02OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA02OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003702E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA02OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA02OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003702F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA02OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA02OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037030

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA02SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA02SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037031

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA02SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA02SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037032

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA03OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA03OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037033

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA03OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA03OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037034

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA03SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA03SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037035

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA03SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA03SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037036

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA04OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA04OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037037

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA04OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA04OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037038

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA04SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA04SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037039

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA04SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA04SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003703A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA05OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA05OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003703B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA05OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA05OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003703C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA05OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA05OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003703D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA05SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA05SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003703E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA05SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA05SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003703F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA06OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA06OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037040

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA06OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA06OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037041

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA06OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA06OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037042

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA06SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA06SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037043

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA06SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA06SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037044

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA07OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA07OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037045

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA07OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA07OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037046

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA07SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA07SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037047

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA07SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA07SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037048

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA08OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA08OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037049

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA08OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA08OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003704A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA08SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA08SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003704B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA08SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA08SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003704C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA09OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA09OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003704D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA09OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA09OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003704E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA09OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA09OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003704F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA09SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA09SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037050

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA09SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA09SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037051

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA10OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA10OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037052

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA10OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA10OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037053

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA10SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA10SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037054

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA10SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA10SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037055

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA11OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA11OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037056

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA11OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA11OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037057

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA11SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA11SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037058

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA11SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA11SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037059

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA12OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA12OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003705A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA12SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA12SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003705B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA12SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA12SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003705C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA16OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA16OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003705D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA16OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA16OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003705E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA16SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA16SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003705F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA16SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA16SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037060

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA17OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA17OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037061

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA17OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA17OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037062

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA17OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA17OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037063

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA17SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA17SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037064

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA17SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA17SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037065

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA18OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA18OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037066

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA18OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA18OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037067

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA18SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA18SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037068

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA18SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA18SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037069

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA19OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA19OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003706A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA19OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA19OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003706B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA19OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA19OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003706C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA19SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA19SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003706D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA19SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA19SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003706E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA20OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA20OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003706F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA20OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA20OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037070

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA20OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA20OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037071

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA20SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA20SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037072

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA20SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA20SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037073

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA31OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA31OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037074

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA31OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA31OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037075

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA31OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA31OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037076

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA31SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA31SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037077

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA31SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA31SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037078

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA32OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA32OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037079

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA32OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA32OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003707A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA32OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA32OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003707B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA32SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA32SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003707C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA32SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA32SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003707D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA33OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA33OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003707E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA33OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA33OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003707F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA33OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA33OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037080

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA33SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA33SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037081

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA33SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA33SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037082

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA34OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA34OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037083

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA34OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA34OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037084

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA34OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA34OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037085

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA34SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA34SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037086

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA34SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA34SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037087

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA35OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA35OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037088

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA35OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA35OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037089

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA35OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA35OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003708A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA35SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA35SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003708B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA35SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA35SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003708C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA46OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA46OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003708D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA46OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA46OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003708E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA46OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA46OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003708F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA46SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA46SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037090

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA46SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA46SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037091

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA47OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA47OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037092

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA47OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA47OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037093

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA47OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA47OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037094

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA47SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA47SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037095

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA47SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA47SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037096

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA48OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA48OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037097

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA48OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA48OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037098

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA48OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA48OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037099

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA48SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA48SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003709A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA48SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA48SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003709B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA49OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA49OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003709C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA49OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA49OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003709D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA49SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA49SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003709E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA49SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA49SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003709F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA50OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA50OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370A0

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA50OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA50OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370A1

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA50SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA50SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370A2

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA50SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA50SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370A3

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA51OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA51OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370A4

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA51OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA51OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370A5

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA51OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA51OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370A6

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA51SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA51SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370A7

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA51SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA51SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370A8

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA52OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA52OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370A9

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA52OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA52OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370AA

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA52OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA52OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370AB

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA52SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA52SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370AC

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA52SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA52SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370AD

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA53OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA53OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370AE

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA53OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA53OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370AF

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA53OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA53OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370B0

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA53SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA53SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370B1

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA53SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA53SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370B2

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA54OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA54OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370B3

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA54OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA54OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370B4

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA54OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA54OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370B5

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA54SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA54SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370B6

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA54SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA54SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370B7

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA55OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA55OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370B8

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA55OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA55OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370B9

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA55SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA55SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370BA

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA55SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA55SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370BB

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA56OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA56OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370BC

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA56OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA56OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370BD

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA56SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA56SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370BE

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA56SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA56SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370BF

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA58OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA58OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370C0

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA58OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA58OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370C1

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA58SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA58SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370C2

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA58SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA58SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370C3

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK07OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK07OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370C4

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK07OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK07OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370C5

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK07OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK07OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370C6

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK07SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK07SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370C7

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK07SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK07SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370C8

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK08OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK08OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370C9

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK08OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK08OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370CA

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK08OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK08OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370CB

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK08SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK08SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370CC

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK08SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK08SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370CD

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK09OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK09OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370CE

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK09OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK09OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370CF

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK09OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK09OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370D0

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK09SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK09SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370D1

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK09SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK09SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370D2

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK12OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK12OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370D3

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK12OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK12OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370D4

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK12SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK12SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370D5

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK12SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK12SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370D6

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK13OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK13OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370D7

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK13OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK13OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370D8

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK13SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK13SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370D9

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK13SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK13SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370DA

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK14OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK14OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370DB

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK14OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK14OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370DC

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK14OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK14OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370DD

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK14SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK14SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370DE

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK14SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK14SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370DF

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK15OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK15OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370E0

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK15OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK15OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370E1

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK15OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK15OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370E2

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK15SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK15SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370E3

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK15SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK15SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370E4

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK16OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK16OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370E5

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK16OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK16OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370E6

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK16OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK16OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370E7

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK16SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK16SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370E8

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK16SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK16SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370E9

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK17OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK17OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370EA

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK17OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK17OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370EB

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK17OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK17OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370EC

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK17SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK17SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370ED

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK17SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK17SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370EE

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK25OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK25OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370EF

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK25SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK25SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370F0

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK25SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK25SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370F1

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK29OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK29OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370F2

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK29OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK29OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370F3

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK29OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK29OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370F4

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK29SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK29SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370F5

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK29SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK29SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370F6

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK51OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK51OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370F7

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK51OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK51OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370F8

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK51SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK51SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370F9

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK51SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK51SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370FA

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK62OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK62OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370FB

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK62SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK62SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370FC

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK62SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK62SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370FD

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK73OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK73OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370FE

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK73OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK73OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370FF

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK73OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK73OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037100

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK73SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK73SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037101

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK73SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK73SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037102

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK80OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK80OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037103

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK80OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK80OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037104

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK80SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK80SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037105

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK80SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK80SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037106

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK81OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK81OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037107

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK81OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK81OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037108

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK81SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK81SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037109

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK81SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK81SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003710A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK82OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK82OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003710B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK82OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK82OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003710C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK82SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK82SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003710D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK82SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK82SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003710E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK83OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK83OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003710F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK83OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK83OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037110

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK83SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK83SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037111

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK83SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK83SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037112

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK84OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK84OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037113

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK84OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK84OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037114

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK84SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK84SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037115

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK84SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK84SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037116

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK85OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK85OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037117

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK85OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK85OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037118

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK85SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK85SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037119

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK85SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK85SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003711A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK86OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK86OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003711B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK86OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK86OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003711C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK86SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK86SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003711D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK86SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK86SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003711E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK87OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK87OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003711F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK87OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK87OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037120

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK87SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK87SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037121

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK87SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK87SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037122

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_EventUpDownDebFault
    "Status of DFC / Status of diagnostic fault check DFC_bds_EventUpDownDebFault"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037123

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_DSMDummy
    "Status of DFC / Status of diagnostic fault check DFC_DSMDummy"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037124

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canGetDataNoBuf
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canGetDataNoBuf"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037125

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canGetDataParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canGetDataParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037126

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canGetDataboxNoInit
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canGetDataboxNoInit"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037127

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canGetDataboxParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canGetDataboxParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037128

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canGetRxBufStatusParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canGetRxBufStatusParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037129

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canGetStatusParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canGetStatusParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003712A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canGetTxBufStatusParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canGetTxBufStatusParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003712B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canInitParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canInitParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003712C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canInitRxDataboxOverlap
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canInitRxDataboxOverlap"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003712D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canInitRxDataboxParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canInitRxDataboxParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003712E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canInitTxDataboxParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canInitTxDataboxParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003712F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canIpduGroupControl
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canIpduGroupControl"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037130

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canIsDataboxFreeNoInit
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canIsDataboxFreeNoInit"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037131

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canIsDataboxFreeParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canIsDataboxFreeParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037132

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canIsTxEmptyParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canIsTxEmptyParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037133

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canRegBusOffCallbInvState
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canRegBusOffCallbInvState"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037134

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canRegBusOffCallbParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canRegBusOffCallbParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037135

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canRegRxBufInvState
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canRegRxBufInvState"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037136

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canRegRxBufOverlap
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canRegRxBufOverlap"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037137

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canRegRxBufParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canRegRxBufParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037138

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canRegRxCallbInvState
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canRegRxCallbInvState"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037139

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canRegRxCallbParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canRegRxCallbParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003713A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canRegRxDataboxInvNumb
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canRegRxDataboxInvNumb"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003713B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canRegRxDataboxInvState
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canRegRxDataboxInvState"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003713C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canRegRxDataboxOverlap
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canRegRxDataboxOverlap"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003713D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canRegRxDataboxParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canRegRxDataboxParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003713E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canRegTxBufInvState
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canRegTxBufInvState"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003713F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canRegTxBufOverlap
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canRegTxBufOverlap"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037140

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canRegTxBufParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canRegTxBufParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037141

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canRegTxDataboxInvNumb
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canRegTxDataboxInvNumb"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037142

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canRegTxDataboxInvState
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canRegTxDataboxInvState"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037143

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canRegTxDataboxOverlap
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canRegTxDataboxOverlap"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037144

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canRegTxDataboxParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canRegTxDataboxParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037145

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canResetTxBufParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canResetTxBufParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037146

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canSendDataBufOvfl
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canSendDataBufOvfl"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037147

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canSendDataParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canSendDataParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037148

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canSendDataboxNoInit
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canSendDataboxNoInit"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037149

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canSendDataboxParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canSendDataboxParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003714A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canSetTxCycleParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canSetTxCycleParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003714B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canStartParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canStartParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003714C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canStopParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canStopParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003714D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_can_ClearIpduGroup
    "Status of DFC / Status of diagnostic fault check DFC_rbr_can_ClearIpduGroup"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003714E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_can_ReceiveSignal
    "Status of DFC / Status of diagnostic fault check DFC_rbr_can_ReceiveSignal"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003714F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_can_SendSignal
    "Status of DFC / Status of diagnostic fault check DFC_rbr_can_SendSignal"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037150

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_can_SetIpduGroup
    "Status of DFC / Status of diagnostic fault check DFC_rbr_can_SetIpduGroup"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037151

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_dsmDTCJ1939
    "Status of DFC / Status of diagnostic fault check DFC_rbr_dsmDTCJ1939"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037152

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_dsmDelDTCJ1939
    "Status of DFC / Status of diagnostic fault check DFC_rbr_dsmDelDTCJ1939"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037153

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_dsmDelErrors
    "Status of DFC / Status of diagnostic fault check DFC_rbr_dsmDelErrors"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037154

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_dsmGetDFES
    "Status of DFC / Status of diagnostic fault check DFC_rbr_dsmGetDFES"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037155

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_dsmGetDTCJ1939
    "Status of DFC / Status of diagnostic fault check DFC_rbr_dsmGetDTCJ1939"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037156

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_dsmGetErrors
    "Status of DFC / Status of diagnostic fault check DFC_rbr_dsmGetErrors"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037157

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_dsmGetNumErrors
    "Status of DFC / Status of diagnostic fault check DFC_rbr_dsmGetNumErrors"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037158

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_dsmInitQueueOverflow
    "Status of DFC / Status of diagnostic fault check DFC_rbr_dsmInitQueueOverflow"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037159

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_dsmNumDTCJ1939
    "Status of DFC / Status of diagnostic fault check DFC_rbr_dsmNumDTCJ1939"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003715A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_dsmTesterror
    "Status of DFC / Status of diagnostic fault check DFC_rbr_dsmTesterror"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003715B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_dsmUpdateDebError
    "Status of DFC / Status of diagnostic fault check DFC_rbr_dsmUpdateDebError"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003715C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_dsmUpdateError
    "Status of DFC / Status of diagnostic fault check DFC_rbr_dsmUpdateError"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003715D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_dsmgetDFCStatus
    "Status of DFC / Status of diagnostic fault check DFC_rbr_dsmgetDFCStatus"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003715E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_dsmtestErrorDFC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_dsmtestErrorDFC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003715F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inAi
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inAi"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037160

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inAic
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inAic"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037161

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inAicCfg
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inAicCfg"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037162

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inAicGetStatus
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inAicGetStatus"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037163

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inAid
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inAid"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037164

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inAidCfg
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inAidCfg"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037165

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inAiv
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inAiv"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037166

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inAivCfg
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inAivCfg"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037167

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inAivGetStatus
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inAivGetStatus"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037168

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inDi
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inDi"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037169

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inFi
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inFi"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003716A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inFiCfg
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inFiCfg"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003716B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inFiGetStatus
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inFiGetStatus"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003716C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inFi_Buffered
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inFi_Buffered"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003716D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inPhase
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inPhase"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003716E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inPhaseGetStatus
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inPhaseGetStatus"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003716F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inPhaseResetCounter
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inPhaseResetCounter"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037170

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inRi
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inRi"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037171

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inRiCfg
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inRiCfg"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037172

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inRiCfgTemp
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inRiCfgTemp"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037173

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inRiGetStatus
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inRiGetStatus"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037174

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inRiGetTemp
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inRiGetTemp"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037175

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inSentCopyFDFifo
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inSentCopyFDFifo"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037176

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inSentDisable
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inSentDisable"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037177

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inSentEnable
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inSentEnable"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037178

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inSentGetErrorStatus
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inSentGetErrorStatus"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037179

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inSentGetFD
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inSentGetFD"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003717A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inSentGetSD
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inSentGetSD"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003717B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inSentGetSDDatabox
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inSentGetSDDatabox"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003717C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inSentGetStatus
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inSentGetStatus"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003717D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inSentInitSDDatabox
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inSentInitSDDatabox"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003717E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inSentRegisterCopyFDFifo
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inSentRegisterCopyFDFifo"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003717F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inSentRegisterFDFifo
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inSentRegisterFDFifo"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037180

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inSentRegisterSDDataboxes
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inSentRegisterSDDataboxes"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037181

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_isobusCanRxBufferOverflow
    "Status of DFC / Status of diagnostic fault check DFC_rbr_isobusCanRxBufferOverflow"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037182

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_isobusGetCaAddrParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_isobusGetCaAddrParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037183

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_isobusGetDiagnosticParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_isobusGetDiagnosticParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037184

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_isobusGetRxDataboxStatusParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_isobusGetRxDataboxStatusParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037185

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_isobusGetStatusParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_isobusGetStatusParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037186

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_isobusInitCommCaMissing
    "Status of DFC / Status of diagnostic fault check DFC_rbr_isobusInitCommCaMissing"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037187

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_isobusInitCommParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_isobusInitCommParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037188

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_isobusInitCommState
    "Status of DFC / Status of diagnostic fault check DFC_rbr_isobusInitCommState"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037189

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_isobusInitDiagnosticParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_isobusInitDiagnosticParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003718A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_isobusInitFailureListParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_isobusInitFailureListParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003718B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_isobusInitRxDataboxParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_isobusInitRxDataboxParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003718C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_isobusInitTxDataboxParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_isobusInitTxDataboxParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003718D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_isobusRegRxDataboxOverlap
    "Status of DFC / Status of diagnostic fault check DFC_rbr_isobusRegRxDataboxOverlap"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003718E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_isobusRegRxDataboxParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_isobusRegRxDataboxParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003718F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_isobusRegRxDataboxState
    "Status of DFC / Status of diagnostic fault check DFC_rbr_isobusRegRxDataboxState"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037190

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_isobusRegTxDataboxOverlap
    "Status of DFC / Status of diagnostic fault check DFC_rbr_isobusRegTxDataboxOverlap"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037191

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_isobusRegTxDataboxParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_isobusRegTxDataboxParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037192

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_isobusRegTxDataboxState
    "Status of DFC / Status of diagnostic fault check DFC_rbr_isobusRegTxDataboxState"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037193

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_isobusRegisterErrClrCallbackParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_isobusRegisterErrClrCallbackParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037194

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_isobusRegisterInstancesOverlap
    "Status of DFC / Status of diagnostic fault check DFC_rbr_isobusRegisterInstancesOverlap"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037195

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_isobusRegisterInstancesParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_isobusRegisterInstancesParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037196

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_isobusRegisterInstancesState
    "Status of DFC / Status of diagnostic fault check DFC_rbr_isobusRegisterInstancesState"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037197

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_isobusSendDataboxParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_isobusSendDataboxParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037198

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_isobusSendRequestPGNParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_isobusSendRequestPGNParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037199

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_isobusSetCaAddrCaUsed
    "Status of DFC / Status of diagnostic fault check DFC_rbr_isobusSetCaAddrCaUsed"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003719A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_isobusSetCaAddrComm
    "Status of DFC / Status of diagnostic fault check DFC_rbr_isobusSetCaAddrComm"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003719B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_isobusSetCaAddrInvCan
    "Status of DFC / Status of diagnostic fault check DFC_rbr_isobusSetCaAddrInvCan"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003719C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_isobusSetCaAddrParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_isobusSetCaAddrParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003719D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_isobusSetCaInfoParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_isobusSetCaInfoParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003719E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_isobusSetCaNameParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_isobusSetCaNameParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003719F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_isobusSftyCanTxErr
    "Status of DFC / Status of diagnostic fault check DFC_rbr_isobusSftyCanTxErr"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371A0

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_lin_ReceiveSignal
    "Status of DFC / Status of diagnostic fault check DFC_rbr_lin_ReceiveSignal"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371A1

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_lin_SendSignal
    "Status of DFC / Status of diagnostic fault check DFC_rbr_lin_SendSignal"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371A2

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_lin_getStatus
    "Status of DFC / Status of diagnostic fault check DFC_rbr_lin_getStatus"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371A3

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_lin_gotoSleep
    "Status of DFC / Status of diagnostic fault check DFC_rbr_lin_gotoSleep"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371A4

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_lin_scheduleRequest
    "Status of DFC / Status of diagnostic fault check DFC_rbr_lin_scheduleRequest"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371A5

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_lin_wakeUp
    "Status of DFC / Status of diagnostic fault check DFC_rbr_lin_wakeUp"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371A6

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_memFlsCfgShr
    "Status of DFC / Status of diagnostic fault check DFC_rbr_memFlsCfgShr"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371A7

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_memGetStatus
    "Status of DFC / Status of diagnostic fault check DFC_rbr_memGetStatus"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371A8

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_memMarkBlock
    "Status of DFC / Status of diagnostic fault check DFC_rbr_memMarkBlock"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371A9

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_memReadApi1Error
    "Status of DFC / Status of diagnostic fault check DFC_rbr_memReadApi1Error"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371AA

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_memReadApi2Error
    "Status of DFC / Status of diagnostic fault check DFC_rbr_memReadApi2Error"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371AB

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_memReadBlock
    "Status of DFC / Status of diagnostic fault check DFC_rbr_memReadBlock"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371AC

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_memReadCalibInputError
    "Status of DFC / Status of diagnostic fault check DFC_rbr_memReadCalibInputError"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371AD

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_memReadCalibOuputError
    "Status of DFC / Status of diagnostic fault check DFC_rbr_memReadCalibOuputError"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371AE

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_memReadSystemError
    "Status of DFC / Status of diagnostic fault check DFC_rbr_memReadSystemError"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371AF

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_memWriteBlock
    "Status of DFC / Status of diagnostic fault check DFC_rbr_memWriteBlock"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371B0

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_moOV_FirstConstADC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_moOV_FirstConstADC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371B1

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_moOV_SecondConstADC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_moOV_SecondConstADC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371B2

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_moUV_FirstConstADC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_moUV_FirstConstADC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371B3

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_moUV_SecondConstADC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_moUV_SecondConstADC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371B4

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_INH
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_INH"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371B5

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_INHLatch
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_INHLatch"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371B6

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_adcPDD_fail
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_adcPDD_fail"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371B7

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_memoryProtection_err
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_memoryProtection_err"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371B8

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA02OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA02OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371B9

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA02Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA02Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371BA

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA03OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA03OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371BB

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA03Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA03Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371BC

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA04OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA04OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371BD

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA04Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA04Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371BE

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA05OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA05OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371BF

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA05Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA05Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371C0

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA07OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA07OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371C1

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA07Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA07Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371C2

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA08OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA08OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371C3

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA08Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA08Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371C4

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA09OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA09OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371C5

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA09Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA09Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371C6

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA10OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA10OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371C7

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA10Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA10Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371C8

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA17OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA17OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371C9

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA17Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA17Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371CA

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA18OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA18OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371CB

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA18Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA18Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371CC

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA19OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA19OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371CD

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA19Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA19Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371CE

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA20OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA20OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371CF

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA20Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA20Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371D0

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA31OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA31OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371D1

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA31Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA31Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371D2

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA32OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA32OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371D3

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA32Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA32Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371D4

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA33OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA33OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371D5

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA33Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA33Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371D6

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA34OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA34OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371D7

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA34Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA34Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371D8

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA35OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA35OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371D9

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA35Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA35Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371DA

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA46OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA46OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371DB

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA46Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA46Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371DC

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA47OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA47OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371DD

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA47Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA47Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371DE

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA48OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA48OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371DF

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA48Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA48Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371E0

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA51OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA51OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371E1

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA51Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA51Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371E2

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA52OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA52OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371E3

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA52Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA52Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371E4

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA53OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA53OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371E5

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA53Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA53Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371E6

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA54OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA54OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371E7

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA54Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA54Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371E8

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outAov
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outAov"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371E9

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outAovCfg
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outAovCfg"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371EA

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outAovCfgPI
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outAovCfgPI"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371EB

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outAovGetStatus
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outAovGetStatus"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371EC

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outAovGetVoltage
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outAovGetVoltage"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371ED

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outAovResetError
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outAovResetError"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371EE

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outDo
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outDo"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371EF

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outDoCfgPwrLs
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outDoCfgPwrLs"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371F0

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outDoDisable
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outDoDisable"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371F1

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outDoGetCurrent
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outDoGetCurrent"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371F2

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outDoGetStatus
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outDoGetStatus"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371F3

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outDoResetError
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outDoResetError"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371F4

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK07OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK07OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371F5

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK07Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK07Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371F6

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK08OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK08OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371F7

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK08Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK08Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371F8

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK09OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK09OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371F9

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK09Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK09Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371FA

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK12OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK12OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371FB

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK12Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK12Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371FC

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK13OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK13OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371FD

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK13Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK13Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371FE

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK14OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK14OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371FF

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK14Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK14Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037200

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK15OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK15OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037201

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK15Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK15Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037202

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK16OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK16OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037203

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK16Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK16Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037204

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK17OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK17OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037205

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK17Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK17Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037206

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK29OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK29OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037207

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK29Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK29Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037208

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK51OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK51OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037209

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK51Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK51Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003720A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK73OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK73OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003720B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK73Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK73Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003720C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outPo
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outPo"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003720D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outPoCfg
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outPoCfg"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003720E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outPoCfgPeriod
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outPoCfgPeriod"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003720F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outPoCfgPwrLs
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outPoCfgPwrLs"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037210

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outPoDisable
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outPoDisable"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037211

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outPoGetCurrent
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outPoGetCurrent"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037212

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outPoGetStatus
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outPoGetStatus"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037213

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outPoResetError
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outPoResetError"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037214

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outPoc
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outPoc"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037215

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outPocCfg
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outPocCfg"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037216

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outPocCfgDither
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outPocCfgDither"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037217

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outPocCfgPI
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outPocCfgPI"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037218

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outPod
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outPod"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037219

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outPodCfg
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outPodCfg"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003721A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outPodCfgPeriod
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outPodCfgPeriod"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003721B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_rsmFfiApiCallErr
    "Status of DFC / Status of diagnostic fault check DFC_rbr_rsmFfiApiCallErr"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003721C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safout
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safout"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003721D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutCfg
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutCfg"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003721E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl1
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl1"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003721F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl10
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl10"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037220

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl10Dev
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl10Dev"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037221

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl10OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl10OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037222

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl11
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl11"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037223

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl11Dev
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl11Dev"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037224

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl11OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl11OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037225

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl12
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl12"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037226

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl12Dev
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl12Dev"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037227

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl12OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl12OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037228

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl13
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl13"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037229

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl13Dev
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl13Dev"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003722A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl13OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl13OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003722B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl14
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl14"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003722C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl14Dev
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl14Dev"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003722D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl14OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl14OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003722E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl15
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl15"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003722F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl15Dev
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl15Dev"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037230

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl15OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl15OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037231

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl16
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl16"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037232

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl16Dev
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl16Dev"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037233

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl16OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl16OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037234

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl17
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl17"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037235

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl17Dev
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl17Dev"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037236

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl17OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl17OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037237

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl18
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl18"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037238

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl18Dev
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl18Dev"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037239

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl18OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl18OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003723A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl1Dev
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl1Dev"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003723B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl1OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl1OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003723C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl2
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl2"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003723D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl2Dev
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl2Dev"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003723E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl2OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl2OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003723F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl3
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl3"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037240

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl3Dev
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl3Dev"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037241

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl3OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl3OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037242

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl4
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl4"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037243

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl4Dev
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl4Dev"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037244

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl4OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl4OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037245

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl5
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl5"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037246

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl5Dev
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl5Dev"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037247

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl5OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl5OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037248

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl6
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl6"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037249

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl6Dev
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl6Dev"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003724A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl6OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl6OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003724B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl7
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl7"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003724C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl7Dev
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl7Dev"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003724D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl7OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl7OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003724E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl8
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl8"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003724F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl8Dev
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl8Dev"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037250

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl8OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl8OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037251

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl9
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl9"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037252

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl9Dev
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl9Dev"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037253

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl9OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl9OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037254

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutDevError
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutDevError"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037255

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutGetStatus
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutGetStatus"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037256

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutIgnoreError
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutIgnoreError"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037257

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutResetError
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutResetError"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037258

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutUnlock
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutUnlock"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037259

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safout_cfgDiag
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safout_cfgDiag"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003725A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_secAccessDenied_RC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_secAccessDenied_RC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003725B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_secAccessDenied_WDBI
    "Status of DFC / Status of diagnostic fault check DFC_rbr_secAccessDenied_WDBI"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003725C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_secEvalRespKey
    "Status of DFC / Status of diagnostic fault check DFC_rbr_secEvalRespKey"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003725D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_secFlashingFailure
    "Status of DFC / Status of diagnostic fault check DFC_rbr_secFlashingFailure"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003725E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_secGetLevel
    "Status of DFC / Status of diagnostic fault check DFC_rbr_secGetLevel"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003725F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_secGetRnd
    "Status of DFC / Status of diagnostic fault check DFC_rbr_secGetRnd"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037260

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_secGetSeed
    "Status of DFC / Status of diagnostic fault check DFC_rbr_secGetSeed"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037261

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_secInvalidPassword
    "Status of DFC / Status of diagnostic fault check DFC_rbr_secInvalidPassword"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037262

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_secIsRequestAllowed
    "Status of DFC / Status of diagnostic fault check DFC_rbr_secIsRequestAllowed"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037263

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_secResetLevel
    "Status of DFC / Status of diagnostic fault check DFC_rbr_secResetLevel"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037264

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_secSaveSecret
    "Status of DFC / Status of diagnostic fault check DFC_rbr_secSaveSecret"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037265

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_secSetLevel
    "Status of DFC / Status of diagnostic fault check DFC_rbr_secSetLevel"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037266

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_sysAit
    "Status of DFC / Status of diagnostic fault check DFC_rbr_sysAit"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037267

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_sysAiv
    "Status of DFC / Status of diagnostic fault check DFC_rbr_sysAiv"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037268

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_sysDi
    "Status of DFC / Status of diagnostic fault check DFC_rbr_sysDi"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037269

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_sysDo
    "Status of DFC / Status of diagnostic fault check DFC_rbr_sysDo"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003726A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_sysGetVss
    "Status of DFC / Status of diagnostic fault check DFC_rbr_sysGetVss"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003726B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_sysInit
    "Status of DFC / Status of diagnostic fault check DFC_rbr_sysInit"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003726C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_sysOperHrIntegrityErr
    "Status of DFC / Status of diagnostic fault check DFC_rbr_sysOperHrIntegrityErr"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003726D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_sysOperHrsSaturated
    "Status of DFC / Status of diagnostic fault check DFC_rbr_sysOperHrsSaturated"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003726E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_sysSetVss
    "Status of DFC / Status of diagnostic fault check DFC_rbr_sysSetVss"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003726F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_sys_coreload
    "Status of DFC / Status of diagnostic fault check DFC_rbr_sys_coreload"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037270

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_sys_taskload
    "Status of DFC / Status of diagnostic fault check DFC_rbr_sys_taskload"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037271

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_OV_VSS1
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_OV_VSS1"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037272

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_OV_VSS2
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_OV_VSS2"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037273

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_UV_VSS1
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_UV_VSS1"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037274

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_UV_VSS2
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_UV_VSS2"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037275

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_CANSM_E_BUS_OFF_NETWORK_0
    "Status of DFC / Status of diagnostic fault check DFC_CANSM_E_BUS_OFF_NETWORK_0"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037276

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_CANSM_E_BUS_OFF_NETWORK_1
    "Status of DFC / Status of diagnostic fault check DFC_CANSM_E_BUS_OFF_NETWORK_1"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037277

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_CANSM_E_BUS_OFF_NETWORK_2
    "Status of DFC / Status of diagnostic fault check DFC_CANSM_E_BUS_OFF_NETWORK_2"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037278

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_CANSM_E_BUS_OFF_NETWORK_3
    "Status of DFC / Status of diagnostic fault check DFC_CANSM_E_BUS_OFF_NETWORK_3"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037279

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_CANTRCV_E_NO_TRCV_CONTROL_0
    "Status of DFC / Status of diagnostic fault check DFC_CANTRCV_E_NO_TRCV_CONTROL_0"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003727A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_CAN_E_TIMEOUT
    "Status of DFC / Status of diagnostic fault check DFC_CAN_E_TIMEOUT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003727B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_COMM_E_NET_START_IND_CHANNEL_0
    "Status of DFC / Status of diagnostic fault check DFC_COMM_E_NET_START_IND_CHANNEL_0"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003727C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_COMM_E_NET_START_IND_CHANNEL_1
    "Status of DFC / Status of diagnostic fault check DFC_COMM_E_NET_START_IND_CHANNEL_1"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003727D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_COMM_E_NET_START_IND_CHANNEL_2
    "Status of DFC / Status of diagnostic fault check DFC_COMM_E_NET_START_IND_CHANNEL_2"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003727E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_COMM_E_NET_START_IND_CHANNEL_3
    "Status of DFC / Status of diagnostic fault check DFC_COMM_E_NET_START_IND_CHANNEL_3"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003727F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_COMM_E_NET_START_IND_CHANNEL_4
    "Status of DFC / Status of diagnostic fault check DFC_COMM_E_NET_START_IND_CHANNEL_4"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037280

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_COMM_E_NET_START_IND_CHANNEL_5
    "Status of DFC / Status of diagnostic fault check DFC_COMM_E_NET_START_IND_CHANNEL_5"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037281

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_LIN_E_TIMEOUT
    "Status of DFC / Status of diagnostic fault check DFC_LIN_E_TIMEOUT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037282

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rba_MultiStackTrace_Threshold
    "Status of DFC / Status of diagnostic fault check DFC_rba_MultiStackTrace_Threshold"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037283

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_ETH_E_ACCESS_0
    "Status of DFC / Status of diagnostic fault check DFC_ETH_E_ACCESS_0"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037284

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_RBA_IOEXTLIB_KEEPALIVE_DRV
    "Status of DFC / Status of diagnostic fault check DFC_RBA_IOEXTLIB_KEEPALIVE_DRV"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037285

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_RBA_IOEXTLIB_KEEPALIVE_INI
    "Status of DFC / Status of diagnostic fault check DFC_RBA_IOEXTLIB_KEEPALIVE_INI"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037286

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rba_MRly_Diag_Stk_Event
    "Status of DFC / Status of diagnostic fault check DFC_rba_MRly_Diag_Stk_Event"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037287

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rba_MemDiagExtd_MemReadSngErr
    "Status of DFC / Status of diagnostic fault check DFC_rba_MemDiagExtd_MemReadSngErr"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037288

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rba_MemDiag_MemReadErr
    "Status of DFC / Status of diagnostic fault check DFC_rba_MemDiag_MemReadErr"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037289

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rba_MemDiag_MemWrErr
    "Status of DFC / Status of diagnostic fault check DFC_rba_MemDiag_MemWrErr"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003728A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rba_SyC_IrrSwOffTrigEngRun_Event
    "Status of DFC / Status of diagnostic fault check DFC_rba_SyC_IrrSwOffTrigEngRun_Event"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003728B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rba_T15_Diag_ComInVld_Event
    "Status of DFC / Status of diagnostic fault check DFC_rba_T15_Diag_ComInVld_Event"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003728C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rba_T15_Diag_ComOff_HwOn_Event
    "Status of DFC / Status of diagnostic fault check DFC_rba_T15_Diag_ComOff_HwOn_Event"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003728D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rba_T15_Diag_ComOn_HwOff_Event
    "Status of DFC / Status of diagnostic fault check DFC_rba_T15_Diag_ComOn_HwOff_Event"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003728E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM0_0
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM0_0"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003728F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM0_1
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM0_1"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037290

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM0_10
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM0_10"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037291

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM0_11
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM0_11"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037292

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM0_13
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM0_13"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037293

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM0_14
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM0_14"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037294

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM0_2
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM0_2"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037295

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM0_22
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM0_22"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037296

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM0_23
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM0_23"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037297

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM0_4
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM0_4"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037298

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM0_5
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM0_5"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037299

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM0_7
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM0_7"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003729A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM0_8
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM0_8"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003729B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM10_16
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM10_16"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003729C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM10_17
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM10_17"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003729D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM10_21
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM10_21"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003729E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM11_0
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM11_0"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003729F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM11_1
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM11_1"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372A0

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM11_2
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM11_2"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372A1

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM11_3
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM11_3"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372A2

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM11_4
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM11_4"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372A3

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM11_5
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM11_5"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372A4

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM11_8
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM11_8"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372A5

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM11_9
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM11_9"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372A6

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM1_0
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM1_0"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372A7

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM1_1
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM1_1"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372A8

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM1_10
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM1_10"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372A9

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM1_11
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM1_11"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372AA

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM1_13
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM1_13"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372AB

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM1_14
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM1_14"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372AC

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM1_2
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM1_2"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372AD

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM1_22
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM1_22"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372AE

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM1_23
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM1_23"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372AF

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM1_4
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM1_4"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372B0

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM1_5
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM1_5"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372B1

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM1_7
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM1_7"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372B2

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM1_8
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM1_8"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372B3

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM21_0
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM21_0"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372B4

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM21_16
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM21_16"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372B5

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM21_3
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM21_3"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372B6

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM2_1
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM2_1"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372B7

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM2_10
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM2_10"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372B8

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM2_11
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM2_11"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372B9

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM2_13
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM2_13"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372BA

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM2_14
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM2_14"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372BB

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM2_2
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM2_2"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372BC

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM2_22
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM2_22"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372BD

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM2_23
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM2_23"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372BE

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM2_4
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM2_4"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372BF

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM2_5
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM2_5"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372C0

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM2_7
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM2_7"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372C1

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM2_8
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM2_8"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372C2

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM3_1
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM3_1"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372C3

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM3_10
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM3_10"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372C4

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM3_11
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM3_11"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372C5

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM3_13
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM3_13"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372C6

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM3_14
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM3_14"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372C7

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM3_2
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM3_2"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372C8

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM3_22
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM3_22"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372C9

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM3_23
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM3_23"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372CA

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM3_4
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM3_4"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372CB

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM3_5
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM3_5"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372CC

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM3_7
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM3_7"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372CD

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM3_8
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM3_8"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372CE

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM6_0
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM6_0"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372CF

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM6_11
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM6_11"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372D0

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM6_12
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM6_12"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372D1

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM6_14
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM6_14"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372D2

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM6_15
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM6_15"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372D3

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM6_17
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM6_17"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372D4

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM6_18
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM6_18"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372D5

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM6_2
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM6_2"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372D6

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM6_20
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM6_20"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372D7

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM6_21
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM6_21"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372D8

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM6_25
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM6_25"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372D9

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM6_4
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM6_4"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372DA

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM6_5
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM6_5"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372DB

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM6_7
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM6_7"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372DC

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM6_8
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM6_8"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372DD

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM7_1
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM7_1"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372DE

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM7_12
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM7_12"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372DF

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM7_13
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM7_13"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372E0

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM7_14
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM7_14"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372E1

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM7_15
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM7_15"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372E2

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM7_16
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM7_16"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372E3

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM7_17
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM7_17"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372E4

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM7_2
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM7_2"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372E5

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM7_20
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM7_20"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372E6

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM7_25
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM7_25"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372E7

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM7_26
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM7_26"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372E8

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM7_28
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM7_28"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372E9

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM7_29
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM7_29"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372EA

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM7_30
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM7_30"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372EB

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM7_31
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM7_31"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372EC

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM8_0
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM8_0"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372ED

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM8_1
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM8_1"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372EE

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM8_10
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM8_10"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372EF

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM8_11
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM8_11"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372F0

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM8_12
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM8_12"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372F1

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM8_13
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM8_13"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372F2

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM8_16
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM8_16"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372F3

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM8_18
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM8_18"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372F4

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM8_2
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM8_2"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372F5

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM8_3
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM8_3"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372F6

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM8_30
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM8_30"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372F7

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM8_31
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM8_31"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372F8

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM8_4
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM8_4"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372F9

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM9_0
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM9_0"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372FA

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM9_1
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM9_1"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372FB

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM9_15
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM9_15"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372FC

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM9_3
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM9_3"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372FD

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MoCSOPICO
    "Status of DFC / Status of diagnostic fault check DFC_MoCSOPICO"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372FE

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MoFVarPostBldSel
    "Status of DFC / Status of diagnostic fault check DFC_MoFVarPostBldSel"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372FF

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MoSysCtrlReIni
    "Status of DFC / Status of diagnostic fault check DFC_MoSysCtrlReIni"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037300

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MoXEMMHwLTMCUFW
    "Status of DFC / Status of diagnostic fault check DFC_MoXEMMHwLTMCUFW"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037301

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MoXEMMHwLTMonBIST
    "Status of DFC / Status of diagnostic fault check DFC_MoXEMMHwLTMonBIST"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037302

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MoXEMMHwLTRegMonTest
    "Status of DFC / Status of diagnostic fault check DFC_MoXEMMHwLTRegMonTest"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037303

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MoXEMMHwLTStbySMUAlvTest
    "Status of DFC / Status of diagnostic fault check DFC_MoXEMMHwLTStbySMUAlvTest"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037304

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MoXEMMHwLTTempSens
    "Status of DFC / Status of diagnostic fault check DFC_MoXEMMHwLTTempSens"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037305

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MoXEMMHwLTUCBCfg
    "Status of DFC / Status of diagnostic fault check DFC_MoXEMMHwLTUCBCfg"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037306

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_OCWDAABEActv
    "Status of DFC / Status of diagnostic fault check DFC_OCWDAABEActv"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037307

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_OCWDACom
    "Status of DFC / Status of diagnostic fault check DFC_OCWDACom"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037308

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_OCWDAErrPin
    "Status of DFC / Status of diagnostic fault check DFC_OCWDAErrPin"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037309

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_SWReset_0
    "Status of DFC / Status of diagnostic fault check DFC_SWReset_0"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003730A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_SWReset_1
    "Status of DFC / Status of diagnostic fault check DFC_SWReset_1"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003730B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_SWReset_2
    "Status of DFC / Status of diagnostic fault check DFC_SWReset_2"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003730C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDebFault1
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDebFault1"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003730D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_stClctFault_mp
    "Collected error states of all fault checks"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    MATRIX_DIM 64  
    ECU_ADDRESS 0x7003026A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_stClctTst_mp
    "Collected tested states of all fault checks"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    MATRIX_DIM 64  
    ECU_ADDRESS 0x700301EA

/end MEASUREMENT

/begin MEASUREMENT

    DFC_stFinal
    "Disable (or check finished) status of all DFCs (for PID$41 calculation)"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    MATRIX_DIM 64  
    ECU_ADDRESS 0x6000B7E8

/end MEASUREMENT

/begin MEASUREMENT

    DFC_stMem
    "Fault entry exists - per DFC"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    MATRIX_DIM 64  
    ECU_ADDRESS 0x60036E9E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_stRdy
    "Ready state due to ""OK"" per DFC"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    MATRIX_DIM 64  
    ECU_ADDRESS 0x60036E1E

/end MEASUREMENT

/begin MEASUREMENT

    DFES_ChkLstDltDemExCond_mp
    "Exit condition of last delete demand check during initialisation"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x700303A3

/end MEASUREMENT

/begin MEASUREMENT

    DFES_chkSt
    "Check state of all DFCs stored in the error memory"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    MATRIX_DIM 32  
    ECU_ADDRESS 0x600379C0

/end MEASUREMENT

/begin MEASUREMENT

    DFES_cnfSequence
    "DSM internal sequence counter to obtain confirmed entry sorting of all error memory entries"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    MATRIX_DIM 32  
    ECU_ADDRESS 0x600377B4

/end MEASUREMENT

/begin MEASUREMENT

    DFES_ctDef
    "Fault counters (FLC) of error memory entries"
    UBYTE
    DFES_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    MATRIX_DIM 32  
    ECU_ADDRESS 0x600378E0

/end MEASUREMENT

/begin MEASUREMENT

    DFES_ctDel
    "Delete counters (DLC) of error memory entries"
    UBYTE
    DFES_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    MATRIX_DIM 32  
    ECU_ADDRESS 0x60037860

/end MEASUREMENT

/begin MEASUREMENT

    DFES_ctEntry
    "Number of occupied DFES Entries"
    UBYTE
    DFES_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE54

/end MEASUREMENT

/begin MEASUREMENT

    DFES_ctFrq
    "Frequency counters of error memory entries"
    UBYTE
    DFES_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    MATRIX_DIM 32  
    ECU_ADDRESS 0x60037394

/end MEASUREMENT

/begin MEASUREMENT

    DFES_ctManuDef
    "Manufacturer fault counters of error memory entries"
    UBYTE
    DFES_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    MATRIX_DIM 32  
    ECU_ADDRESS 0x600378A0

/end MEASUREMENT

/begin MEASUREMENT

    DFES_ctManuOk
    "Manufacturer healing counters of error memory entries"
    UBYTE
    DFES_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    MATRIX_DIM 32  
    ECU_ADDRESS 0x60037880

/end MEASUREMENT

/begin MEASUREMENT

    DFES_ctMIL
    "Number of DFES Entries illuminating the MIL(Only continuous illumination, no blinking counted)"
    UBYTE
    DFES_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE56

/end MEASUREMENT

/begin MEASUREMENT

    DFES_ctOBD
    "Number of DFES Entries visible in OBD Mode 3"
    UBYTE
    DFES_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE58

/end MEASUREMENT

/begin MEASUREMENT

    DFES_ctOBDPend
    "Number of DFES Entries visible in OBD Mode 7 (pending)"
    UBYTE
    DFES_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE57

/end MEASUREMENT

/begin MEASUREMENT

    DFES_ctOk
    "Healing counters (HLC) of error memory entries"
    UBYTE
    DFES_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    MATRIX_DIM 32  
    ECU_ADDRESS 0x600378C0

/end MEASUREMENT

/begin MEASUREMENT

    DFES_ctPDTC
    "Number of DFES Entries visible in OBD Mode A (PDTC)"
    UBYTE
    DFES_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE51

/end MEASUREMENT

/begin MEASUREMENT

    DFES_ctSrv
    "Number of DFES Entries visible for Service tester"
    UBYTE
    DFES_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE55

/end MEASUREMENT

/begin MEASUREMENT

    DFES_ctSrvDef
    ""
    UBYTE
    DFES_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE52

/end MEASUREMENT

/begin MEASUREMENT

    DFES_entrySt
    "Entry state of all DFCs stored in the error memory"
    UBYTE
    DFES_Entry_Verb
    1
    100
    0.00
    30.0000000000

    
    FORMAT "%13.10"
    MATRIX_DIM 32  
    ECU_ADDRESS 0x600379A0

/end MEASUREMENT

/begin MEASUREMENT

    DFES_entryStPdtcStrd
    "Current EEPROM storage state of PDTC DFES entries"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    MATRIX_DIM 5  
    ECU_ADDRESS 0x60034006

/end MEASUREMENT

/begin MEASUREMENT

    DFES_EnvBlock
    "Environmental data of all fault entries"
    UBYTE
    DFES_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    MATRIX_DIM 896  
    ECU_ADDRESS 0x600373B4

/end MEASUREMENT

/begin MEASUREMENT

    DFES_FrzFrVal
    "Freeze frame values of all fault entries"
    UBYTE
    DFES_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    MATRIX_DIM 128  
    ECU_ADDRESS 0x60037734

/end MEASUREMENT

/begin MEASUREMENT

    DFES_idxSequence
    "Sequence in which DFES entries were allocated (became Service$03 or Service$07 visible)"
    UBYTE
    DFES_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    MATRIX_DIM 32  
    ECU_ADDRESS 0x600377D5

/end MEASUREMENT

/begin MEASUREMENT

    DFES_ISOFrstCnfDFC
    "DFC matching to criteria of first confirmed DTC"
    UWORD
    DFCDFP_Verb
    1
    100
    0.00
    1009.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x60037392

/end MEASUREMENT

/begin MEASUREMENT

    DFES_ISOFrstFailDFC
    "DFC matching to criteria of first failed DTC"
    UWORD
    DFCDFP_Verb
    1
    100
    0.00
    1009.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x60037A42

/end MEASUREMENT

/begin MEASUREMENT

    DFES_ISORcntCnfDFC
    "DFC matching to criteria of most recent confirmed DTC"
    UWORD
    DFCDFP_Verb
    1
    100
    0.00
    1009.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x60037390

/end MEASUREMENT

/begin MEASUREMENT

    DFES_ISORcntFailDFC
    "DFC matching to criteria of most recent failed DTC"
    UWORD
    DFCDFP_Verb
    1
    100
    0.00
    1009.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x60037A00

/end MEASUREMENT

/begin MEASUREMENT

    DFES_lenLstAllwdDst_mp
    ""
    SLONG
    Length
    1
    100
    -2147483648.00
    2147483647.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x70030174

/end MEASUREMENT

/begin MEASUREMENT

    DFES_MonEvnt
    "DFES monitoring - Event Id"
    UWORD
    DFES_Mon_Verb
    1
    100
    0.00
    32786.0000000

    
    FORMAT "%13.7"
    MATRIX_DIM 2  
    ECU_ADDRESS 0x60037B0E

/end MEASUREMENT

/begin MEASUREMENT

    DFES_MonObjt
    "DFES monitoring - Object Id"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    MATRIX_DIM 2  
    ECU_ADDRESS 0x60037B0A

/end MEASUREMENT

/begin MEASUREMENT

    DFES_MonParm
    "DFES monitoring - Parameter"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    MATRIX_DIM 2  
    ECU_ADDRESS 0x60037B06

/end MEASUREMENT

/begin MEASUREMENT

    DFES_MonPtr
    "DSM internal pointer for DFES monitoring"
    UBYTE
    DFES_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037B12

/end MEASUREMENT

/begin MEASUREMENT

    DFES_numDFC
    "Names of stored fault checks in the error memory"
    UWORD
    DFC_Verb
    1
    100
    0.00
    1007.

    
    FORMAT "%2.0"
    MATRIX_DIM 32  
    ECU_ADDRESS 0x60037960

/end MEASUREMENT

/begin MEASUREMENT

    DFES_numDFCAck
    "acknowledged ID of fault entry (scanned and handled)"
    UWORD
    DFC_Verb
    1
    100
    0.00
    1007.

    
    FORMAT "%2.0"
    MATRIX_DIM 32  
    ECU_ADDRESS 0x60037820

/end MEASUREMENT

/begin MEASUREMENT

    DFES_numDFCImdt
    "Names of immediately stored fault checks in the error memory"
    UWORD
    DFC_Verb
    1
    100
    0.00
    1007.

    
    FORMAT "%2.0"
    MATRIX_DIM 32  
    ECU_ADDRESS 0x60037AC4

/end MEASUREMENT

/begin MEASUREMENT

    DFES_numEntryAvl
    "Number of possible DFES Entries"
    UBYTE
    DFES_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE50

/end MEASUREMENT

/begin MEASUREMENT

    DFES_numEnvSize
    "Number of bytes in one environment block"
    UBYTE
    DFES_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE4D

/end MEASUREMENT

/begin MEASUREMENT

    DFES_numExtdFrzFrmSize
    "Number of bytes for environmental conditions contained in one freeze frame extension set"
    UBYTE
    DFES_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE4E

/end MEASUREMENT

/begin MEASUREMENT

    DFES_numFrzFrmSize
    "Number of bytes in one freeze frame"
    UBYTE
    DFES_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE4F

/end MEASUREMENT

/begin MEASUREMENT

    DFES_OutLamps
    "Error lamp status of error memory entries"
    UBYTE
    DFES_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    MATRIX_DIM 32  
    ECU_ADDRESS 0x6000CDE1

/end MEASUREMENT

/begin MEASUREMENT

    DFES_OutMILMod
    ""
    UBYTE
    DFES_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    MATRIX_DIM 32  
    ECU_ADDRESS 0x6000CE01

/end MEASUREMENT

/begin MEASUREMENT

    DFES_PDTCStore
    "indication to store permanent DTCs at beginning of postdrive"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE46

/end MEASUREMENT

/begin MEASUREMENT

    DFES_prioEntryImdt
    "Priority of error memory entries"
    UBYTE
    DFES_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    MATRIX_DIM 32  
    ECU_ADDRESS 0x60037AA4

/end MEASUREMENT

/begin MEASUREMENT

    DFES_StateVisibility
    "Tester visibility of error memory entries"
    UWORD
    DFES_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    MATRIX_DIM 32  
    ECU_ADDRESS 0x6000B86C

/end MEASUREMENT

/begin MEASUREMENT

    DFES_stChk
    "Legacy check state of all DFCs stored in the error memory"
    UBYTE
    DFES_stCheck_Verb
    1
    100
    0.00
    7.00000000000

    
    FORMAT "%13.11"
    MATRIX_DIM 32  
    ECU_ADDRESS 0x60037940

/end MEASUREMENT

/begin MEASUREMENT

    DFES_stCounters
    "Counter state of all DFCs stored in the error memory"
    UBYTE
    DFES_stCnt_Verb
    1
    100
    0.00
    85.0000000000

    
    FORMAT "%13.10"
    MATRIX_DIM 32  
    ECU_ADDRESS 0x60037900

/end MEASUREMENT

/begin MEASUREMENT

    DFES_stCtlSetting
    "internal and central disable request"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE43

/end MEASUREMENT

/begin MEASUREMENT

    DFES_stDataImdt
    "Environment data state of error memory entries"
    UBYTE
    DFES_stDataImdt_Verb
    1
    100
    0.00
    21.0000000000

    
    FORMAT "%13.10"
    MATRIX_DIM 32  
    ECU_ADDRESS 0x60037A44

/end MEASUREMENT

/begin MEASUREMENT

    DFES_stDataImdtTrans
    "Alternative environment data state of error memory entries during transition."
    UBYTE
    DFES_stDataImdt_Verb
    1
    100
    0.00
    21.0000000000

    
    FORMAT "%13.10"
    MATRIX_DIM 32  
    ECU_ADDRESS 0x6000CE21

/end MEASUREMENT

/begin MEASUREMENT

    DFES_stDTCRecUpdt
    "state of disable DTC record update, AUTOSAR feature"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE42

/end MEASUREMENT

/begin MEASUREMENT

    DFES_stDTCStorage
    "state of disable DTC storage AUTOSAR feature"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE41

/end MEASUREMENT

/begin MEASUREMENT

    DFES_stEepWrReq
    "request for an EEPROM storage"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE4A

/end MEASUREMENT

/begin MEASUREMENT

    DFES_stEntry
    "Legacy entry state of all DFCs stored in the error memory"
    UBYTE
    DFES_stEntry_Verb
    1
    100
    0.00
    252.000000000

    
    FORMAT "%13.9"
    MATRIX_DIM 32  
    ECU_ADDRESS 0x60037920

/end MEASUREMENT

/begin MEASUREMENT

    DFES_stErrDia
    "DSM internal status of all tester visibilities"
    UBYTE
    DFES_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE5C

/end MEASUREMENT

/begin MEASUREMENT

    DFES_stErrLamp
    "DFES error lamp demands"
    UBYTE
    DFES_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE5E

/end MEASUREMENT

/begin MEASUREMENT

    DFES_stInh
    "Inhibit (FIM) relevant state of fault entry"
    UBYTE
    DFES_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    MATRIX_DIM 32  
    ECU_ADDRESS 0x60037800

/end MEASUREMENT

/begin MEASUREMENT

    DFES_stMILDsplStgy
    ""
    UBYTE
    DFES_DsplStgy
    1
    100
    0.00
    2.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6000CE59

/end MEASUREMENT

/begin MEASUREMENT

    DFES_stMILMod
    ""
    UBYTE
    DFES_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE5A

/end MEASUREMENT

/begin MEASUREMENT

    DFES_stOrdImdt
    "Order state of error memory entries"
    UWORD
    DFES_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    MATRIX_DIM 32  
    ECU_ADDRESS 0x60037A64

/end MEASUREMENT

/begin MEASUREMENT

    DFES_stOutstate
    "DSM Flag status to check whether error counter is valid or not."
    UBYTE
    DFES_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE5B

/end MEASUREMENT

/begin MEASUREMENT

    DFES_stPrgEvt
    "ECU programming event detected (reset of all diagnostic informations including IUMPR and permanent DTCs)"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE45

/end MEASUREMENT

/begin MEASUREMENT

    DFES_stPrgEvt_msg
    "Interface that gives information about ECU programming event."
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6BA

/end MEASUREMENT

/begin MEASUREMENT

    DFES_stRepClrAftPwrFail
    "Repeated DSM clear after powerfail necessary"
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x1
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6000C673

/end MEASUREMENT

/begin MEASUREMENT

    DFES_SvsLampIllumn
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE5D

/end MEASUREMENT

/begin MEASUREMENT

    DFES_tiDefCntr
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    MATRIX_DIM 32  
    ECU_ADDRESS 0x60037310

/end MEASUREMENT

/begin MEASUREMENT

    DFES_xAsgnEnvAllDataSize
    "Memory usage of common calibrated environment data"
    UBYTE
    DFES_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CD61

/end MEASUREMENT

/begin MEASUREMENT

    DiaActrElecPsDiag_cntTestPlsTsk_mp
    "L-1 L=enNumber of testpulses in current driving cycleL-1"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x700301E6

/end MEASUREMENT

/begin MEASUREMENT

    DiaActrElecPsDiag_nrDiagErr_mp
    "Number of supported errors of the diagnosis signal"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x70030398

/end MEASUREMENT

/begin MEASUREMENT

    DiaActrElecPsDiag_nrTestPls_mp
    "Number of testpulses in current driving cycle"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x7003015C

/end MEASUREMENT

/begin MEASUREMENT

    DiaActrElecPsDiag_stAttribOL_mp
    "Current DSM attribute (Tested detection) of the open load error when reporting open load error to DSM module"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x70030158

/end MEASUREMENT

/begin MEASUREMENT

    DiaActrElecPsDiag_stAttribOT_mp
    "Current DSM attribute (Tested detection) of the overtemperature error when reporting overtemperature error to DSM module"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x70030154

/end MEASUREMENT

/begin MEASUREMENT

    DiaActrElecPsDiag_stAttribSCB_mp
    "Current DSM attribute (Tested detection) of the short circuit to battery error when reporting short circuit to battery error to DSM module"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x70030150

/end MEASUREMENT

/begin MEASUREMENT

    DiaActrElecPsDiag_stAttribSCG_mp
    "Current DSM attribute (Tested detection) of the short circuit to ground error when reporting short circuit to ground error to DSM module"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x7003014C

/end MEASUREMENT

/begin MEASUREMENT

    DiaActrElecPsDiag_stDsmDebOpenLoad_mp
    "Debounce status of OL error"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x70030148

/end MEASUREMENT

/begin MEASUREMENT

    DiaActrElecPsDiag_stDsmDebOverT_mp
    "Debounce status of OT error"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x70030144

/end MEASUREMENT

/begin MEASUREMENT

    DiaActrElecPsDiag_stDsmDebScb_mp
    "Debounce status of SCB error"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x70030140

/end MEASUREMENT

/begin MEASUREMENT

    DiaActrElecPsDiag_stDsmDebScg_mp
    "Debounce status of SCG error"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x7003013C

/end MEASUREMENT

/begin MEASUREMENT

    DiaActrElecPsDiag_stErrCfgOpenLoad_mp
    "Configuration of behaviour for OL error"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x70030397

/end MEASUREMENT

/begin MEASUREMENT

    DiaActrElecPsDiag_stErrCfgOverT_mp
    "Configuration of behaviour for OT error"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x70030396

/end MEASUREMENT

/begin MEASUREMENT

    DiaActrElecPsDiag_stErrCfgScb_mp
    "Configuration of behaviour for SCB error"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x70030395

/end MEASUREMENT

/begin MEASUREMENT

    DiaActrElecPsDiag_stErrCfgScg_mp
    "Configuration of behaviour for SCG error"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x70030394

/end MEASUREMENT

/begin MEASUREMENT

    DiaActrElecPsDiag_stPrvTstRslt_mp
    "The latest result of test impulse"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x70030138

/end MEASUREMENT

/begin MEASUREMENT

    DiaActrElecPsDiag_stSigCfg_mp
    "Configuration of the diagnosis signal"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x70030393

/end MEASUREMENT

/begin MEASUREMENT

    DiaActrElecPsDiag_stSigErrInfo_mp
    "The last error information of HWE read from the chip"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x70030134

/end MEASUREMENT

/begin MEASUREMENT

    DiaActrElecPsDiag_stSig_mp
    "Actual state of the diagnosis signal: INVALID, NOTEST, NOFAULT, FAULT, PREFAULT, HEALFAULT, WAITSTATE"
    UBYTE
    DiaActrElecPsDiag_stSig_COMPU_VERB
    1
    100
    0.00
    6.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x70030392

/end MEASUREMENT

/begin MEASUREMENT

    DiaActrElecPsDiag_stTestPls_mp
    "L-1 L=enThe actual state of the testpulse state machine: NO, REQUESTED, RUN, FINISHED, RE-TRIGGEREDL-1"
    UBYTE
    DiaActrElecPsDiag_stTestPls_COMPU_VERB
    1
    100
    1.00000000000
    5.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x70030391

/end MEASUREMENT

/begin MEASUREMENT

    DiaActrElecPsDiag_stTmngTestPls_mp
    "The current time to wait between two testpulses"
    UBYTE
    DiaActrElecPsDiag_stTmngTestPls_COMPU_VERB
    1
    100
    0.00
    3.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x70030390

/end MEASUREMENT

/begin MEASUREMENT

    DiaActrElecPsDiag_tiTstPls_mp
    "Current status of timer for the time between testpulses during permanent fault"
    SWORD
    OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x700301E4

/end MEASUREMENT

/begin MEASUREMENT

    DiaActr_ElecHBrdgDiag_HBrDiagInfo_mp
    "Diagnosis information from HWE - HBr."
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x70030170

/end MEASUREMENT

/begin MEASUREMENT

    DiaActr_ElecHBrdgDiag_HlfBrDiagInfo_mp
    "Diagnosis information from IoSrv - HlfBr"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    MATRIX_DIM 2  
    ECU_ADDRESS 0x70030168

/end MEASUREMENT

/begin MEASUREMENT

    DiaActr_ElecHBrdgDiag_nrDiagErr_mp
    "Number of diagnostic errors Size of error object array."
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x700303A2

/end MEASUREMENT

/begin MEASUREMENT

    DiaActr_ElecHBrdgDiag_OLSigErrInfo_mp
    "Signal error information during open load diagnosis."
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x70030164

/end MEASUREMENT

/begin MEASUREMENT

    DiaActr_ElecHBrdgDiag_ReasOLAbort_mp
    "Measuring point indicating reason for open load diagnosis abort. [Relevant only if open load is configured in switchoff or disable mode]."
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x700303A1

/end MEASUREMENT

/begin MEASUREMENT

    DiaActr_ElecHBrdgDiag_SigErrInfo_mp
    "Signal error information during normal diagnosis."
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x70030160

/end MEASUREMENT

/begin MEASUREMENT

    DiaActr_ElecHBrdgDiag_stAddOLDiag_mp
    "Additional open load diagnosis status."
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x700303A0

/end MEASUREMENT

/begin MEASUREMENT

    DiaActr_ElecHBrdgDiag_stDiagCtrl_mp
    "Status of diagnosis software (DiaActr_ElecHBrdgDiag) controlling H-Bridge output."
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x7003039F

/end MEASUREMENT

/begin MEASUREMENT

    DiaActr_ElecHBrdgDiag_stDiagDi_mp
    "Diagnosis disable status."
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x7003039E

/end MEASUREMENT

/begin MEASUREMENT

    DiaActr_ElecHBrdgDiag_stOLAbortReq_mp
    "Open load abort request status."
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x7003039D

/end MEASUREMENT

/begin MEASUREMENT

    DiaActr_ElecHBrdgDiag_stOLDiagMode_mp
    "Open load diagnosis mode."
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x7003039C

/end MEASUREMENT

/begin MEASUREMENT

    DiaActr_ElecHBrdgDiag_stOLDiag_mp
    "Open load diagnosis status."
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x7003039B

/end MEASUREMENT

/begin MEASUREMENT

    DiaActr_ElecHBrdgDiag_stSigQly_mp
    "Signal quality returned."
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x7003039A

/end MEASUREMENT

/begin MEASUREMENT

    DiaActr_ElecHBrdgDiag_TestPlsReq_mp
    "Test pulse request status."
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x70030399

/end MEASUREMENT

/begin MEASUREMENT

    DINH_ctMonCorr
    ""
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B8C0

/end MEASUREMENT

/begin MEASUREMENT

    DINH_DSQSrv7Vis
    "Service 0x07 visibility of DSQs"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    MATRIX_DIM 1  
    ECU_ADDRESS 0x6000C2DE

/end MEASUREMENT

/begin MEASUREMENT

    DINH_FIdSrv7Vis
    "Service 0x07 visibility of FIds"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    MATRIX_DIM 2  
    ECU_ADDRESS 0x6000C2E0

/end MEASUREMENT

/begin MEASUREMENT

    DINH_nrActvInhReas.FId_InhibitAlways
    "Number of active inhibit reasons for the FIds / Number of active inhibit reasons for FId_InhibitAlways"
    UWORD
    DINH_ct_Compu
    1
    100
    -4095.000
    4096.000

    BIT_MASK 0x1fff
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000C2EA

/end MEASUREMENT

/begin MEASUREMENT

    DINH_nrActvInhReas.FId_ComCILAddCond0
    "Number of active inhibit reasons for the FIds / Number of active inhibit reasons for FId_ComCILAddCond0"
    UWORD
    DINH_ct_Compu
    1
    100
    -4095.000
    4096.000

    BIT_MASK 0x1fff
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000C2EC

/end MEASUREMENT

/begin MEASUREMENT

    DINH_nrActvInhReas.FId_ComCILAddCond1
    "Number of active inhibit reasons for the FIds / Number of active inhibit reasons for FId_ComCILAddCond1"
    UWORD
    DINH_ct_Compu
    1
    100
    -4095.000
    4096.000

    BIT_MASK 0x1fff
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000C2EE

/end MEASUREMENT

/begin MEASUREMENT

    DINH_nrActvInhReas.FId_ComCILAddCond2
    "Number of active inhibit reasons for the FIds / Number of active inhibit reasons for FId_ComCILAddCond2"
    UWORD
    DINH_ct_Compu
    1
    100
    -4095.000
    4096.000

    BIT_MASK 0x1fff
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000C2F0

/end MEASUREMENT

/begin MEASUREMENT

    DINH_nrActvInhReas.FId_ComCILAddCond3
    "Number of active inhibit reasons for the FIds / Number of active inhibit reasons for FId_ComCILAddCond3"
    UWORD
    DINH_ct_Compu
    1
    100
    -4095.000
    4096.000

    BIT_MASK 0x1fff
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000C2F2

/end MEASUREMENT

/begin MEASUREMENT

    DINH_nrActvInhReas.FId_ComNEngNPL
    "Number of active inhibit reasons for the FIds / Number of active inhibit reasons for FId_ComNEngNPL"
    UWORD
    DINH_ct_Compu
    1
    100
    -4095.000
    4096.000

    BIT_MASK 0x1fff
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000C2F4

/end MEASUREMENT

/begin MEASUREMENT

    DINH_nrActvInhReas.FId_DELibEnvP
    "Number of active inhibit reasons for the FIds / Number of active inhibit reasons for FId_DELibEnvP"
    UWORD
    DINH_ct_Compu
    1
    100
    -4095.000
    4096.000

    BIT_MASK 0x1fff
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000C2F6

/end MEASUREMENT

/begin MEASUREMENT

    DINH_nrActvInhReas.FId_DELibEnvT
    "Number of active inhibit reasons for the FIds / Number of active inhibit reasons for FId_DELibEnvT"
    UWORD
    DINH_ct_Compu
    1
    100
    -4095.000
    4096.000

    BIT_MASK 0x1fff
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000C2F8

/end MEASUREMENT

/begin MEASUREMENT

    DINH_nrActvInhReas.FId_DELibPRelPfilDs
    "Number of active inhibit reasons for the FIds / Number of active inhibit reasons for FId_DELibPRelPfilDs"
    UWORD
    DINH_ct_Compu
    1
    100
    -4095.000
    4096.000

    BIT_MASK 0x1fff
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000C2FA

/end MEASUREMENT

/begin MEASUREMENT

    DINH_nrActvInhReas.FId_DIUMPRGenDenom1
    "Number of active inhibit reasons for the FIds / Number of active inhibit reasons for FId_DIUMPRGenDenom1"
    UWORD
    DINH_ct_Compu
    1
    100
    -4095.000
    4096.000

    BIT_MASK 0x1fff
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000C2FC

/end MEASUREMENT

/begin MEASUREMENT

    DINH_nrActvInhReas.FId_DIUMPRGenDenom1PDTC
    "Number of active inhibit reasons for the FIds / Number of active inhibit reasons for FId_DIUMPRGenDenom1PDTC"
    UWORD
    DINH_ct_Compu
    1
    100
    -4095.000
    4096.000

    BIT_MASK 0x1fff
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000C2FE

/end MEASUREMENT

/begin MEASUREMENT

    DINH_nrActvInhReas.FId_DIUMPRGenDenom2
    "Number of active inhibit reasons for the FIds / Number of active inhibit reasons for FId_DIUMPRGenDenom2"
    UWORD
    DINH_ct_Compu
    1
    100
    -4095.000
    4096.000

    BIT_MASK 0x1fff
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000C300

/end MEASUREMENT

/begin MEASUREMENT

    DINH_nrActvInhReas.FId_DIUMPRGenDenom3
    "Number of active inhibit reasons for the FIds / Number of active inhibit reasons for FId_DIUMPRGenDenom3"
    UWORD
    DINH_ct_Compu
    1
    100
    -4095.000
    4096.000

    BIT_MASK 0x1fff
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000C302

/end MEASUREMENT

/begin MEASUREMENT

    DINH_nrActvInhReas.FId_DIUMPRIgn
    "Number of active inhibit reasons for the FIds / Number of active inhibit reasons for FId_DIUMPRIgn"
    UWORD
    DINH_ct_Compu
    1
    100
    -4095.000
    4096.000

    BIT_MASK 0x1fff
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000C304

/end MEASUREMENT

/begin MEASUREMENT

    DINH_nrActvInhReas.FId_DSMWarmUpCycle
    "Number of active inhibit reasons for the FIds / Number of active inhibit reasons for FId_DSMWarmUpCycle"
    UWORD
    DINH_ct_Compu
    1
    100
    -4095.000
    4096.000

    BIT_MASK 0x1fff
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000C306

/end MEASUREMENT

/begin MEASUREMENT

    DINH_nrActvInhReas.FId_I15031_srv9_VT_Freeze
    "Number of active inhibit reasons for the FIds / Number of active inhibit reasons for FId_I15031_srv9_VT_Freeze"
    UWORD
    DINH_ct_Compu
    1
    100
    -4095.000
    4096.000

    BIT_MASK 0x1fff
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000C308

/end MEASUREMENT

/begin MEASUREMENT

    DINH_nrActvInhReas.FId_InhibitNever
    "Number of active inhibit reasons for the FIds / Number of active inhibit reasons for FId_InhibitNever"
    UWORD
    DINH_ct_Compu
    1
    100
    -4095.000
    4096.000

    BIT_MASK 0x1fff
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000C30A

/end MEASUREMENT

/begin MEASUREMENT

    DINH_nrActvInhReas.FId_MILLmpPwrStg
    "Number of active inhibit reasons for the FIds / Number of active inhibit reasons for FId_MILLmpPwrStg"
    UWORD
    DINH_ct_Compu
    1
    100
    -4095.000
    4096.000

    BIT_MASK 0x1fff
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000C30C

/end MEASUREMENT

/begin MEASUREMENT

    DINH_nrActvInhReas.FId_SVSLmpPwrStg
    "Number of active inhibit reasons for the FIds / Number of active inhibit reasons for FId_SVSLmpPwrStg"
    UWORD
    DINH_ct_Compu
    1
    100
    -4095.000
    4096.000

    BIT_MASK 0x1fff
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000C30E

/end MEASUREMENT

/begin MEASUREMENT

    DINH_nrActvInhReas.FId_StopLmpPwrStg
    "Number of active inhibit reasons for the FIds / Number of active inhibit reasons for FId_StopLmpPwrStg"
    UWORD
    DINH_ct_Compu
    1
    100
    -4095.000
    4096.000

    BIT_MASK 0x1fff
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000C310

/end MEASUREMENT

/begin MEASUREMENT

    DINH_nrActvInhReas.FId_WrnLmpPwrStg
    "Number of active inhibit reasons for the FIds / Number of active inhibit reasons for FId_WrnLmpPwrStg"
    UWORD
    DINH_ct_Compu
    1
    100
    -4095.000
    4096.000

    BIT_MASK 0x1fff
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000C312

/end MEASUREMENT

/begin MEASUREMENT

    DINH_nrActvInhReas.Function_Id_1
    "Number of active inhibit reasons for the FIds / Number of active inhibit reasons for Function_Id_1"
    UWORD
    DINH_ct_Compu
    1
    100
    -4095.000
    4096.000

    BIT_MASK 0x1fff
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000C314

/end MEASUREMENT

/begin MEASUREMENT

    DINH_nrActvInhReas.Function_Id_2
    "Number of active inhibit reasons for the FIds / Number of active inhibit reasons for Function_Id_2"
    UWORD
    DINH_ct_Compu
    1
    100
    -4095.000
    4096.000

    BIT_MASK 0x1fff
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000C316

/end MEASUREMENT

/begin MEASUREMENT

    DINH_nrActvInhReas.Function_Id_3
    "Number of active inhibit reasons for the FIds / Number of active inhibit reasons for Function_Id_3"
    UWORD
    DINH_ct_Compu
    1
    100
    -4095.000
    4096.000

    BIT_MASK 0x1fff
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000C318

/end MEASUREMENT

/begin MEASUREMENT

    DINH_stClctFId_mp
    "Collected states of all function identifiers, if the bit is 1 the FId is inhibited"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    MATRIX_DIM 2  
    ECU_ADDRESS 0x700301E0

/end MEASUREMENT

/begin MEASUREMENT

    DINH_stFId.FId_Unused
    "Inhibit Status of FIds / "
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C2E8

/end MEASUREMENT

/begin MEASUREMENT

    DINH_stFId.FId_InhibitAlways
    "Inhibit Status of FIds / Status of function identifier FId_InhibitAlways"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C2EA

/end MEASUREMENT

/begin MEASUREMENT

    DINH_stFId.FId_ComCILAddCond0
    "Inhibit Status of FIds / Status of function identifier FId_ComCILAddCond0"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C2EC

/end MEASUREMENT

/begin MEASUREMENT

    DINH_stFId.FId_ComCILAddCond1
    "Inhibit Status of FIds / Status of function identifier FId_ComCILAddCond1"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C2EE

/end MEASUREMENT

/begin MEASUREMENT

    DINH_stFId.FId_ComCILAddCond2
    "Inhibit Status of FIds / Status of function identifier FId_ComCILAddCond2"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C2F0

/end MEASUREMENT

/begin MEASUREMENT

    DINH_stFId.FId_ComCILAddCond3
    "Inhibit Status of FIds / Status of function identifier FId_ComCILAddCond3"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C2F2

/end MEASUREMENT

/begin MEASUREMENT

    DINH_stFId.FId_ComNEngNPL
    "Inhibit Status of FIds / Status of function identifier FId_ComNEngNPL"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C2F4

/end MEASUREMENT

/begin MEASUREMENT

    DINH_stFId.FId_DELibEnvP
    "Inhibit Status of FIds / Status of function identifier FId_DELibEnvP"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C2F6

/end MEASUREMENT

/begin MEASUREMENT

    DINH_stFId.FId_DELibEnvT
    "Inhibit Status of FIds / Status of function identifier FId_DELibEnvT"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C2F8

/end MEASUREMENT

/begin MEASUREMENT

    DINH_stFId.FId_DELibPRelPfilDs
    "Inhibit Status of FIds / Status of function identifier FId_DELibPRelPfilDs"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C2FA

/end MEASUREMENT

/begin MEASUREMENT

    DINH_stFId.FId_DIUMPRGenDenom1
    "Inhibit Status of FIds / Status of function identifier FId_DIUMPRGenDenom1"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C2FC

/end MEASUREMENT

/begin MEASUREMENT

    DINH_stFId.FId_DIUMPRGenDenom1PDTC
    "Inhibit Status of FIds / Status of function identifier FId_DIUMPRGenDenom1PDTC"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C2FE

/end MEASUREMENT

/begin MEASUREMENT

    DINH_stFId.FId_DIUMPRGenDenom2
    "Inhibit Status of FIds / Status of function identifier FId_DIUMPRGenDenom2"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C300

/end MEASUREMENT

/begin MEASUREMENT

    DINH_stFId.FId_DIUMPRGenDenom3
    "Inhibit Status of FIds / Status of function identifier FId_DIUMPRGenDenom3"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C302

/end MEASUREMENT

/begin MEASUREMENT

    DINH_stFId.FId_DIUMPRIgn
    "Inhibit Status of FIds / Status of function identifier FId_DIUMPRIgn"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C304

/end MEASUREMENT

/begin MEASUREMENT

    DINH_stFId.FId_DSMWarmUpCycle
    "Inhibit Status of FIds / Status of function identifier FId_DSMWarmUpCycle"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C306

/end MEASUREMENT

/begin MEASUREMENT

    DINH_stFId.FId_I15031_srv9_VT_Freeze
    "Inhibit Status of FIds / Status of function identifier FId_I15031_srv9_VT_Freeze"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C308

/end MEASUREMENT

/begin MEASUREMENT

    DINH_stFId.FId_InhibitNever
    "Inhibit Status of FIds / Status of function identifier FId_InhibitNever"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C30A

/end MEASUREMENT

/begin MEASUREMENT

    DINH_stFId.FId_MILLmpPwrStg
    "Inhibit Status of FIds / Status of function identifier FId_MILLmpPwrStg"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C30C

/end MEASUREMENT

/begin MEASUREMENT

    DINH_stFId.FId_SVSLmpPwrStg
    "Inhibit Status of FIds / Status of function identifier FId_SVSLmpPwrStg"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C30E

/end MEASUREMENT

/begin MEASUREMENT

    DINH_stFId.FId_StopLmpPwrStg
    "Inhibit Status of FIds / Status of function identifier FId_StopLmpPwrStg"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C310

/end MEASUREMENT

/begin MEASUREMENT

    DINH_stFId.FId_WrnLmpPwrStg
    "Inhibit Status of FIds / Status of function identifier FId_WrnLmpPwrStg"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C312

/end MEASUREMENT

/begin MEASUREMENT

    DINH_stFId.Function_Id_1
    "Inhibit Status of FIds / Status of function identifier Function_Id_1"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C314

/end MEASUREMENT

/begin MEASUREMENT

    DINH_stFId.Function_Id_2
    "Inhibit Status of FIds / Status of function identifier Function_Id_2"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C316

/end MEASUREMENT

/begin MEASUREMENT

    DINH_stFId.Function_Id_3
    "Inhibit Status of FIds / Status of function identifier Function_Id_3"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C318

/end MEASUREMENT

/begin MEASUREMENT

    DINH_stMod7VisyCmpl
    "status of the first completed calculation of mode7 visibility"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000D16B

/end MEASUREMENT

/begin MEASUREMENT

    DINH_xFIDObsvInh_mp
    "DFCs and DSQs which inhibit the FId currently"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    MATRIX_DIM 10  
    ECU_ADDRESS 0x700301CC

/end MEASUREMENT

/begin MEASUREMENT

    DINH_xFIDObsvRls_mp
    "DFCs and DSQs which don't inhibit the FId currently"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    MATRIX_DIM 10  
    ECU_ADDRESS 0x700301B8

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_ctDenom
    "Calculated denominators of IUMPR relevant diagnostics (variant 1)"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    MATRIX_DIM 40  
    ECU_ADDRESS 0x60037B82

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_ctGenDenom
    "General denominator"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x60037B80

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_ctIgn
    "Ignition cycle counter"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x60037B7E

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_ctNum
    "Calculated numerators of IUMPR relevant diagnostics (variant 1)"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    MATRIX_DIM 40  
    ECU_ADDRESS 0x60037BD2

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_numIndGrp
    "IUMPR record with smallest ratio within the component group"
    UBYTE
    CfgRatio_Verb
    1
    100
    0.00
    39.

    
    FORMAT "%2.0"
    MATRIX_DIM 8  
    ECU_ADDRESS 0x6000D1A6

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_rValRatMin
    "Smallest ratio within component group"
    UWORD
    Fact
    1
    100
    0.00
    7.999878

    
    FORMAT "%8.6"
    MATRIX_DIM 8  
    ECU_ADDRESS 0x6000C392

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_state
    "Status bytes of IUMPR relevant diagnostics (variant 1)"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    MATRIX_DIM 40  
    ECU_ADDRESS 0x60037B56

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_stEnaDenom
    "enable status for general denominator and ignition cycle counter"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x60034088

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_stEnaPDTC
    "status of PDTC driving cycle condition"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60034078

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_stFIdGenDenom_mp
    "collected FId status (mode 7 visibility) of general denominator"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x7003038F

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_stProtdRamVld
    "DIUMPR protected ram content is valid"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60034104

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_0
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 0"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x6003408C

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_1
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 1"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x6003408D

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_2
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 2"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x6003408E

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_3
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 3"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x6003408F

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_4
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 4"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x60034090

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_5
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 5"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x60034091

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_6
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 6"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x60034092

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_7
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 7"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x60034093

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_8
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 8"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x60034094

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_9
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 9"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x60034095

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_10
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 10"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x60034096

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_11
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 11"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x60034097

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_12
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 12"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x60034098

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_13
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 13"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x60034099

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_14
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 14"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x6003409A

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_15
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 15"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x6003409B

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_16
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 16"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x6003409C

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_17
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 17"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x6003409D

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_18
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 18"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x6003409E

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_19
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 19"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x6003409F

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_20
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 20"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x600340A0

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_21
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 21"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x600340A1

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_22
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 22"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x600340A2

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_23
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 23"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x600340A3

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_24
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 24"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x600340A4

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_25
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 25"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x600340A5

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_26
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 26"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x600340A6

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_27
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 27"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x600340A7

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_28
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 28"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x600340A8

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_29
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 29"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x600340A9

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_30
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 30"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x600340AA

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_31
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 31"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x600340AB

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_32
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 32"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x600340AC

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_33
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 33"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x600340AD

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_34
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 34"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x600340AE

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_35
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 35"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x600340AF

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_36
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 36"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x600340B0

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_37
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 37"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x600340B1

/end MEASUREMENT

/begin MEASUREMENT

