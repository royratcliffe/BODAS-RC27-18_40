/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK15OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK15OL"
    VAL_BLK
    0x80801A60
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK15OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK15OR"
    VAL_BLK
    0x80801A64
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK15OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK15OT"
    VAL_BLK
    0x80801A68
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK15SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK15SCB"
    VAL_BLK
    0x80801A6C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK15SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK15SCG"
    VAL_BLK
    0x80801A70
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK16OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK16OL"
    VAL_BLK
    0x80801A74
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK16OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK16OR"
    VAL_BLK
    0x80801A78
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK16OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK16OT"
    VAL_BLK
    0x80801A7C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK16SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK16SCB"
    VAL_BLK
    0x80801A80
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK16SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK16SCG"
    VAL_BLK
    0x80801A84
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK17OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK17OL"
    VAL_BLK
    0x80801A88
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK17OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK17OR"
    VAL_BLK
    0x80801A8C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK17OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK17OT"
    VAL_BLK
    0x80801A90
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK17SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK17SCB"
    VAL_BLK
    0x80801A94
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK17SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK17SCG"
    VAL_BLK
    0x80801A98
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK25OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK25OR"
    VAL_BLK
    0x80801A9C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK25SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK25SCB"
    VAL_BLK
    0x80801AA0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK25SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK25SCG"
    VAL_BLK
    0x80801AA4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK29OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK29OL"
    VAL_BLK
    0x80801AA8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK29OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK29OR"
    VAL_BLK
    0x80801AAC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK29OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK29OT"
    VAL_BLK
    0x80801AB0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK29SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK29SCB"
    VAL_BLK
    0x80801AB4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK29SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK29SCG"
    VAL_BLK
    0x80801AB8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK51OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK51OL"
    VAL_BLK
    0x80801ABC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK51OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK51OT"
    VAL_BLK
    0x80801AC0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK51SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK51SCB"
    VAL_BLK
    0x80801AC4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK51SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK51SCG"
    VAL_BLK
    0x80801AC8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK62OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK62OR"
    VAL_BLK
    0x80801ACC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK62SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK62SCB"
    VAL_BLK
    0x80801AD0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK62SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK62SCG"
    VAL_BLK
    0x80801AD4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK73OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK73OL"
    VAL_BLK
    0x80801AD8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK73OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK73OR"
    VAL_BLK
    0x80801ADC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK73OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK73OT"
    VAL_BLK
    0x80801AE0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK73SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK73SCB"
    VAL_BLK
    0x80801AE4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK73SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK73SCG"
    VAL_BLK
    0x80801AE8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK80OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK80OL"
    VAL_BLK
    0x80801AEC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK80OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK80OT"
    VAL_BLK
    0x80801AF0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK80SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK80SCB"
    VAL_BLK
    0x80801AF4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK80SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK80SCG"
    VAL_BLK
    0x80801AF8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK81OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK81OL"
    VAL_BLK
    0x80801AFC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK81OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK81OT"
    VAL_BLK
    0x80801B00
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK81SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK81SCB"
    VAL_BLK
    0x80801B04
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK81SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK81SCG"
    VAL_BLK
    0x80801B08
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK82OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK82OL"
    VAL_BLK
    0x80801B0C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK82OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK82OT"
    VAL_BLK
    0x80801B10
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK82SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK82SCB"
    VAL_BLK
    0x80801B14
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK82SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK82SCG"
    VAL_BLK
    0x80801B18
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK83OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK83OL"
    VAL_BLK
    0x80801B1C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK83OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK83OT"
    VAL_BLK
    0x80801B20
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK83SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK83SCB"
    VAL_BLK
    0x80801B24
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK83SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK83SCG"
    VAL_BLK
    0x80801B28
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK84OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK84OL"
    VAL_BLK
    0x80801B2C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK84OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK84OT"
    VAL_BLK
    0x80801B30
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK84SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK84SCB"
    VAL_BLK
    0x80801B34
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK84SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK84SCG"
    VAL_BLK
    0x80801B38
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK85OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK85OL"
    VAL_BLK
    0x80801B3C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK85OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK85OT"
    VAL_BLK
    0x80801B40
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK85SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK85SCB"
    VAL_BLK
    0x80801B44
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK85SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK85SCG"
    VAL_BLK
    0x80801B48
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK86OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK86OL"
    VAL_BLK
    0x80801B4C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK86OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK86OT"
    VAL_BLK
    0x80801B50
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK86SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK86SCB"
    VAL_BLK
    0x80801B54
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK86SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK86SCG"
    VAL_BLK
    0x80801B58
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK87OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK87OL"
    VAL_BLK
    0x80801B5C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK87OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK87OT"
    VAL_BLK
    0x80801B60
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK87SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK87SCB"
    VAL_BLK
    0x80801B64
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK87SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK87SCG"
    VAL_BLK
    0x80801B68
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_EventUpDownDebFault_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_EventUpDownDebFault"
    VAL_BLK
    0x80801B6C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_DSMDummy_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_DSMDummy"
    VAL_BLK
    0x80801B70
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canGetDataNoBuf_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canGetDataNoBuf"
    VAL_BLK
    0x80801B74
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canGetDataParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canGetDataParam"
    VAL_BLK
    0x80801B78
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canGetDataboxNoInit_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canGetDataboxNoInit"
    VAL_BLK
    0x80801B7C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canGetDataboxParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canGetDataboxParam"
    VAL_BLK
    0x80801B80
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canGetRxBufStatusParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canGetRxBufStatusParam"
    VAL_BLK
    0x80801B84
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canGetStatusParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canGetStatusParam"
    VAL_BLK
    0x80801B88
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canGetTxBufStatusParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canGetTxBufStatusParam"
    VAL_BLK
    0x80801B8C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canInitParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canInitParam"
    VAL_BLK
    0x80801B90
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canInitRxDataboxOverlap_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canInitRxDataboxOverlap"
    VAL_BLK
    0x80801B94
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canInitRxDataboxParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canInitRxDataboxParam"
    VAL_BLK
    0x80801B98
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canInitTxDataboxParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canInitTxDataboxParam"
    VAL_BLK
    0x80801B9C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canIpduGroupControl_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canIpduGroupControl"
    VAL_BLK
    0x80801BA0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canIsDataboxFreeNoInit_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canIsDataboxFreeNoInit"
    VAL_BLK
    0x80801BA4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canIsDataboxFreeParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canIsDataboxFreeParam"
    VAL_BLK
    0x80801BA8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canIsTxEmptyParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canIsTxEmptyParam"
    VAL_BLK
    0x80801BAC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canRegBusOffCallbInvState_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canRegBusOffCallbInvState"
    VAL_BLK
    0x80801BB0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canRegBusOffCallbParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canRegBusOffCallbParam"
    VAL_BLK
    0x80801BB4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canRegRxBufInvState_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canRegRxBufInvState"
    VAL_BLK
    0x80801BB8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canRegRxBufOverlap_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canRegRxBufOverlap"
    VAL_BLK
    0x80801BBC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canRegRxBufParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canRegRxBufParam"
    VAL_BLK
    0x80801BC0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canRegRxCallbInvState_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canRegRxCallbInvState"
    VAL_BLK
    0x80801BC4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canRegRxCallbParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canRegRxCallbParam"
    VAL_BLK
    0x80801BC8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canRegRxDataboxInvNumb_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canRegRxDataboxInvNumb"
    VAL_BLK
    0x80801BCC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canRegRxDataboxInvState_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canRegRxDataboxInvState"
    VAL_BLK
    0x80801BD0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canRegRxDataboxOverlap_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canRegRxDataboxOverlap"
    VAL_BLK
    0x80801BD4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canRegRxDataboxParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canRegRxDataboxParam"
    VAL_BLK
    0x80801BD8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canRegTxBufInvState_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canRegTxBufInvState"
    VAL_BLK
    0x80801BDC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canRegTxBufOverlap_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canRegTxBufOverlap"
    VAL_BLK
    0x80801BE0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canRegTxBufParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canRegTxBufParam"
    VAL_BLK
    0x80801BE4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canRegTxDataboxInvNumb_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canRegTxDataboxInvNumb"
    VAL_BLK
    0x80801BE8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canRegTxDataboxInvState_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canRegTxDataboxInvState"
    VAL_BLK
    0x80801BEC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canRegTxDataboxOverlap_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canRegTxDataboxOverlap"
    VAL_BLK
    0x80801BF0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canRegTxDataboxParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canRegTxDataboxParam"
    VAL_BLK
    0x80801BF4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canResetTxBufParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canResetTxBufParam"
    VAL_BLK
    0x80801BF8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canSendDataBufOvfl_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canSendDataBufOvfl"
    VAL_BLK
    0x80801BFC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canSendDataParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canSendDataParam"
    VAL_BLK
    0x80801C00
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canSendDataboxNoInit_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canSendDataboxNoInit"
    VAL_BLK
    0x80801C04
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canSendDataboxParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canSendDataboxParam"
    VAL_BLK
    0x80801C08
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canSetTxCycleParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canSetTxCycleParam"
    VAL_BLK
    0x80801C0C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canStartParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canStartParam"
    VAL_BLK
    0x80801C10
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canStopParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canStopParam"
    VAL_BLK
    0x80801C14
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_can_ClearIpduGroup_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_can_ClearIpduGroup"
    VAL_BLK
    0x80801C18
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_can_ReceiveSignal_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_can_ReceiveSignal"
    VAL_BLK
    0x80801C1C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_can_SendSignal_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_can_SendSignal"
    VAL_BLK
    0x80801C20
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_can_SetIpduGroup_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_can_SetIpduGroup"
    VAL_BLK
    0x80801C24
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_dsmDTCJ1939_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_dsmDTCJ1939"
    VAL_BLK
    0x80801C28
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_dsmDelDTCJ1939_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_dsmDelDTCJ1939"
    VAL_BLK
    0x80801C2C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_dsmDelErrors_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_dsmDelErrors"
    VAL_BLK
    0x80801C30
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_dsmGetDFES_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_dsmGetDFES"
    VAL_BLK
    0x80801C34
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_dsmGetDTCJ1939_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_dsmGetDTCJ1939"
    VAL_BLK
    0x80801C38
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_dsmGetErrors_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_dsmGetErrors"
    VAL_BLK
    0x80801C3C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_dsmGetNumErrors_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_dsmGetNumErrors"
    VAL_BLK
    0x80801C40
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_dsmInitQueueOverflow_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_dsmInitQueueOverflow"
    VAL_BLK
    0x80801C44
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_dsmNumDTCJ1939_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_dsmNumDTCJ1939"
    VAL_BLK
    0x80801C48
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_dsmTesterror_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_dsmTesterror"
    VAL_BLK
    0x80801C4C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_dsmUpdateDebError_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_dsmUpdateDebError"
    VAL_BLK
    0x80801C50
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_dsmUpdateError_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_dsmUpdateError"
    VAL_BLK
    0x80801C54
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_dsmgetDFCStatus_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_dsmgetDFCStatus"
    VAL_BLK
    0x80801C58
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_dsmtestErrorDFC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_dsmtestErrorDFC"
    VAL_BLK
    0x80801C5C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inAi_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inAi"
    VAL_BLK
    0x80801C60
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inAic_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inAic"
    VAL_BLK
    0x80801C64
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inAicCfg_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inAicCfg"
    VAL_BLK
    0x80801C68
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inAicGetStatus_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inAicGetStatus"
    VAL_BLK
    0x80801C6C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inAid_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inAid"
    VAL_BLK
    0x80801C70
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inAidCfg_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inAidCfg"
    VAL_BLK
    0x80801C74
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inAiv_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inAiv"
    VAL_BLK
    0x80801C78
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inAivCfg_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inAivCfg"
    VAL_BLK
    0x80801C7C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inAivGetStatus_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inAivGetStatus"
    VAL_BLK
    0x80801C80
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inDi_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inDi"
    VAL_BLK
    0x80801C84
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inFi_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inFi"
    VAL_BLK
    0x80801C88
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inFiCfg_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inFiCfg"
    VAL_BLK
    0x80801C8C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inFiGetStatus_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inFiGetStatus"
    VAL_BLK
    0x80801C90
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inFi_Buffered_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inFi_Buffered"
    VAL_BLK
    0x80801C94
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inPhase_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inPhase"
    VAL_BLK
    0x80801C98
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inPhaseGetStatus_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inPhaseGetStatus"
    VAL_BLK
    0x80801C9C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inPhaseResetCounter_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inPhaseResetCounter"
    VAL_BLK
    0x80801CA0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inRi_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inRi"
    VAL_BLK
    0x80801CA4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inRiCfg_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inRiCfg"
    VAL_BLK
    0x80801CA8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inRiCfgTemp_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inRiCfgTemp"
    VAL_BLK
    0x80801CAC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inRiGetStatus_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inRiGetStatus"
    VAL_BLK
    0x80801CB0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inRiGetTemp_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inRiGetTemp"
    VAL_BLK
    0x80801CB4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inSentCopyFDFifo_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inSentCopyFDFifo"
    VAL_BLK
    0x80801CB8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inSentDisable_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inSentDisable"
    VAL_BLK
    0x80801CBC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inSentEnable_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inSentEnable"
    VAL_BLK
    0x80801CC0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inSentGetErrorStatus_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inSentGetErrorStatus"
    VAL_BLK
    0x80801CC4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inSentGetFD_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inSentGetFD"
    VAL_BLK
    0x80801CC8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inSentGetSD_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inSentGetSD"
    VAL_BLK
    0x80801CCC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inSentGetSDDatabox_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inSentGetSDDatabox"
    VAL_BLK
    0x80801CD0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inSentGetStatus_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inSentGetStatus"
    VAL_BLK
    0x80801CD4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inSentInitSDDatabox_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inSentInitSDDatabox"
    VAL_BLK
    0x80801CD8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inSentRegisterCopyFDFifo_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inSentRegisterCopyFDFifo"
    VAL_BLK
    0x80801CDC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inSentRegisterFDFifo_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inSentRegisterFDFifo"
    VAL_BLK
    0x80801CE0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inSentRegisterSDDataboxes_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inSentRegisterSDDataboxes"
    VAL_BLK
    0x80801CE4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_isobusCanRxBufferOverflow_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_isobusCanRxBufferOverflow"
    VAL_BLK
    0x80801CE8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_isobusGetCaAddrParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_isobusGetCaAddrParam"
    VAL_BLK
    0x80801CEC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_isobusGetDiagnosticParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_isobusGetDiagnosticParam"
    VAL_BLK
    0x80801CF0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_isobusGetRxDataboxStatusParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_isobusGetRxDataboxStatusParam"
    VAL_BLK
    0x80801CF4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_isobusGetStatusParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_isobusGetStatusParam"
    VAL_BLK
    0x80801CF8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_isobusInitCommCaMissing_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_isobusInitCommCaMissing"
    VAL_BLK
    0x80801CFC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_isobusInitCommParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_isobusInitCommParam"
    VAL_BLK
    0x80801D00
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_isobusInitCommState_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_isobusInitCommState"
    VAL_BLK
    0x80801D04
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_isobusInitDiagnosticParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_isobusInitDiagnosticParam"
    VAL_BLK
    0x80801D08
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_isobusInitFailureListParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_isobusInitFailureListParam"
    VAL_BLK
    0x80801D0C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_isobusInitRxDataboxParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_isobusInitRxDataboxParam"
    VAL_BLK
    0x80801D10
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_isobusInitTxDataboxParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_isobusInitTxDataboxParam"
    VAL_BLK
    0x80801D14
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_isobusRegRxDataboxOverlap_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_isobusRegRxDataboxOverlap"
    VAL_BLK
    0x80801D18
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_isobusRegRxDataboxParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_isobusRegRxDataboxParam"
    VAL_BLK
    0x80801D1C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_isobusRegRxDataboxState_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_isobusRegRxDataboxState"
    VAL_BLK
    0x80801D20
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_isobusRegTxDataboxOverlap_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_isobusRegTxDataboxOverlap"
    VAL_BLK
    0x80801D24
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_isobusRegTxDataboxParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_isobusRegTxDataboxParam"
    VAL_BLK
    0x80801D28
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_isobusRegTxDataboxState_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_isobusRegTxDataboxState"
    VAL_BLK
    0x80801D2C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_isobusRegisterErrClrCallbackParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_isobusRegisterErrClrCallbackParam"
    VAL_BLK
    0x80801D30
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_isobusRegisterInstancesOverlap_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_isobusRegisterInstancesOverlap"
    VAL_BLK
    0x80801D34
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_isobusRegisterInstancesParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_isobusRegisterInstancesParam"
    VAL_BLK
    0x80801D38
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_isobusRegisterInstancesState_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_isobusRegisterInstancesState"
    VAL_BLK
    0x80801D3C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_isobusSendDataboxParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_isobusSendDataboxParam"
    VAL_BLK
    0x80801D40
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_isobusSendRequestPGNParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_isobusSendRequestPGNParam"
    VAL_BLK
    0x80801D44
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_isobusSetCaAddrCaUsed_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_isobusSetCaAddrCaUsed"
    VAL_BLK
    0x80801D48
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_isobusSetCaAddrComm_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_isobusSetCaAddrComm"
    VAL_BLK
    0x80801D4C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_isobusSetCaAddrInvCan_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_isobusSetCaAddrInvCan"
    VAL_BLK
    0x80801D50
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_isobusSetCaAddrParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_isobusSetCaAddrParam"
    VAL_BLK
    0x80801D54
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_isobusSetCaInfoParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_isobusSetCaInfoParam"
    VAL_BLK
    0x80801D58
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_isobusSetCaNameParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_isobusSetCaNameParam"
    VAL_BLK
    0x80801D5C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_isobusSftyCanTxErr_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_isobusSftyCanTxErr"
    VAL_BLK
    0x80801D60
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_lin_ReceiveSignal_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_lin_ReceiveSignal"
    VAL_BLK
    0x80801D64
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_lin_SendSignal_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_lin_SendSignal"
    VAL_BLK
    0x80801D68
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_lin_getStatus_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_lin_getStatus"
    VAL_BLK
    0x80801D6C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_lin_gotoSleep_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_lin_gotoSleep"
    VAL_BLK
    0x80801D70
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_lin_scheduleRequest_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_lin_scheduleRequest"
    VAL_BLK
    0x80801D74
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_lin_wakeUp_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_lin_wakeUp"
    VAL_BLK
    0x80801D78
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_memFlsCfgShr_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_memFlsCfgShr"
    VAL_BLK
    0x80801D7C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_memGetStatus_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_memGetStatus"
    VAL_BLK
    0x80801D80
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_memMarkBlock_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_memMarkBlock"
    VAL_BLK
    0x80801D84
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_memReadApi1Error_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_memReadApi1Error"
    VAL_BLK
    0x80801D88
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_memReadApi2Error_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_memReadApi2Error"
    VAL_BLK
    0x80801D8C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_memReadBlock_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_memReadBlock"
    VAL_BLK
    0x80801D90
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_memReadCalibInputError_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_memReadCalibInputError"
    VAL_BLK
    0x80801D94
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_memReadCalibOuputError_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_memReadCalibOuputError"
    VAL_BLK
    0x80801D98
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_memReadSystemError_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_memReadSystemError"
    VAL_BLK
    0x80801D9C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_memWriteBlock_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_memWriteBlock"
    VAL_BLK
    0x80801DA0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_moOV_FirstConstADC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_moOV_FirstConstADC"
    VAL_BLK
    0x80801DA4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_moOV_SecondConstADC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_moOV_SecondConstADC"
    VAL_BLK
    0x80801DA8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_moUV_FirstConstADC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_moUV_FirstConstADC"
    VAL_BLK
    0x80801DAC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_moUV_SecondConstADC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_moUV_SecondConstADC"
    VAL_BLK
    0x80801DB0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_INH_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_INH"
    VAL_BLK
    0x80801DB4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_INHLatch_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_INHLatch"
    VAL_BLK
    0x80801DB8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_adcPDD_fail_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_adcPDD_fail"
    VAL_BLK
    0x80801DBC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_memoryProtection_err_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_memoryProtection_err"
    VAL_BLK
    0x80801DC0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA02OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA02OC"
    VAL_BLK
    0x80801DC4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA02Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA02Unintended"
    VAL_BLK
    0x80801DC8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA03OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA03OC"
    VAL_BLK
    0x80801DCC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA03Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA03Unintended"
    VAL_BLK
    0x80801DD0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA04OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA04OC"
    VAL_BLK
    0x80801DD4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA04Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA04Unintended"
    VAL_BLK
    0x80801DD8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA05OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA05OC"
    VAL_BLK
    0x80801DDC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA05Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA05Unintended"
    VAL_BLK
    0x80801DE0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA07OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA07OC"
    VAL_BLK
    0x80801DE4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA07Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA07Unintended"
    VAL_BLK
    0x80801DE8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA08OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA08OC"
    VAL_BLK
    0x80801DEC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA08Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA08Unintended"
    VAL_BLK
    0x80801DF0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA09OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA09OC"
    VAL_BLK
    0x80801DF4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA09Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA09Unintended"
    VAL_BLK
    0x80801DF8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA10OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA10OC"
    VAL_BLK
    0x80801DFC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA10Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA10Unintended"
    VAL_BLK
    0x80801E00
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA17OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA17OC"
    VAL_BLK
    0x80801E04
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA17Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA17Unintended"
    VAL_BLK
    0x80801E08
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA18OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA18OC"
    VAL_BLK
    0x80801E0C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA18Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA18Unintended"
    VAL_BLK
    0x80801E10
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA19OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA19OC"
    VAL_BLK
    0x80801E14
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA19Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA19Unintended"
    VAL_BLK
    0x80801E18
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA20OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA20OC"
    VAL_BLK
    0x80801E1C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA20Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA20Unintended"
    VAL_BLK
    0x80801E20
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA31OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA31OC"
    VAL_BLK
    0x80801E24
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA31Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA31Unintended"
    VAL_BLK
    0x80801E28
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA32OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA32OC"
    VAL_BLK
    0x80801E2C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA32Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA32Unintended"
    VAL_BLK
    0x80801E30
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA33OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA33OC"
    VAL_BLK
    0x80801E34
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA33Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA33Unintended"
    VAL_BLK
    0x80801E38
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA34OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA34OC"
    VAL_BLK
    0x80801E3C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA34Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA34Unintended"
    VAL_BLK
    0x80801E40
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA35OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA35OC"
    VAL_BLK
    0x80801E44
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA35Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA35Unintended"
    VAL_BLK
    0x80801E48
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA46OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA46OC"
    VAL_BLK
    0x80801E4C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA46Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA46Unintended"
    VAL_BLK
    0x80801E50
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA47OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA47OC"
    VAL_BLK
    0x80801E54
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA47Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA47Unintended"
    VAL_BLK
    0x80801E58
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA48OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA48OC"
    VAL_BLK
    0x80801E5C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA48Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA48Unintended"
    VAL_BLK
    0x80801E60
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA51OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA51OC"
    VAL_BLK
    0x80801E64
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA51Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA51Unintended"
    VAL_BLK
    0x80801E68
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA52OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA52OC"
    VAL_BLK
    0x80801E6C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA52Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA52Unintended"
    VAL_BLK
    0x80801E70
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA53OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA53OC"
    VAL_BLK
    0x80801E74
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA53Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA53Unintended"
    VAL_BLK
    0x80801E78
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA54OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA54OC"
    VAL_BLK
    0x80801E7C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA54Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA54Unintended"
    VAL_BLK
    0x80801E80
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outAov_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outAov"
    VAL_BLK
    0x80801E84
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outAovCfg_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outAovCfg"
    VAL_BLK
    0x80801E88
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outAovCfgPI_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outAovCfgPI"
    VAL_BLK
    0x80801E8C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outAovGetStatus_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outAovGetStatus"
    VAL_BLK
    0x80801E90
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outAovGetVoltage_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outAovGetVoltage"
    VAL_BLK
    0x80801E94
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outAovResetError_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outAovResetError"
    VAL_BLK
    0x80801E98
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outDo_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outDo"
    VAL_BLK
    0x80801E9C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outDoCfgPwrLs_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outDoCfgPwrLs"
    VAL_BLK
    0x80801EA0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outDoDisable_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outDoDisable"
    VAL_BLK
    0x80801EA4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outDoGetCurrent_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outDoGetCurrent"
    VAL_BLK
    0x80801EA8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outDoGetStatus_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outDoGetStatus"
    VAL_BLK
    0x80801EAC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outDoResetError_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outDoResetError"
    VAL_BLK
    0x80801EB0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK07OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK07OC"
    VAL_BLK
    0x80801EB4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK07Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK07Unintended"
    VAL_BLK
    0x80801EB8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK08OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK08OC"
    VAL_BLK
    0x80801EBC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK08Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK08Unintended"
    VAL_BLK
    0x80801EC0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK09OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK09OC"
    VAL_BLK
    0x80801EC4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK09Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK09Unintended"
    VAL_BLK
    0x80801EC8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK12OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK12OC"
    VAL_BLK
    0x80801ECC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK12Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK12Unintended"
    VAL_BLK
    0x80801ED0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK13OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK13OC"
    VAL_BLK
    0x80801ED4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK13Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK13Unintended"
    VAL_BLK
    0x80801ED8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK14OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK14OC"
    VAL_BLK
    0x80801EDC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK14Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK14Unintended"
    VAL_BLK
    0x80801EE0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK15OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK15OC"
    VAL_BLK
    0x80801EE4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK15Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK15Unintended"
    VAL_BLK
    0x80801EE8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK16OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK16OC"
    VAL_BLK
    0x80801EEC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK16Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK16Unintended"
    VAL_BLK
    0x80801EF0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK17OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK17OC"
    VAL_BLK
    0x80801EF4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK17Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK17Unintended"
    VAL_BLK
    0x80801EF8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK29OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK29OC"
    VAL_BLK
    0x80801EFC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK29Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK29Unintended"
    VAL_BLK
    0x80801F00
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK51OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK51OC"
    VAL_BLK
    0x80801F04
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK51Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK51Unintended"
    VAL_BLK
    0x80801F08
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK73OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK73OC"
    VAL_BLK
    0x80801F0C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK73Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK73Unintended"
    VAL_BLK
    0x80801F10
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outPo_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outPo"
    VAL_BLK
    0x80801F14
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outPoCfg_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outPoCfg"
    VAL_BLK
    0x80801F18
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outPoCfgPeriod_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outPoCfgPeriod"
    VAL_BLK
    0x80801F1C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outPoCfgPwrLs_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outPoCfgPwrLs"
    VAL_BLK
    0x80801F20
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outPoDisable_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outPoDisable"
    VAL_BLK
    0x80801F24
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outPoGetCurrent_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outPoGetCurrent"
    VAL_BLK
    0x80801F28
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outPoGetStatus_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outPoGetStatus"
    VAL_BLK
    0x80801F2C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outPoResetError_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outPoResetError"
    VAL_BLK
    0x80801F30
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outPoc_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outPoc"
    VAL_BLK
    0x80801F34
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outPocCfg_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outPocCfg"
    VAL_BLK
    0x80801F38
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outPocCfgDither_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outPocCfgDither"
    VAL_BLK
    0x80801F3C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outPocCfgPI_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outPocCfgPI"
    VAL_BLK
    0x80801F40
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outPod_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outPod"
    VAL_BLK
    0x80801F44
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outPodCfg_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outPodCfg"
    VAL_BLK
    0x80801F48
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outPodCfgPeriod_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outPodCfgPeriod"
    VAL_BLK
    0x80801F4C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_rsmFfiApiCallErr_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_rsmFfiApiCallErr"
    VAL_BLK
    0x80801F50
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safout_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safout"
    VAL_BLK
    0x80801F54
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutCfg_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutCfg"
    VAL_BLK
    0x80801F58
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl1_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl1"
    VAL_BLK
    0x80801F5C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl10_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl10"
    VAL_BLK
    0x80801F60
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl10Dev_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl10Dev"
    VAL_BLK
    0x80801F64
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl10OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl10OR"
    VAL_BLK
    0x80801F68
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl11_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl11"
    VAL_BLK
    0x80801F6C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl11Dev_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl11Dev"
    VAL_BLK
    0x80801F70
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl11OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl11OR"
    VAL_BLK
    0x80801F74
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl12_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl12"
    VAL_BLK
    0x80801F78
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl12Dev_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl12Dev"
    VAL_BLK
    0x80801F7C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl12OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl12OR"
    VAL_BLK
    0x80801F80
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl13_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl13"
    VAL_BLK
    0x80801F84
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl13Dev_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl13Dev"
    VAL_BLK
    0x80801F88
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl13OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl13OR"
    VAL_BLK
    0x80801F8C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl14_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl14"
    VAL_BLK
    0x80801F90
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl14Dev_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl14Dev"
    VAL_BLK
    0x80801F94
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl14OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl14OR"
    VAL_BLK
    0x80801F98
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl15_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl15"
    VAL_BLK
    0x80801F9C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl15Dev_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl15Dev"
    VAL_BLK
    0x80801FA0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl15OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl15OR"
    VAL_BLK
    0x80801FA4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl16_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl16"
    VAL_BLK
    0x80801FA8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl16Dev_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl16Dev"
    VAL_BLK
    0x80801FAC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl16OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl16OR"
    VAL_BLK
    0x80801FB0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl17_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl17"
    VAL_BLK
    0x80801FB4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl17Dev_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl17Dev"
    VAL_BLK
    0x80801FB8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl17OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl17OR"
    VAL_BLK
    0x80801FBC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl18_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl18"
    VAL_BLK
    0x80801FC0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl18Dev_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl18Dev"
    VAL_BLK
    0x80801FC4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl18OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl18OR"
    VAL_BLK
    0x80801FC8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl1Dev_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl1Dev"
    VAL_BLK
    0x80801FCC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl1OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl1OR"
    VAL_BLK
    0x80801FD0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl2_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl2"
    VAL_BLK
    0x80801FD4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl2Dev_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl2Dev"
    VAL_BLK
    0x80801FD8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl2OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl2OR"
    VAL_BLK
    0x80801FDC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl3_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl3"
    VAL_BLK
    0x80801FE0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl3Dev_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl3Dev"
    VAL_BLK
    0x80801FE4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl3OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl3OR"
    VAL_BLK
    0x80801FE8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl4_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl4"
    VAL_BLK
    0x80801FEC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl4Dev_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl4Dev"
    VAL_BLK
    0x80801FF0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl4OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl4OR"
    VAL_BLK
    0x80801FF4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl5_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl5"
    VAL_BLK
    0x80801FF8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl5Dev_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl5Dev"
    VAL_BLK
    0x80801FFC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl5OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl5OR"
    VAL_BLK
    0x80802000
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl6_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl6"
    VAL_BLK
    0x80802004
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl6Dev_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl6Dev"
    VAL_BLK
    0x80802008
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl6OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl6OR"
    VAL_BLK
    0x8080200C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl7_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl7"
    VAL_BLK
    0x80802010
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl7Dev_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl7Dev"
    VAL_BLK
    0x80802014
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl7OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl7OR"
    VAL_BLK
    0x80802018
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl8_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl8"
    VAL_BLK
    0x8080201C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl8Dev_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl8Dev"
    VAL_BLK
    0x80802020
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl8OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl8OR"
    VAL_BLK
    0x80802024
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl9_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl9"
    VAL_BLK
    0x80802028
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl9Dev_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl9Dev"
    VAL_BLK
    0x8080202C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl9OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl9OR"
    VAL_BLK
    0x80802030
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutDevError_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutDevError"
    VAL_BLK
    0x80802034
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutGetStatus_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutGetStatus"
    VAL_BLK
    0x80802038
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutIgnoreError_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutIgnoreError"
    VAL_BLK
    0x8080203C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutResetError_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutResetError"
    VAL_BLK
    0x80802040
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutUnlock_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutUnlock"
    VAL_BLK
    0x80802044
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safout_cfgDiag_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safout_cfgDiag"
    VAL_BLK
    0x80802048
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_secAccessDenied_RC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_secAccessDenied_RC"
    VAL_BLK
    0x8080204C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_secAccessDenied_WDBI_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_secAccessDenied_WDBI"
    VAL_BLK
    0x80802050
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_secEvalRespKey_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_secEvalRespKey"
    VAL_BLK
    0x80802054
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_secFlashingFailure_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_secFlashingFailure"
    VAL_BLK
    0x80802058
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_secGetLevel_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_secGetLevel"
    VAL_BLK
    0x8080205C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_secGetRnd_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_secGetRnd"
    VAL_BLK
    0x80802060
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_secGetSeed_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_secGetSeed"
    VAL_BLK
    0x80802064
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_secInvalidPassword_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_secInvalidPassword"
    VAL_BLK
    0x80802068
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_secIsRequestAllowed_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_secIsRequestAllowed"
    VAL_BLK
    0x8080206C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_secResetLevel_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_secResetLevel"
    VAL_BLK
    0x80802070
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_secSaveSecret_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_secSaveSecret"
    VAL_BLK
    0x80802074
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_secSetLevel_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_secSetLevel"
    VAL_BLK
    0x80802078
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_sysAit_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_sysAit"
    VAL_BLK
    0x8080207C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_sysAiv_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_sysAiv"
    VAL_BLK
    0x80802080
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_sysDi_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_sysDi"
    VAL_BLK
    0x80802084
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_sysDo_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_sysDo"
    VAL_BLK
    0x80802088
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_sysGetVss_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_sysGetVss"
    VAL_BLK
    0x8080208C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_sysInit_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_sysInit"
    VAL_BLK
    0x80802090
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_sysOperHrIntegrityErr_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_sysOperHrIntegrityErr"
    VAL_BLK
    0x80802094
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_sysOperHrsSaturated_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_sysOperHrsSaturated"
    VAL_BLK
    0x80802098
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_sysSetVss_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_sysSetVss"
    VAL_BLK
    0x8080209C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_sys_coreload_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_sys_coreload"
    VAL_BLK
    0x808020A0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_sys_taskload_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_sys_taskload"
    VAL_BLK
    0x808020A4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_OV_VSS1_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_OV_VSS1"
    VAL_BLK
    0x808020A8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_OV_VSS2_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_OV_VSS2"
    VAL_BLK
    0x808020AC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_UV_VSS1_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_UV_VSS1"
    VAL_BLK
    0x808020B0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_UV_VSS2_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_UV_VSS2"
    VAL_BLK
    0x808020B4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_CANSM_E_BUS_OFF_NETWORK_0_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_CANSM_E_BUS_OFF_NETWORK_0"
    VAL_BLK
    0x808020B8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_CANSM_E_BUS_OFF_NETWORK_1_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_CANSM_E_BUS_OFF_NETWORK_1"
    VAL_BLK
    0x808020BC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_CANSM_E_BUS_OFF_NETWORK_2_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_CANSM_E_BUS_OFF_NETWORK_2"
    VAL_BLK
    0x808020C0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_CANSM_E_BUS_OFF_NETWORK_3_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_CANSM_E_BUS_OFF_NETWORK_3"
    VAL_BLK
    0x808020C4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_CANTRCV_E_NO_TRCV_CONTROL_0_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_CANTRCV_E_NO_TRCV_CONTROL_0"
    VAL_BLK
    0x808020C8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_CAN_E_TIMEOUT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_CAN_E_TIMEOUT"
    VAL_BLK
    0x808020CC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_COMM_E_NET_START_IND_CHANNEL_0_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_COMM_E_NET_START_IND_CHANNEL_0"
    VAL_BLK
    0x808020D0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_COMM_E_NET_START_IND_CHANNEL_1_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_COMM_E_NET_START_IND_CHANNEL_1"
    VAL_BLK
    0x808020D4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_COMM_E_NET_START_IND_CHANNEL_2_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_COMM_E_NET_START_IND_CHANNEL_2"
    VAL_BLK
    0x808020D8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_COMM_E_NET_START_IND_CHANNEL_3_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_COMM_E_NET_START_IND_CHANNEL_3"
    VAL_BLK
    0x808020DC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_COMM_E_NET_START_IND_CHANNEL_4_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_COMM_E_NET_START_IND_CHANNEL_4"
    VAL_BLK
    0x808020E0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_COMM_E_NET_START_IND_CHANNEL_5_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_COMM_E_NET_START_IND_CHANNEL_5"
    VAL_BLK
    0x808020E4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_LIN_E_TIMEOUT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_LIN_E_TIMEOUT"
    VAL_BLK
    0x808020E8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rba_MultiStackTrace_Threshold_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rba_MultiStackTrace_Threshold"
    VAL_BLK
    0x808020EC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_ETH_E_ACCESS_0_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_ETH_E_ACCESS_0"
    VAL_BLK
    0x808020F0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_RBA_IOEXTLIB_KEEPALIVE_DRV_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_RBA_IOEXTLIB_KEEPALIVE_DRV"
    VAL_BLK
    0x808020F4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_RBA_IOEXTLIB_KEEPALIVE_INI_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_RBA_IOEXTLIB_KEEPALIVE_INI"
    VAL_BLK
    0x808020F8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rba_MRly_Diag_Stk_Event_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rba_MRly_Diag_Stk_Event"
    VAL_BLK
    0x808020FC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rba_MemDiagExtd_MemReadSngErr_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rba_MemDiagExtd_MemReadSngErr"
    VAL_BLK
    0x80802100
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rba_MemDiag_MemReadErr_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rba_MemDiag_MemReadErr"
    VAL_BLK
    0x80802104
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rba_MemDiag_MemWrErr_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rba_MemDiag_MemWrErr"
    VAL_BLK
    0x80802108
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rba_SyC_IrrSwOffTrigEngRun_Event_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rba_SyC_IrrSwOffTrigEngRun_Event"
    VAL_BLK
    0x8080210C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rba_T15_Diag_ComInVld_Event_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rba_T15_Diag_ComInVld_Event"
    VAL_BLK
    0x80802110
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rba_T15_Diag_ComOff_HwOn_Event_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rba_T15_Diag_ComOff_HwOn_Event"
    VAL_BLK
    0x80802114
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rba_T15_Diag_ComOn_HwOff_Event_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rba_T15_Diag_ComOn_HwOff_Event"
    VAL_BLK
    0x80802118
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM0_0_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM0_0"
    VAL_BLK
    0x8080211C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM0_1_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM0_1"
    VAL_BLK
    0x80802120
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM0_10_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM0_10"
    VAL_BLK
    0x80802124
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM0_11_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM0_11"
    VAL_BLK
    0x80802128
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM0_13_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM0_13"
    VAL_BLK
    0x8080212C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM0_14_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM0_14"
    VAL_BLK
    0x80802130
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM0_2_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM0_2"
    VAL_BLK
    0x80802134
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM0_22_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM0_22"
    VAL_BLK
    0x80802138
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM0_23_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM0_23"
    VAL_BLK
    0x8080213C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM0_4_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM0_4"
    VAL_BLK
    0x80802140
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM0_5_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM0_5"
    VAL_BLK
    0x80802144
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM0_7_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM0_7"
    VAL_BLK
    0x80802148
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM0_8_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM0_8"
    VAL_BLK
    0x8080214C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM10_16_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM10_16"
    VAL_BLK
    0x80802150
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM10_17_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM10_17"
    VAL_BLK
    0x80802154
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM10_21_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM10_21"
    VAL_BLK
    0x80802158
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM11_0_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM11_0"
    VAL_BLK
    0x8080215C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM11_1_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM11_1"
    VAL_BLK
    0x80802160
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM11_2_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM11_2"
    VAL_BLK
    0x80802164
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM11_3_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM11_3"
    VAL_BLK
    0x80802168
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM11_4_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM11_4"
    VAL_BLK
    0x8080216C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM11_5_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM11_5"
    VAL_BLK
    0x80802170
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM11_8_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM11_8"
    VAL_BLK
    0x80802174
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM11_9_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM11_9"
    VAL_BLK
    0x80802178
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM1_0_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM1_0"
    VAL_BLK
    0x8080217C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM1_1_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM1_1"
    VAL_BLK
    0x80802180
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM1_10_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM1_10"
    VAL_BLK
    0x80802184
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM1_11_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM1_11"
    VAL_BLK
    0x80802188
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM1_13_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM1_13"
    VAL_BLK
    0x8080218C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM1_14_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM1_14"
    VAL_BLK
    0x80802190
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM1_2_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM1_2"
    VAL_BLK
    0x80802194
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM1_22_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM1_22"
    VAL_BLK
    0x80802198
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM1_23_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM1_23"
    VAL_BLK
    0x8080219C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM1_4_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM1_4"
    VAL_BLK
    0x808021A0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM1_5_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM1_5"
    VAL_BLK
    0x808021A4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM1_7_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM1_7"
    VAL_BLK
    0x808021A8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM1_8_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM1_8"
    VAL_BLK
    0x808021AC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM21_0_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM21_0"
    VAL_BLK
    0x808021B0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM21_16_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM21_16"
    VAL_BLK
    0x808021B4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM21_3_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM21_3"
    VAL_BLK
    0x808021B8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM2_1_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM2_1"
    VAL_BLK
    0x808021BC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM2_10_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM2_10"
    VAL_BLK
    0x808021C0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM2_11_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM2_11"
    VAL_BLK
    0x808021C4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM2_13_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM2_13"
    VAL_BLK
    0x808021C8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM2_14_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM2_14"
    VAL_BLK
    0x808021CC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM2_2_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM2_2"
    VAL_BLK
    0x808021D0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM2_22_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM2_22"
    VAL_BLK
    0x808021D4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM2_23_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM2_23"
    VAL_BLK
    0x808021D8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM2_4_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM2_4"
    VAL_BLK
    0x808021DC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM2_5_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM2_5"
    VAL_BLK
    0x808021E0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM2_7_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM2_7"
    VAL_BLK
    0x808021E4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM2_8_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM2_8"
    VAL_BLK
    0x808021E8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM3_1_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM3_1"
    VAL_BLK
    0x808021EC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM3_10_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM3_10"
    VAL_BLK
    0x808021F0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM3_11_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM3_11"
    VAL_BLK
    0x808021F4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM3_13_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM3_13"
    VAL_BLK
    0x808021F8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM3_14_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM3_14"
    VAL_BLK
    0x808021FC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM3_2_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM3_2"
    VAL_BLK
    0x80802200
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM3_22_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM3_22"
    VAL_BLK
    0x80802204
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM3_23_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM3_23"
    VAL_BLK
    0x80802208
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM3_4_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM3_4"
    VAL_BLK
    0x8080220C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM3_5_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM3_5"
    VAL_BLK
    0x80802210
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM3_7_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM3_7"
    VAL_BLK
    0x80802214
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM3_8_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM3_8"
    VAL_BLK
    0x80802218
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM6_0_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM6_0"
    VAL_BLK
    0x8080221C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM6_11_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM6_11"
    VAL_BLK
    0x80802220
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM6_12_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM6_12"
    VAL_BLK
    0x80802224
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM6_14_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM6_14"
    VAL_BLK
    0x80802228
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM6_15_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM6_15"
    VAL_BLK
    0x8080222C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM6_17_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM6_17"
    VAL_BLK
    0x80802230
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM6_18_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM6_18"
    VAL_BLK
    0x80802234
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM6_2_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM6_2"
    VAL_BLK
    0x80802238
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM6_20_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM6_20"
    VAL_BLK
    0x8080223C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM6_21_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM6_21"
    VAL_BLK
    0x80802240
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM6_25_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM6_25"
    VAL_BLK
    0x80802244
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM6_4_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM6_4"
    VAL_BLK
    0x80802248
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM6_5_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM6_5"
    VAL_BLK
    0x8080224C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM6_7_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM6_7"
    VAL_BLK
    0x80802250
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM6_8_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM6_8"
    VAL_BLK
    0x80802254
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM7_1_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM7_1"
    VAL_BLK
    0x80802258
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM7_12_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM7_12"
    VAL_BLK
    0x8080225C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM7_13_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM7_13"
    VAL_BLK
    0x80802260
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM7_14_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM7_14"
    VAL_BLK
    0x80802264
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM7_15_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM7_15"
    VAL_BLK
    0x80802268
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM7_16_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM7_16"
    VAL_BLK
    0x8080226C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM7_17_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM7_17"
    VAL_BLK
    0x80802270
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM7_2_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM7_2"
    VAL_BLK
    0x80802274
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM7_20_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM7_20"
    VAL_BLK
    0x80802278
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM7_25_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM7_25"
    VAL_BLK
    0x8080227C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM7_26_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM7_26"
    VAL_BLK
    0x80802280
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM7_28_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM7_28"
    VAL_BLK
    0x80802284
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM7_29_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM7_29"
    VAL_BLK
    0x80802288
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM7_30_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM7_30"
    VAL_BLK
    0x8080228C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM7_31_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM7_31"
    VAL_BLK
    0x80802290
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM8_0_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM8_0"
    VAL_BLK
    0x80802294
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM8_1_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM8_1"
    VAL_BLK
    0x80802298
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM8_10_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM8_10"
    VAL_BLK
    0x8080229C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM8_11_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM8_11"
    VAL_BLK
    0x808022A0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM8_12_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM8_12"
    VAL_BLK
    0x808022A4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM8_13_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM8_13"
    VAL_BLK
    0x808022A8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM8_16_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM8_16"
    VAL_BLK
    0x808022AC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM8_18_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM8_18"
    VAL_BLK
    0x808022B0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM8_2_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM8_2"
    VAL_BLK
    0x808022B4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM8_3_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM8_3"
    VAL_BLK
    0x808022B8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM8_30_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM8_30"
    VAL_BLK
    0x808022BC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM8_31_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM8_31"
    VAL_BLK
    0x808022C0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM8_4_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM8_4"
    VAL_BLK
    0x808022C4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM9_0_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM9_0"
    VAL_BLK
    0x808022C8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM9_1_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM9_1"
    VAL_BLK
    0x808022CC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM9_15_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM9_15"
    VAL_BLK
    0x808022D0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM9_3_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM9_3"
    VAL_BLK
    0x808022D4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MoCSOPICO_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MoCSOPICO"
    VAL_BLK
    0x808022D8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MoFVarPostBldSel_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MoFVarPostBldSel"
    VAL_BLK
    0x808022DC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MoSysCtrlReIni_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MoSysCtrlReIni"
    VAL_BLK
    0x808022E0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MoXEMMHwLTMCUFW_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MoXEMMHwLTMCUFW"
    VAL_BLK
    0x808022E4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MoXEMMHwLTMonBIST_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MoXEMMHwLTMonBIST"
    VAL_BLK
    0x808022E8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MoXEMMHwLTRegMonTest_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MoXEMMHwLTRegMonTest"
    VAL_BLK
    0x808022EC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MoXEMMHwLTStbySMUAlvTest_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MoXEMMHwLTStbySMUAlvTest"
    VAL_BLK
    0x808022F0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MoXEMMHwLTTempSens_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MoXEMMHwLTTempSens"
    VAL_BLK
    0x808022F4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MoXEMMHwLTUCBCfg_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MoXEMMHwLTUCBCfg"
    VAL_BLK
    0x808022F8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_OCWDAABEActv_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_OCWDAABEActv"
    VAL_BLK
    0x808022FC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_OCWDACom_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_OCWDACom"
    VAL_BLK
    0x80802300
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_OCWDAErrPin_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_OCWDAErrPin"
    VAL_BLK
    0x80802304
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_SWReset_0_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_SWReset_0"
    VAL_BLK
    0x80802308
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_SWReset_1_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_SWReset_1"
    VAL_BLK
    0x8080230C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_SWReset_2_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_SWReset_2"
    VAL_BLK
    0x80802310
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDebFault1_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDebFault1"
    VAL_BLK
    0x80802314
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 3 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DSQ_DSMInhibitAlways_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DSQ_DSMInhibitAlways"
    VAL_BLK
    0x8080231A
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 3 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DSQ_ErrLmpActrMIL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DSQ_ErrLmpActrMIL"
    VAL_BLK
    0x80802320
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DSQ_ErrLmpActrSVS_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DSQ_ErrLmpActrSVS"
    VAL_BLK
    0x80802324
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DSQ_StopLmp_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DSQ_StopLmp"
    VAL_BLK
    0x80802328
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DSQ_T15TurnOfDly_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DSQ_T15TurnOfDly"
    VAL_BLK
    0x8080232C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DSQ_WrnLmp_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DSQ_WrnLmp"
    VAL_BLK
    0x80802330
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_TimeInRowDebFault_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_TimeInRowDebFault"
    VAL_BLK
    0x8080334C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_EventInRowDebFault_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_EventInRowDebFault"
    VAL_BLK
    0x8080334E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_DevLibBattUHi_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_DevLibBattUHi"
    VAL_BLK
    0x80803350
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_DevLibBattULo_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_DevLibBattULo"
    VAL_BLK
    0x80803352
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_TimeUpDownDebFault_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_TimeUpDownDebFault"
    VAL_BLK
    0x80803354
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA13OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA13OR"
    VAL_BLK
    0x80803356
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA13SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA13SCB"
    VAL_BLK
    0x80803358
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA13SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA13SCG"
    VAL_BLK
    0x8080335A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA14OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA14OR"
    VAL_BLK
    0x8080335C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA14SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA14SCB"
    VAL_BLK
    0x8080335E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA14SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA14SCG"
    VAL_BLK
    0x80803360
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA21OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA21OR"
    VAL_BLK
    0x80803362
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA21SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA21SCB"
    VAL_BLK
    0x80803364
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA21SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA21SCG"
    VAL_BLK
    0x80803366
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA22OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA22OR"
    VAL_BLK
    0x80803368
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA22SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA22SCB"
    VAL_BLK
    0x8080336A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA22SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA22SCG"
    VAL_BLK
    0x8080336C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA23OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA23OR"
    VAL_BLK
    0x8080336E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA23SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA23SCB"
    VAL_BLK
    0x80803370
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA23SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA23SCG"
    VAL_BLK
    0x80803372
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA24OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA24OR"
    VAL_BLK
    0x80803374
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA24SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA24SCB"
    VAL_BLK
    0x80803376
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA24SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA24SCG"
    VAL_BLK
    0x80803378
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA25OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA25OR"
    VAL_BLK
    0x8080337A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA25SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA25SCB"
    VAL_BLK
    0x8080337C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA25SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA25SCG"
    VAL_BLK
    0x8080337E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA26OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA26OR"
    VAL_BLK
    0x80803380
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA26SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA26SCB"
    VAL_BLK
    0x80803382
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA26SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA26SCG"
    VAL_BLK
    0x80803384
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA27OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA27OR"
    VAL_BLK
    0x80803386
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA27SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA27SCB"
    VAL_BLK
    0x80803388
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA27SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA27SCG"
    VAL_BLK
    0x8080338A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA28OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA28OR"
    VAL_BLK
    0x8080338C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA28SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA28SCB"
    VAL_BLK
    0x8080338E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA28SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA28SCG"
    VAL_BLK
    0x80803390
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA29OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA29OR"
    VAL_BLK
    0x80803392
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA29SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA29SCB"
    VAL_BLK
    0x80803394
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA29SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA29SCG"
    VAL_BLK
    0x80803396
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA36AicSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA36AicSCB"
    VAL_BLK
    0x80803398
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA36AicSCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA36AicSCG"
    VAL_BLK
    0x8080339A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA36OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA36OR"
    VAL_BLK
    0x8080339C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA36SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA36SCB"
    VAL_BLK
    0x8080339E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA36SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA36SCG"
    VAL_BLK
    0x808033A0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA36ShuntSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA36ShuntSCB"
    VAL_BLK
    0x808033A2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA37AicSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA37AicSCB"
    VAL_BLK
    0x808033A4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA37AicSCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA37AicSCG"
    VAL_BLK
    0x808033A6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA37OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA37OR"
    VAL_BLK
    0x808033A8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA37SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA37SCB"
    VAL_BLK
    0x808033AA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA37SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA37SCG"
    VAL_BLK
    0x808033AC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA37ShuntSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA37ShuntSCB"
    VAL_BLK
    0x808033AE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA38AicSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA38AicSCB"
    VAL_BLK
    0x808033B0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA38AicSCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA38AicSCG"
    VAL_BLK
    0x808033B2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA38OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA38OR"
    VAL_BLK
    0x808033B4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA38SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA38SCB"
    VAL_BLK
    0x808033B6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA38SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA38SCG"
    VAL_BLK
    0x808033B8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA38ShuntSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA38ShuntSCB"
    VAL_BLK
    0x808033BA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA39AicSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA39AicSCB"
    VAL_BLK
    0x808033BC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA39AicSCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA39AicSCG"
    VAL_BLK
    0x808033BE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA39OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA39OR"
    VAL_BLK
    0x808033C0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA39SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA39SCB"
    VAL_BLK
    0x808033C2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA39SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA39SCG"
    VAL_BLK
    0x808033C4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA39ShuntSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA39ShuntSCB"
    VAL_BLK
    0x808033C6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA40OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA40OR"
    VAL_BLK
    0x808033C8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA40SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA40SCB"
    VAL_BLK
    0x808033CA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA40SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA40SCG"
    VAL_BLK
    0x808033CC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA41OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA41OR"
    VAL_BLK
    0x808033CE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA41SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA41SCB"
    VAL_BLK
    0x808033D0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA41SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA41SCG"
    VAL_BLK
    0x808033D2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA42OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA42OR"
    VAL_BLK
    0x808033D4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA42SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA42SCB"
    VAL_BLK
    0x808033D6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA42SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA42SCG"
    VAL_BLK
    0x808033D8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA43AicSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA43AicSCB"
    VAL_BLK
    0x808033DA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA43AicSCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA43AicSCG"
    VAL_BLK
    0x808033DC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA43OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA43OR"
    VAL_BLK
    0x808033DE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA43SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA43SCB"
    VAL_BLK
    0x808033E0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA43SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA43SCG"
    VAL_BLK
    0x808033E2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA43ShuntSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA43ShuntSCB"
    VAL_BLK
    0x808033E4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA44OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA44OL"
    VAL_BLK
    0x808033E6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA44SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA44SCB"
    VAL_BLK
    0x808033E8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA44SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA44SCG"
    VAL_BLK
    0x808033EA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA57OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA57OR"
    VAL_BLK
    0x808033EC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA57SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA57SCB"
    VAL_BLK
    0x808033EE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA57SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA57SCG"
    VAL_BLK
    0x808033F0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA59OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA59OL"
    VAL_BLK
    0x808033F2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA59SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA59SCB"
    VAL_BLK
    0x808033F4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA59SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA59SCG"
    VAL_BLK
    0x808033F6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK10OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK10OR"
    VAL_BLK
    0x808033F8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK10SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK10SCB"
    VAL_BLK
    0x808033FA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK10SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK10SCG"
    VAL_BLK
    0x808033FC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK11OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK11OR"
    VAL_BLK
    0x808033FE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK11SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK11SCB"
    VAL_BLK
    0x80803400
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK11SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK11SCG"
    VAL_BLK
    0x80803402
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK30AicSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK30AicSCB"
    VAL_BLK
    0x80803404
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK30AicSCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK30AicSCG"
    VAL_BLK
    0x80803406
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK30OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK30OR"
    VAL_BLK
    0x80803408
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK30SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK30SCB"
    VAL_BLK
    0x8080340A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK30SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK30SCG"
    VAL_BLK
    0x8080340C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK30ShuntSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK30ShuntSCB"
    VAL_BLK
    0x8080340E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK31OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK31OR"
    VAL_BLK
    0x80803410
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK31SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK31SCB"
    VAL_BLK
    0x80803412
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK31SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK31SCG"
    VAL_BLK
    0x80803414
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK32OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK32OR"
    VAL_BLK
    0x80803416
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK32SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK32SCB"
    VAL_BLK
    0x80803418
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK32SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK32SCG"
    VAL_BLK
    0x8080341A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK33OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK33OR"
    VAL_BLK
    0x8080341C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK33SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK33SCB"
    VAL_BLK
    0x8080341E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK33SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK33SCG"
    VAL_BLK
    0x80803420
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK34OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK34OR"
    VAL_BLK
    0x80803422
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK34SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK34SCB"
    VAL_BLK
    0x80803424
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK34SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK34SCG"
    VAL_BLK
    0x80803426
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK35OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK35OR"
    VAL_BLK
    0x80803428
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK35SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK35SCB"
    VAL_BLK
    0x8080342A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK35SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK35SCG"
    VAL_BLK
    0x8080342C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK36OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK36OR"
    VAL_BLK
    0x8080342E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK36SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK36SCB"
    VAL_BLK
    0x80803430
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK36SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK36SCG"
    VAL_BLK
    0x80803432
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK37AicSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK37AicSCB"
    VAL_BLK
    0x80803434
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK37AicSCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK37AicSCG"
    VAL_BLK
    0x80803436
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK37OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK37OR"
    VAL_BLK
    0x80803438
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK37SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK37SCB"
    VAL_BLK
    0x8080343A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK37SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK37SCG"
    VAL_BLK
    0x8080343C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK37ShuntSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK37ShuntSCB"
    VAL_BLK
    0x8080343E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK38AicSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK38AicSCB"
    VAL_BLK
    0x80803440
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK38AicSCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK38AicSCG"
    VAL_BLK
    0x80803442
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK38OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK38OR"
    VAL_BLK
    0x80803444
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK38SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK38SCB"
    VAL_BLK
    0x80803446
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK38SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK38SCG"
    VAL_BLK
    0x80803448
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK38ShuntSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK38ShuntSCB"
    VAL_BLK
    0x8080344A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK39AicSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK39AicSCB"
    VAL_BLK
    0x8080344C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK39AicSCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK39AicSCG"
    VAL_BLK
    0x8080344E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK39OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK39OR"
    VAL_BLK
    0x80803450
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK39SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK39SCB"
    VAL_BLK
    0x80803452
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK39SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK39SCG"
    VAL_BLK
    0x80803454
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK39ShuntSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK39ShuntSCB"
    VAL_BLK
    0x80803456
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK40AicSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK40AicSCB"
    VAL_BLK
    0x80803458
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK40AicSCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK40AicSCG"
    VAL_BLK
    0x8080345A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK40OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK40OR"
    VAL_BLK
    0x8080345C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK40SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK40SCB"
    VAL_BLK
    0x8080345E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK40SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK40SCG"
    VAL_BLK
    0x80803460
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK40ShuntSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK40ShuntSCB"
    VAL_BLK
    0x80803462
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK41AicSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK41AicSCB"
    VAL_BLK
    0x80803464
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK41AicSCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK41AicSCG"
    VAL_BLK
    0x80803466
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK41OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK41OR"
    VAL_BLK
    0x80803468
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK41SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK41SCB"
    VAL_BLK
    0x8080346A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK41SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK41SCG"
    VAL_BLK
    0x8080346C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK41ShuntSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK41ShuntSCB"
    VAL_BLK
    0x8080346E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK42AicSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK42AicSCB"
    VAL_BLK
    0x80803470
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK42AicSCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK42AicSCG"
    VAL_BLK
    0x80803472
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK42OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK42OR"
    VAL_BLK
    0x80803474
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK42SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK42SCB"
    VAL_BLK
    0x80803476
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK42SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK42SCG"
    VAL_BLK
    0x80803478
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK42ShuntSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK42ShuntSCB"
    VAL_BLK
    0x8080347A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK43OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK43OR"
    VAL_BLK
    0x8080347C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK43SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK43SCB"
    VAL_BLK
    0x8080347E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK43SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK43SCG"
    VAL_BLK
    0x80803480
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK44AicSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK44AicSCB"
    VAL_BLK
    0x80803482
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK44AicSCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK44AicSCG"
    VAL_BLK
    0x80803484
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK44OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK44OR"
    VAL_BLK
    0x80803486
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK44SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK44SCB"
    VAL_BLK
    0x80803488
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK44SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK44SCG"
    VAL_BLK
    0x8080348A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK44ShuntSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK44ShuntSCB"
    VAL_BLK
    0x8080348C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK45AicSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK45AicSCB"
    VAL_BLK
    0x8080348E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK45AicSCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK45AicSCG"
    VAL_BLK
    0x80803490
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK45OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK45OR"
    VAL_BLK
    0x80803492
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK45SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK45SCB"
    VAL_BLK
    0x80803494
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK45SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK45SCG"
    VAL_BLK
    0x80803496
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK45ShuntSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK45ShuntSCB"
    VAL_BLK
    0x80803498
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK52OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK52OR"
    VAL_BLK
    0x8080349A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK52SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK52SCB"
    VAL_BLK
    0x8080349C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK52SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK52SCG"
    VAL_BLK
    0x8080349E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK53OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK53OR"
    VAL_BLK
    0x808034A0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK53SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK53SCB"
    VAL_BLK
    0x808034A2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK53SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK53SCG"
    VAL_BLK
    0x808034A4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK54AicSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK54AicSCB"
    VAL_BLK
    0x808034A6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK54AicSCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK54AicSCG"
    VAL_BLK
    0x808034A8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK54OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK54OR"
    VAL_BLK
    0x808034AA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK54SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK54SCB"
    VAL_BLK
    0x808034AC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK54SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK54SCG"
    VAL_BLK
    0x808034AE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK54ShuntSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK54ShuntSCB"
    VAL_BLK
    0x808034B0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK55AicSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK55AicSCB"
    VAL_BLK
    0x808034B2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK55AicSCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK55AicSCG"
    VAL_BLK
    0x808034B4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK55OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK55OR"
    VAL_BLK
    0x808034B6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK55SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK55SCB"
    VAL_BLK
    0x808034B8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK55SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK55SCG"
    VAL_BLK
    0x808034BA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK55ShuntSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK55ShuntSCB"
    VAL_BLK
    0x808034BC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK56OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK56OR"
    VAL_BLK
    0x808034BE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK56SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK56SCB"
    VAL_BLK
    0x808034C0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK56SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK56SCG"
    VAL_BLK
    0x808034C2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK57OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK57OR"
    VAL_BLK
    0x808034C4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK57SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK57SCB"
    VAL_BLK
    0x808034C6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK57SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK57SCG"
    VAL_BLK
    0x808034C8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK58OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK58OR"
    VAL_BLK
    0x808034CA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK58SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK58SCB"
    VAL_BLK
    0x808034CC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK58SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK58SCG"
    VAL_BLK
    0x808034CE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK59OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK59OR"
    VAL_BLK
    0x808034D0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK59SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK59SCB"
    VAL_BLK
    0x808034D2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK59SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK59SCG"
    VAL_BLK
    0x808034D4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK60OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK60OR"
    VAL_BLK
    0x808034D6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK60SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK60SCB"
    VAL_BLK
    0x808034D8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK60SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK60SCG"
    VAL_BLK
    0x808034DA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK61AicSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK61AicSCB"
    VAL_BLK
    0x808034DC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK61AicSCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK61AicSCG"
    VAL_BLK
    0x808034DE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK61OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK61OR"
    VAL_BLK
    0x808034E0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK61SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK61SCB"
    VAL_BLK
    0x808034E2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK61SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK61SCG"
    VAL_BLK
    0x808034E4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK61ShuntSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK61ShuntSCB"
    VAL_BLK
    0x808034E6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK62OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK62OR"
    VAL_BLK
    0x808034E8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK62SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK62SCB"
    VAL_BLK
    0x808034EA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK62SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK62SCG"
    VAL_BLK
    0x808034EC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK63AicSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK63AicSCB"
    VAL_BLK
    0x808034EE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK63AicSCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK63AicSCG"
    VAL_BLK
    0x808034F0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK63OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK63OR"
    VAL_BLK
    0x808034F2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK63SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK63SCB"
    VAL_BLK
    0x808034F4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK63SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK63SCG"
    VAL_BLK
    0x808034F6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK63ShuntSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK63ShuntSCB"
    VAL_BLK
    0x808034F8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK64AicSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK64AicSCB"
    VAL_BLK
    0x808034FA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK64AicSCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK64AicSCG"
    VAL_BLK
    0x808034FC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK64OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK64OR"
    VAL_BLK
    0x808034FE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK64SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK64SCB"
    VAL_BLK
    0x80803500
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK64SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK64SCG"
    VAL_BLK
    0x80803502
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK64ShuntSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK64ShuntSCB"
    VAL_BLK
    0x80803504
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK65AicSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK65AicSCB"
    VAL_BLK
    0x80803506
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK65AicSCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK65AicSCG"
    VAL_BLK
    0x80803508
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK65OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK65OR"
    VAL_BLK
    0x8080350A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK65SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK65SCB"
    VAL_BLK
    0x8080350C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK65SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK65SCG"
    VAL_BLK
    0x8080350E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK65ShuntSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK65ShuntSCB"
    VAL_BLK
    0x80803510
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK74OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK74OR"
    VAL_BLK
    0x80803512
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK74SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK74SCB"
    VAL_BLK
    0x80803514
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK74SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK74SCG"
    VAL_BLK
    0x80803516
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK75OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK75OR"
    VAL_BLK
    0x80803518
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK75SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK75SCB"
    VAL_BLK
    0x8080351A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK75SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK75SCG"
    VAL_BLK
    0x8080351C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK76OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK76OR"
    VAL_BLK
    0x8080351E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK76SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK76SCB"
    VAL_BLK
    0x80803520
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK76SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK76SCG"
    VAL_BLK
    0x80803522
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK77OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK77OR"
    VAL_BLK
    0x80803524
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK77SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK77SCB"
    VAL_BLK
    0x80803526
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK77SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK77SCG"
    VAL_BLK
    0x80803528
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK78OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK78OR"
    VAL_BLK
    0x8080352A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK78SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK78SCB"
    VAL_BLK
    0x8080352C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK78SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK78SCG"
    VAL_BLK
    0x8080352E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_DvUBAT_FWs_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_DvUBAT_FWs"
    VAL_BLK
    0x80803530
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_OVErr_VPR6_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_OVErr_VPR6"
    VAL_BLK
    0x80803532
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_OVWarn_VPR6_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_OVWarn_VPR6"
    VAL_BLK
    0x80803534
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3"
    VAL_BLK
    0x80803536
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2"
    VAL_BLK
    0x80803538
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_OV_UBAT_MON_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_OV_UBAT_MON"
    VAL_BLK
    0x8080353A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_OV_UBRM24_FLEXIN_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_OV_UBRM24_FLEXIN"
    VAL_BLK
    0x8080353C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_OV_UBRM24_LOADS_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_OV_UBRM24_LOADS"
    VAL_BLK
    0x8080353E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_OV_UBRM24_MON_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_OV_UBRM24_MON"
    VAL_BLK
    0x80803540
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_OV_VDD5_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_OV_VDD5"
    VAL_BLK
    0x80803542
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_OV_VDD5_IN_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_OV_VDD5_IN"
    VAL_BLK
    0x80803544
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_OV_VPR6_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_OV_VPR6"
    VAL_BLK
    0x80803546
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_OV_VSS3_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_OV_VSS3"
    VAL_BLK
    0x80803548
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_OV_VSS4_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_OV_VSS4"
    VAL_BLK
    0x8080354A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_Temp1_HTErr_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_Temp1_HTErr"
    VAL_BLK
    0x8080354C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_Temp1_HTWarn_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_Temp1_HTWarn"
    VAL_BLK
    0x8080354E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_Temp2_HTErr_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_Temp2_HTErr"
    VAL_BLK
    0x80803550
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_Temp2_HTWarn_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_Temp2_HTWarn"
    VAL_BLK
    0x80803552
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3"
    VAL_BLK
    0x80803554
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2"
    VAL_BLK
    0x80803556
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_UV_VDD5_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_UV_VDD5"
    VAL_BLK
    0x80803558
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_UV_VDD5_IN_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_UV_VDD5_IN"
    VAL_BLK
    0x8080355A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_UV_VPR6_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_UV_VPR6"
    VAL_BLK
    0x8080355C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_UV_VSS3_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_UV_VSS3"
    VAL_BLK
    0x8080355E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_UV_VSS4_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_UV_VSS4"
    VAL_BLK
    0x80803560
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA01OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA01OL"
    VAL_BLK
    0x80803562
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA01OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA01OT"
    VAL_BLK
    0x80803564
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA01SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA01SCB"
    VAL_BLK
    0x80803566
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA01SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA01SCG"
    VAL_BLK
    0x80803568
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA02OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA02OL"
    VAL_BLK
    0x8080356A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA02OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA02OR"
    VAL_BLK
    0x8080356C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA02OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA02OT"
    VAL_BLK
    0x8080356E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA02SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA02SCB"
    VAL_BLK
    0x80803570
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA02SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA02SCG"
    VAL_BLK
    0x80803572
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA03OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA03OL"
    VAL_BLK
    0x80803574
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA03OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA03OT"
    VAL_BLK
    0x80803576
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA03SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA03SCB"
    VAL_BLK
    0x80803578
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA03SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA03SCG"
    VAL_BLK
    0x8080357A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA04OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA04OL"
    VAL_BLK
    0x8080357C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA04OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA04OT"
    VAL_BLK
    0x8080357E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA04SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA04SCB"
    VAL_BLK
    0x80803580
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA04SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA04SCG"
    VAL_BLK
    0x80803582
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA05OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA05OL"
    VAL_BLK
    0x80803584
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA05OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA05OR"
    VAL_BLK
    0x80803586
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA05OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA05OT"
    VAL_BLK
    0x80803588
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA05SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA05SCB"
    VAL_BLK
    0x8080358A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA05SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA05SCG"
    VAL_BLK
    0x8080358C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA06OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA06OL"
    VAL_BLK
    0x8080358E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA06OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA06OR"
    VAL_BLK
    0x80803590
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA06OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA06OT"
    VAL_BLK
    0x80803592
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA06SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA06SCB"
    VAL_BLK
    0x80803594
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA06SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA06SCG"
    VAL_BLK
    0x80803596
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA07OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA07OL"
    VAL_BLK
    0x80803598
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA07OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA07OT"
    VAL_BLK
    0x8080359A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA07SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA07SCB"
    VAL_BLK
    0x8080359C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA07SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA07SCG"
    VAL_BLK
    0x8080359E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA08OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA08OL"
    VAL_BLK
    0x808035A0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA08OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA08OT"
    VAL_BLK
    0x808035A2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA08SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA08SCB"
    VAL_BLK
    0x808035A4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA08SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA08SCG"
    VAL_BLK
    0x808035A6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA09OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA09OL"
    VAL_BLK
    0x808035A8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA09OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA09OR"
    VAL_BLK
    0x808035AA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA09OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA09OT"
    VAL_BLK
    0x808035AC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA09SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA09SCB"
    VAL_BLK
    0x808035AE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA09SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA09SCG"
    VAL_BLK
    0x808035B0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA10OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA10OL"
    VAL_BLK
    0x808035B2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA10OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA10OT"
    VAL_BLK
    0x808035B4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA10SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA10SCB"
    VAL_BLK
    0x808035B6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA10SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA10SCG"
    VAL_BLK
    0x808035B8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA11OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA11OL"
    VAL_BLK
    0x808035BA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA11OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA11OT"
    VAL_BLK
    0x808035BC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA11SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA11SCB"
    VAL_BLK
    0x808035BE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA11SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA11SCG"
    VAL_BLK
    0x808035C0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA12OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA12OR"
    VAL_BLK
    0x808035C2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA12SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA12SCB"
    VAL_BLK
    0x808035C4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA12SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA12SCG"
    VAL_BLK
    0x808035C6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA16OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA16OL"
    VAL_BLK
    0x808035C8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA16OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA16OT"
    VAL_BLK
    0x808035CA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA16SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA16SCB"
    VAL_BLK
    0x808035CC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA16SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA16SCG"
    VAL_BLK
    0x808035CE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA17OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA17OL"
    VAL_BLK
    0x808035D0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA17OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA17OR"
    VAL_BLK
    0x808035D2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA17OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA17OT"
    VAL_BLK
    0x808035D4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA17SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA17SCB"
    VAL_BLK
    0x808035D6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA17SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA17SCG"
    VAL_BLK
    0x808035D8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA18OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA18OL"
    VAL_BLK
    0x808035DA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA18OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA18OT"
    VAL_BLK
    0x808035DC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA18SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA18SCB"
    VAL_BLK
    0x808035DE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA18SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA18SCG"
    VAL_BLK
    0x808035E0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA19OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA19OL"
    VAL_BLK
    0x808035E2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA19OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA19OR"
    VAL_BLK
    0x808035E4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA19OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA19OT"
    VAL_BLK
    0x808035E6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA19SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA19SCB"
    VAL_BLK
    0x808035E8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA19SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA19SCG"
    VAL_BLK
    0x808035EA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA20OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA20OL"
    VAL_BLK
    0x808035EC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA20OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA20OR"
    VAL_BLK
    0x808035EE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA20OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA20OT"
    VAL_BLK
    0x808035F0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA20SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA20SCB"
    VAL_BLK
    0x808035F2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA20SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA20SCG"
    VAL_BLK
    0x808035F4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA31OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA31OL"
    VAL_BLK
    0x808035F6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA31OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA31OR"
    VAL_BLK
    0x808035F8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA31OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA31OT"
    VAL_BLK
    0x808035FA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA31SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA31SCB"
    VAL_BLK
    0x808035FC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA31SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA31SCG"
    VAL_BLK
    0x808035FE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA32OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA32OL"
    VAL_BLK
    0x80803600
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA32OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA32OR"
    VAL_BLK
    0x80803602
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA32OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA32OT"
    VAL_BLK
    0x80803604
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA32SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA32SCB"
    VAL_BLK
    0x80803606
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA32SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA32SCG"
    VAL_BLK
    0x80803608
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA33OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA33OL"
    VAL_BLK
    0x8080360A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA33OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA33OR"
    VAL_BLK
    0x8080360C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA33OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA33OT"
    VAL_BLK
    0x8080360E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA33SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA33SCB"
    VAL_BLK
    0x80803610
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA33SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA33SCG"
    VAL_BLK
    0x80803612
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA34OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA34OL"
    VAL_BLK
    0x80803614
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA34OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA34OR"
    VAL_BLK
    0x80803616
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA34OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA34OT"
    VAL_BLK
    0x80803618
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA34SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA34SCB"
    VAL_BLK
    0x8080361A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA34SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA34SCG"
    VAL_BLK
    0x8080361C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA35OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA35OL"
    VAL_BLK
    0x8080361E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA35OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA35OR"
    VAL_BLK
    0x80803620
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA35OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA35OT"
    VAL_BLK
    0x80803622
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA35SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA35SCB"
    VAL_BLK
    0x80803624
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA35SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA35SCG"
    VAL_BLK
    0x80803626
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA46OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA46OL"
    VAL_BLK
    0x80803628
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA46OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA46OR"
    VAL_BLK
    0x8080362A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA46OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA46OT"
    VAL_BLK
    0x8080362C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA46SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA46SCB"
    VAL_BLK
    0x8080362E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA46SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA46SCG"
    VAL_BLK
    0x80803630
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA47OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA47OL"
    VAL_BLK
    0x80803632
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA47OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA47OR"
    VAL_BLK
    0x80803634
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA47OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA47OT"
    VAL_BLK
    0x80803636
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA47SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA47SCB"
    VAL_BLK
    0x80803638
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA47SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA47SCG"
    VAL_BLK
    0x8080363A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA48OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA48OL"
    VAL_BLK
    0x8080363C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA48OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA48OR"
    VAL_BLK
    0x8080363E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA48OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA48OT"
    VAL_BLK
    0x80803640
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA48SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA48SCB"
    VAL_BLK
    0x80803642
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA48SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA48SCG"
    VAL_BLK
    0x80803644
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA49OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA49OL"
    VAL_BLK
    0x80803646
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA49OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA49OT"
    VAL_BLK
    0x80803648
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA49SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA49SCB"
    VAL_BLK
    0x8080364A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA49SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA49SCG"
    VAL_BLK
    0x8080364C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA50OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA50OL"
    VAL_BLK
    0x8080364E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA50OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA50OT"
    VAL_BLK
    0x80803650
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA50SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA50SCB"
    VAL_BLK
    0x80803652
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA50SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA50SCG"
    VAL_BLK
    0x80803654
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA51OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA51OL"
    VAL_BLK
    0x80803656
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA51OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA51OR"
    VAL_BLK
    0x80803658
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA51OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA51OT"
    VAL_BLK
    0x8080365A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA51SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA51SCB"
    VAL_BLK
    0x8080365C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA51SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA51SCG"
    VAL_BLK
    0x8080365E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA52OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA52OL"
    VAL_BLK
    0x80803660
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA52OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA52OR"
    VAL_BLK
    0x80803662
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA52OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA52OT"
    VAL_BLK
    0x80803664
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA52SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA52SCB"
    VAL_BLK
    0x80803666
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA52SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA52SCG"
    VAL_BLK
    0x80803668
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA53OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA53OL"
    VAL_BLK
    0x8080366A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA53OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA53OR"
    VAL_BLK
    0x8080366C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA53OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA53OT"
    VAL_BLK
    0x8080366E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA53SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA53SCB"
    VAL_BLK
    0x80803670
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA53SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA53SCG"
    VAL_BLK
    0x80803672
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA54OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA54OL"
    VAL_BLK
    0x80803674
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA54OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA54OR"
    VAL_BLK
    0x80803676
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA54OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA54OT"
    VAL_BLK
    0x80803678
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA54SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA54SCB"
    VAL_BLK
    0x8080367A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA54SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA54SCG"
    VAL_BLK
    0x8080367C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA55OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA55OL"
    VAL_BLK
    0x8080367E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA55OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA55OT"
    VAL_BLK
    0x80803680
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA55SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA55SCB"
    VAL_BLK
    0x80803682
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA55SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA55SCG"
    VAL_BLK
    0x80803684
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA56OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA56OL"
    VAL_BLK
    0x80803686
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA56OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA56OT"
    VAL_BLK
    0x80803688
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA56SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA56SCB"
    VAL_BLK
    0x8080368A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA56SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA56SCG"
    VAL_BLK
    0x8080368C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA58OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA58OL"
    VAL_BLK
    0x8080368E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA58OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA58OT"
    VAL_BLK
    0x80803690
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA58SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA58SCB"
    VAL_BLK
    0x80803692
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA58SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA58SCG"
    VAL_BLK
    0x80803694
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK07OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK07OL"
    VAL_BLK
    0x80803696
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK07OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK07OR"
    VAL_BLK
    0x80803698
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK07OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK07OT"
    VAL_BLK
    0x8080369A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK07SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK07SCB"
    VAL_BLK
    0x8080369C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK07SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK07SCG"
    VAL_BLK
    0x8080369E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK08OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK08OL"
    VAL_BLK
    0x808036A0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK08OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK08OR"
    VAL_BLK
    0x808036A2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK08OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK08OT"
    VAL_BLK
    0x808036A4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK08SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK08SCB"
    VAL_BLK
    0x808036A6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK08SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK08SCG"
    VAL_BLK
    0x808036A8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK09OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK09OL"
    VAL_BLK
    0x808036AA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK09OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK09OR"
    VAL_BLK
    0x808036AC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK09OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK09OT"
    VAL_BLK
    0x808036AE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK09SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK09SCB"
    VAL_BLK
    0x808036B0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK09SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK09SCG"
    VAL_BLK
    0x808036B2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK12OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK12OL"
    VAL_BLK
    0x808036B4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK12OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK12OT"
    VAL_BLK
    0x808036B6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK12SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK12SCB"
    VAL_BLK
    0x808036B8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK12SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK12SCG"
    VAL_BLK
    0x808036BA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK13OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK13OL"
    VAL_BLK
    0x808036BC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK13OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK13OT"
    VAL_BLK
    0x808036BE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK13SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK13SCB"
    VAL_BLK
    0x808036C0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK13SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK13SCG"
    VAL_BLK
    0x808036C2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK14OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK14OL"
    VAL_BLK
    0x808036C4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK14OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK14OR"
    VAL_BLK
    0x808036C6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK14OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK14OT"
    VAL_BLK
    0x808036C8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK14SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK14SCB"
    VAL_BLK
    0x808036CA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK14SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK14SCG"
    VAL_BLK
    0x808036CC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK15OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK15OL"
    VAL_BLK
    0x808036CE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK15OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK15OR"
    VAL_BLK
    0x808036D0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK15OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK15OT"
    VAL_BLK
    0x808036D2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK15SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK15SCB"
    VAL_BLK
    0x808036D4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK15SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK15SCG"
    VAL_BLK
    0x808036D6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK16OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK16OL"
    VAL_BLK
    0x808036D8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK16OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK16OR"
    VAL_BLK
    0x808036DA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK16OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK16OT"
    VAL_BLK
    0x808036DC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK16SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK16SCB"
    VAL_BLK
    0x808036DE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK16SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK16SCG"
    VAL_BLK
    0x808036E0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK17OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK17OL"
    VAL_BLK
    0x808036E2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK17OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK17OR"
    VAL_BLK
    0x808036E4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK17OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK17OT"
    VAL_BLK
    0x808036E6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK17SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK17SCB"
    VAL_BLK
    0x808036E8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK17SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK17SCG"
    VAL_BLK
    0x808036EA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK25OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK25OR"
    VAL_BLK
    0x808036EC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK25SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK25SCB"
    VAL_BLK
    0x808036EE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK25SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK25SCG"
    VAL_BLK
    0x808036F0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK29OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK29OL"
    VAL_BLK
    0x808036F2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK29OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK29OR"
    VAL_BLK
    0x808036F4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK29OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK29OT"
    VAL_BLK
    0x808036F6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK29SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK29SCB"
    VAL_BLK
    0x808036F8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK29SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK29SCG"
    VAL_BLK
    0x808036FA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK51OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK51OL"
    VAL_BLK
    0x808036FC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK51OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK51OT"
    VAL_BLK
    0x808036FE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK51SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK51SCB"
    VAL_BLK
    0x80803700
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK51SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK51SCG"
    VAL_BLK
    0x80803702
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK62OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK62OR"
    VAL_BLK
    0x80803704
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK62SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK62SCB"
    VAL_BLK
    0x80803706
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK62SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK62SCG"
    VAL_BLK
    0x80803708
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK73OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK73OL"
    VAL_BLK
    0x8080370A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK73OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK73OR"
    VAL_BLK
    0x8080370C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK73OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK73OT"
    VAL_BLK
    0x8080370E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK73SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK73SCB"
    VAL_BLK
    0x80803710
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK73SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK73SCG"
    VAL_BLK
    0x80803712
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK80OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK80OL"
    VAL_BLK
    0x80803714
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK80OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK80OT"
    VAL_BLK
    0x80803716
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK80SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK80SCB"
    VAL_BLK
    0x80803718
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK80SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK80SCG"
    VAL_BLK
    0x8080371A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK81OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK81OL"
    VAL_BLK
    0x8080371C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK81OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK81OT"
    VAL_BLK
    0x8080371E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK81SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK81SCB"
    VAL_BLK
    0x80803720
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK81SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK81SCG"
    VAL_BLK
    0x80803722
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK82OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK82OL"
    VAL_BLK
    0x80803724
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK82OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK82OT"
    VAL_BLK
    0x80803726
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK82SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK82SCB"
    VAL_BLK
    0x80803728
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK82SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK82SCG"
    VAL_BLK
    0x8080372A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK83OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK83OL"
    VAL_BLK
    0x8080372C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK83OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK83OT"
    VAL_BLK
    0x8080372E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK83SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK83SCB"
    VAL_BLK
    0x80803730
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK83SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK83SCG"
    VAL_BLK
    0x80803732
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK84OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK84OL"
    VAL_BLK
    0x80803734
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK84OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK84OT"
    VAL_BLK
    0x80803736
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK84SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK84SCB"
    VAL_BLK
    0x80803738
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK84SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK84SCG"
    VAL_BLK
    0x8080373A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK85OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK85OL"
    VAL_BLK
    0x8080373C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK85OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK85OT"
    VAL_BLK
    0x8080373E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK85SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK85SCB"
    VAL_BLK
    0x80803740
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK85SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK85SCG"
    VAL_BLK
    0x80803742
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK86OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK86OL"
    VAL_BLK
    0x80803744
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK86OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK86OT"
    VAL_BLK
    0x80803746
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK86SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK86SCB"
    VAL_BLK
    0x80803748
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK86SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK86SCG"
    VAL_BLK
    0x8080374A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK87OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK87OL"
    VAL_BLK
    0x8080374C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK87OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK87OT"
    VAL_BLK
    0x8080374E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK87SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK87SCB"
    VAL_BLK
    0x80803750
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK87SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK87SCG"
    VAL_BLK
    0x80803752
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_EventUpDownDebFault_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_EventUpDownDebFault"
    VAL_BLK
    0x80803754
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_DSMDummy_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_DSMDummy"
    VAL_BLK
    0x80803756
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canGetDataNoBuf_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canGetDataNoBuf"
    VAL_BLK
    0x80803758
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canGetDataParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canGetDataParam"
    VAL_BLK
    0x8080375A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canGetDataboxNoInit_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canGetDataboxNoInit"
    VAL_BLK
    0x8080375C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canGetDataboxParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canGetDataboxParam"
    VAL_BLK
    0x8080375E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canGetRxBufStatusParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canGetRxBufStatusParam"
    VAL_BLK
    0x80803760
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canGetStatusParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canGetStatusParam"
    VAL_BLK
    0x80803762
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canGetTxBufStatusParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canGetTxBufStatusParam"
    VAL_BLK
    0x80803764
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canInitParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canInitParam"
    VAL_BLK
    0x80803766
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canInitRxDataboxOverlap_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canInitRxDataboxOverlap"
    VAL_BLK
    0x80803768
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canInitRxDataboxParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canInitRxDataboxParam"
    VAL_BLK
    0x8080376A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canInitTxDataboxParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canInitTxDataboxParam"
    VAL_BLK
    0x8080376C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canIpduGroupControl_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canIpduGroupControl"
    VAL_BLK
    0x8080376E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canIsDataboxFreeNoInit_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canIsDataboxFreeNoInit"
    VAL_BLK
    0x80803770
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canIsDataboxFreeParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canIsDataboxFreeParam"
    VAL_BLK
    0x80803772
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canIsTxEmptyParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canIsTxEmptyParam"
    VAL_BLK
    0x80803774
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canRegBusOffCallbInvState_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canRegBusOffCallbInvState"
    VAL_BLK
    0x80803776
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canRegBusOffCallbParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canRegBusOffCallbParam"
    VAL_BLK
    0x80803778
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canRegRxBufInvState_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canRegRxBufInvState"
    VAL_BLK
    0x8080377A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canRegRxBufOverlap_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canRegRxBufOverlap"
    VAL_BLK
    0x8080377C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canRegRxBufParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canRegRxBufParam"
    VAL_BLK
    0x8080377E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canRegRxCallbInvState_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canRegRxCallbInvState"
    VAL_BLK
    0x80803780
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canRegRxCallbParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canRegRxCallbParam"
    VAL_BLK
    0x80803782
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canRegRxDataboxInvNumb_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canRegRxDataboxInvNumb"
    VAL_BLK
    0x80803784
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canRegRxDataboxInvState_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canRegRxDataboxInvState"
    VAL_BLK
    0x80803786
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canRegRxDataboxOverlap_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canRegRxDataboxOverlap"
    VAL_BLK
    0x80803788
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canRegRxDataboxParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canRegRxDataboxParam"
    VAL_BLK
    0x8080378A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canRegTxBufInvState_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canRegTxBufInvState"
    VAL_BLK
    0x8080378C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canRegTxBufOverlap_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canRegTxBufOverlap"
    VAL_BLK
    0x8080378E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canRegTxBufParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canRegTxBufParam"
    VAL_BLK
    0x80803790
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canRegTxDataboxInvNumb_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canRegTxDataboxInvNumb"
    VAL_BLK
    0x80803792
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canRegTxDataboxInvState_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canRegTxDataboxInvState"
    VAL_BLK
    0x80803794
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canRegTxDataboxOverlap_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canRegTxDataboxOverlap"
    VAL_BLK
    0x80803796
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canRegTxDataboxParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canRegTxDataboxParam"
    VAL_BLK
    0x80803798
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canResetTxBufParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canResetTxBufParam"
    VAL_BLK
    0x8080379A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canSendDataBufOvfl_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canSendDataBufOvfl"
    VAL_BLK
    0x8080379C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canSendDataParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canSendDataParam"
    VAL_BLK
    0x8080379E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canSendDataboxNoInit_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canSendDataboxNoInit"
    VAL_BLK
    0x808037A0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canSendDataboxParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canSendDataboxParam"
    VAL_BLK
    0x808037A2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canSetTxCycleParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canSetTxCycleParam"
    VAL_BLK
    0x808037A4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canStartParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canStartParam"
    VAL_BLK
    0x808037A6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canStopParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canStopParam"
    VAL_BLK
    0x808037A8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_can_ClearIpduGroup_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_can_ClearIpduGroup"
    VAL_BLK
    0x808037AA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_can_ReceiveSignal_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_can_ReceiveSignal"
    VAL_BLK
    0x808037AC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_can_SendSignal_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_can_SendSignal"
    VAL_BLK
    0x808037AE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_can_SetIpduGroup_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_can_SetIpduGroup"
    VAL_BLK
    0x808037B0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_dsmDTCJ1939_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_dsmDTCJ1939"
    VAL_BLK
    0x808037B2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_dsmDelDTCJ1939_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_dsmDelDTCJ1939"
    VAL_BLK
    0x808037B4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_dsmDelErrors_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_dsmDelErrors"
    VAL_BLK
    0x808037B6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_dsmGetDFES_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_dsmGetDFES"
    VAL_BLK
    0x808037B8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_dsmGetDTCJ1939_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_dsmGetDTCJ1939"
    VAL_BLK
    0x808037BA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_dsmGetErrors_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_dsmGetErrors"
    VAL_BLK
    0x808037BC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_dsmGetNumErrors_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_dsmGetNumErrors"
    VAL_BLK
    0x808037BE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_dsmInitQueueOverflow_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_dsmInitQueueOverflow"
    VAL_BLK
    0x808037C0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_dsmNumDTCJ1939_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_dsmNumDTCJ1939"
    VAL_BLK
    0x808037C2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_dsmTesterror_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_dsmTesterror"
    VAL_BLK
    0x808037C4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_dsmUpdateDebError_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_dsmUpdateDebError"
    VAL_BLK
    0x808037C6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_dsmUpdateError_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_dsmUpdateError"
    VAL_BLK
    0x808037C8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_dsmgetDFCStatus_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_dsmgetDFCStatus"
    VAL_BLK
    0x808037CA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_dsmtestErrorDFC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_dsmtestErrorDFC"
    VAL_BLK
    0x808037CC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inAi_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inAi"
    VAL_BLK
    0x808037CE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inAic_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inAic"
    VAL_BLK
    0x808037D0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inAicCfg_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inAicCfg"
    VAL_BLK
    0x808037D2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inAicGetStatus_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inAicGetStatus"
    VAL_BLK
    0x808037D4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inAid_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inAid"
    VAL_BLK
    0x808037D6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inAidCfg_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inAidCfg"
    VAL_BLK
    0x808037D8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inAiv_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inAiv"
    VAL_BLK
    0x808037DA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inAivCfg_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inAivCfg"
    VAL_BLK
    0x808037DC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inAivGetStatus_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inAivGetStatus"
    VAL_BLK
    0x808037DE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inDi_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inDi"
    VAL_BLK
    0x808037E0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inFi_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inFi"
    VAL_BLK
    0x808037E2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inFiCfg_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inFiCfg"
    VAL_BLK
    0x808037E4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inFiGetStatus_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inFiGetStatus"
    VAL_BLK
    0x808037E6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inFi_Buffered_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inFi_Buffered"
    VAL_BLK
    0x808037E8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inPhase_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inPhase"
    VAL_BLK
    0x808037EA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inPhaseGetStatus_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inPhaseGetStatus"
    VAL_BLK
    0x808037EC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inPhaseResetCounter_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inPhaseResetCounter"
    VAL_BLK
    0x808037EE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inRi_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inRi"
    VAL_BLK
    0x808037F0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inRiCfg_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inRiCfg"
    VAL_BLK
    0x808037F2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inRiCfgTemp_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inRiCfgTemp"
    VAL_BLK
    0x808037F4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inRiGetStatus_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inRiGetStatus"
    VAL_BLK
    0x808037F6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inRiGetTemp_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inRiGetTemp"
    VAL_BLK
    0x808037F8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inSentCopyFDFifo_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inSentCopyFDFifo"
    VAL_BLK
    0x808037FA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inSentDisable_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inSentDisable"
    VAL_BLK
    0x808037FC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inSentEnable_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inSentEnable"
    VAL_BLK
    0x808037FE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inSentGetErrorStatus_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inSentGetErrorStatus"
    VAL_BLK
    0x80803800
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inSentGetFD_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inSentGetFD"
    VAL_BLK
    0x80803802
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inSentGetSD_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inSentGetSD"
    VAL_BLK
    0x80803804
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inSentGetSDDatabox_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inSentGetSDDatabox"
    VAL_BLK
    0x80803806
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inSentGetStatus_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inSentGetStatus"
    VAL_BLK
    0x80803808
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inSentInitSDDatabox_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inSentInitSDDatabox"
    VAL_BLK
    0x8080380A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inSentRegisterCopyFDFifo_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inSentRegisterCopyFDFifo"
    VAL_BLK
    0x8080380C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inSentRegisterFDFifo_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inSentRegisterFDFifo"
    VAL_BLK
    0x8080380E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inSentRegisterSDDataboxes_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inSentRegisterSDDataboxes"
    VAL_BLK
    0x80803810
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_isobusCanRxBufferOverflow_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_isobusCanRxBufferOverflow"
    VAL_BLK
    0x80803812
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_isobusGetCaAddrParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_isobusGetCaAddrParam"
    VAL_BLK
    0x80803814
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_isobusGetDiagnosticParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_isobusGetDiagnosticParam"
    VAL_BLK
    0x80803816
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_isobusGetRxDataboxStatusParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_isobusGetRxDataboxStatusParam"
    VAL_BLK
    0x80803818
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_isobusGetStatusParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_isobusGetStatusParam"
    VAL_BLK
    0x8080381A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_isobusInitCommCaMissing_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_isobusInitCommCaMissing"
    VAL_BLK
    0x8080381C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_isobusInitCommParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_isobusInitCommParam"
    VAL_BLK
    0x8080381E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_isobusInitCommState_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_isobusInitCommState"
    VAL_BLK
    0x80803820
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_isobusInitDiagnosticParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_isobusInitDiagnosticParam"
    VAL_BLK
    0x80803822
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_isobusInitFailureListParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_isobusInitFailureListParam"
    VAL_BLK
    0x80803824
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_isobusInitRxDataboxParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_isobusInitRxDataboxParam"
    VAL_BLK
    0x80803826
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_isobusInitTxDataboxParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_isobusInitTxDataboxParam"
    VAL_BLK
    0x80803828
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_isobusRegRxDataboxOverlap_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_isobusRegRxDataboxOverlap"
    VAL_BLK
    0x8080382A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_isobusRegRxDataboxParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_isobusRegRxDataboxParam"
    VAL_BLK
    0x8080382C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_isobusRegRxDataboxState_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_isobusRegRxDataboxState"
    VAL_BLK
    0x8080382E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_isobusRegTxDataboxOverlap_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_isobusRegTxDataboxOverlap"
    VAL_BLK
    0x80803830
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_isobusRegTxDataboxParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_isobusRegTxDataboxParam"
    VAL_BLK
    0x80803832
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_isobusRegTxDataboxState_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_isobusRegTxDataboxState"
    VAL_BLK
    0x80803834
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_isobusRegisterErrClrCallbackParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_isobusRegisterErrClrCallbackParam"
    VAL_BLK
    0x80803836
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_isobusRegisterInstancesOverlap_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_isobusRegisterInstancesOverlap"
    VAL_BLK
    0x80803838
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_isobusRegisterInstancesParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_isobusRegisterInstancesParam"
    VAL_BLK
    0x8080383A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_isobusRegisterInstancesState_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_isobusRegisterInstancesState"
    VAL_BLK
    0x8080383C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_isobusSendDataboxParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_isobusSendDataboxParam"
    VAL_BLK
    0x8080383E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_isobusSendRequestPGNParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_isobusSendRequestPGNParam"
    VAL_BLK
    0x80803840
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_isobusSetCaAddrCaUsed_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_isobusSetCaAddrCaUsed"
    VAL_BLK
    0x80803842
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_isobusSetCaAddrComm_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_isobusSetCaAddrComm"
    VAL_BLK
    0x80803844
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_isobusSetCaAddrInvCan_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_isobusSetCaAddrInvCan"
    VAL_BLK
    0x80803846
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_isobusSetCaAddrParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_isobusSetCaAddrParam"
    VAL_BLK
    0x80803848
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_isobusSetCaInfoParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_isobusSetCaInfoParam"
    VAL_BLK
    0x8080384A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_isobusSetCaNameParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_isobusSetCaNameParam"
    VAL_BLK
    0x8080384C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_isobusSftyCanTxErr_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_isobusSftyCanTxErr"
    VAL_BLK
    0x8080384E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_lin_ReceiveSignal_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_lin_ReceiveSignal"
    VAL_BLK
    0x80803850
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_lin_SendSignal_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_lin_SendSignal"
    VAL_BLK
    0x80803852
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_lin_getStatus_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_lin_getStatus"
    VAL_BLK
    0x80803854
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_lin_gotoSleep_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_lin_gotoSleep"
    VAL_BLK
    0x80803856
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_lin_scheduleRequest_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_lin_scheduleRequest"
    VAL_BLK
    0x80803858
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_lin_wakeUp_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_lin_wakeUp"
    VAL_BLK
    0x8080385A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_memFlsCfgShr_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_memFlsCfgShr"
    VAL_BLK
    0x8080385C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_memGetStatus_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_memGetStatus"
    VAL_BLK
    0x8080385E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_memMarkBlock_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_memMarkBlock"
    VAL_BLK
    0x80803860
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_memReadApi1Error_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_memReadApi1Error"
    VAL_BLK
    0x80803862
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_memReadApi2Error_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_memReadApi2Error"
    VAL_BLK
    0x80803864
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_memReadBlock_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_memReadBlock"
    VAL_BLK
    0x80803866
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_memReadCalibInputError_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_memReadCalibInputError"
    VAL_BLK
    0x80803868
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_memReadCalibOuputError_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_memReadCalibOuputError"
    VAL_BLK
    0x8080386A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_memReadSystemError_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_memReadSystemError"
    VAL_BLK
    0x8080386C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_memWriteBlock_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_memWriteBlock"
    VAL_BLK
    0x8080386E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_moOV_FirstConstADC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_moOV_FirstConstADC"
    VAL_BLK
    0x80803870
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_moOV_SecondConstADC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_moOV_SecondConstADC"
    VAL_BLK
    0x80803872
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_moUV_FirstConstADC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_moUV_FirstConstADC"
    VAL_BLK
    0x80803874
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_moUV_SecondConstADC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_moUV_SecondConstADC"
    VAL_BLK
    0x80803876
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_INH_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_INH"
    VAL_BLK
    0x80803878
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_INHLatch_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_INHLatch"
    VAL_BLK
    0x8080387A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_adcPDD_fail_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_adcPDD_fail"
    VAL_BLK
    0x8080387C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_memoryProtection_err_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_memoryProtection_err"
    VAL_BLK
    0x8080387E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA02OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA02OC"
    VAL_BLK
    0x80803880
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA02Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA02Unintended"
    VAL_BLK
    0x80803882
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA03OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA03OC"
    VAL_BLK
    0x80803884
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA03Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA03Unintended"
    VAL_BLK
    0x80803886
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA04OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA04OC"
    VAL_BLK
    0x80803888
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA04Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA04Unintended"
    VAL_BLK
    0x8080388A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA05OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA05OC"
    VAL_BLK
    0x8080388C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA05Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA05Unintended"
    VAL_BLK
    0x8080388E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA07OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA07OC"
    VAL_BLK
    0x80803890
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA07Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA07Unintended"
    VAL_BLK
    0x80803892
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA08OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA08OC"
    VAL_BLK
    0x80803894
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA08Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA08Unintended"
    VAL_BLK
    0x80803896
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA09OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA09OC"
    VAL_BLK
    0x80803898
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA09Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA09Unintended"
    VAL_BLK
    0x8080389A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA10OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA10OC"
    VAL_BLK
    0x8080389C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA10Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA10Unintended"
    VAL_BLK
    0x8080389E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA17OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA17OC"
    VAL_BLK
    0x808038A0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA17Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA17Unintended"
    VAL_BLK
    0x808038A2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA18OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA18OC"
    VAL_BLK
    0x808038A4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA18Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA18Unintended"
    VAL_BLK
    0x808038A6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA19OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA19OC"
    VAL_BLK
    0x808038A8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA19Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA19Unintended"
    VAL_BLK
    0x808038AA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA20OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA20OC"
    VAL_BLK
    0x808038AC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA20Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA20Unintended"
    VAL_BLK
    0x808038AE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA31OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA31OC"
    VAL_BLK
    0x808038B0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA31Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA31Unintended"
    VAL_BLK
    0x808038B2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA32OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA32OC"
    VAL_BLK
    0x808038B4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA32Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA32Unintended"
    VAL_BLK
    0x808038B6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA33OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA33OC"
    VAL_BLK
    0x808038B8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA33Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA33Unintended"
    VAL_BLK
    0x808038BA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA34OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA34OC"
    VAL_BLK
    0x808038BC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA34Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA34Unintended"
    VAL_BLK
    0x808038BE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA35OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA35OC"
    VAL_BLK
    0x808038C0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA35Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA35Unintended"
    VAL_BLK
    0x808038C2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA46OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA46OC"
    VAL_BLK
    0x808038C4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA46Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA46Unintended"
    VAL_BLK
    0x808038C6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA47OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA47OC"
    VAL_BLK
    0x808038C8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA47Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA47Unintended"
    VAL_BLK
    0x808038CA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA48OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA48OC"
    VAL_BLK
    0x808038CC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA48Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA48Unintended"
    VAL_BLK
    0x808038CE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA51OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA51OC"
    VAL_BLK
    0x808038D0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA51Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA51Unintended"
    VAL_BLK
    0x808038D2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA52OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA52OC"
    VAL_BLK
    0x808038D4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA52Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA52Unintended"
    VAL_BLK
    0x808038D6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA53OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA53OC"
    VAL_BLK
    0x808038D8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA53Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA53Unintended"
    VAL_BLK
    0x808038DA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA54OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA54OC"
    VAL_BLK
    0x808038DC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA54Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA54Unintended"
    VAL_BLK
    0x808038DE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outAov_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outAov"
    VAL_BLK
    0x808038E0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outAovCfg_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outAovCfg"
    VAL_BLK
    0x808038E2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outAovCfgPI_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outAovCfgPI"
    VAL_BLK
    0x808038E4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outAovGetStatus_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outAovGetStatus"
    VAL_BLK
    0x808038E6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outAovGetVoltage_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outAovGetVoltage"
    VAL_BLK
    0x808038E8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outAovResetError_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outAovResetError"
    VAL_BLK
    0x808038EA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outDo_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outDo"
    VAL_BLK
    0x808038EC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outDoCfgPwrLs_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outDoCfgPwrLs"
    VAL_BLK
    0x808038EE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outDoDisable_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outDoDisable"
    VAL_BLK
    0x808038F0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outDoGetCurrent_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outDoGetCurrent"
    VAL_BLK
    0x808038F2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outDoGetStatus_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outDoGetStatus"
    VAL_BLK
    0x808038F4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outDoResetError_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outDoResetError"
    VAL_BLK
    0x808038F6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK07OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK07OC"
    VAL_BLK
    0x808038F8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK07Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK07Unintended"
    VAL_BLK
    0x808038FA
