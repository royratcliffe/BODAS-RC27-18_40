    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK85SCG"
    VALUE
    0x80805108
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK86OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK86OL"
    VALUE
    0x8080510C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK86OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK86OT"
    VALUE
    0x80805110
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK86SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK86SCB"
    VALUE
    0x80805114
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK86SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK86SCG"
    VALUE
    0x80805118
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK87OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK87OL"
    VALUE
    0x8080511C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK87OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK87OT"
    VALUE
    0x80805120
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK87SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK87SCB"
    VALUE
    0x80805124
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK87SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK87SCG"
    VALUE
    0x80805128
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_EventUpDownDebFault_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_EventUpDownDebFault"
    VALUE
    0x8080512C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_DSMDummy_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_DSMDummy"
    VALUE
    0x80805130
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canGetDataNoBuf_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canGetDataNoBuf"
    VALUE
    0x80805134
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canGetDataParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canGetDataParam"
    VALUE
    0x80805138
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canGetDataboxNoInit_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canGetDataboxNoInit"
    VALUE
    0x8080513C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canGetDataboxParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canGetDataboxParam"
    VALUE
    0x80805140
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canGetRxBufStatusParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canGetRxBufStatusParam"
    VALUE
    0x80805144
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canGetStatusParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canGetStatusParam"
    VALUE
    0x80805148
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canGetTxBufStatusParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canGetTxBufStatusParam"
    VALUE
    0x8080514C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canInitParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canInitParam"
    VALUE
    0x80805150
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canInitRxDataboxOverlap_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canInitRxDataboxOverlap"
    VALUE
    0x80805154
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canInitRxDataboxParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canInitRxDataboxParam"
    VALUE
    0x80805158
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canInitTxDataboxParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canInitTxDataboxParam"
    VALUE
    0x8080515C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canIpduGroupControl_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canIpduGroupControl"
    VALUE
    0x80805160
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canIsDataboxFreeNoInit_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canIsDataboxFreeNoInit"
    VALUE
    0x80805164
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canIsDataboxFreeParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canIsDataboxFreeParam"
    VALUE
    0x80805168
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canIsTxEmptyParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canIsTxEmptyParam"
    VALUE
    0x8080516C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canRegBusOffCallbInvState_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canRegBusOffCallbInvState"
    VALUE
    0x80805170
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canRegBusOffCallbParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canRegBusOffCallbParam"
    VALUE
    0x80805174
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canRegRxBufInvState_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canRegRxBufInvState"
    VALUE
    0x80805178
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canRegRxBufOverlap_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canRegRxBufOverlap"
    VALUE
    0x8080517C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canRegRxBufParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canRegRxBufParam"
    VALUE
    0x80805180
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canRegRxCallbInvState_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canRegRxCallbInvState"
    VALUE
    0x80805184
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canRegRxCallbParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canRegRxCallbParam"
    VALUE
    0x80805188
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canRegRxDataboxInvNumb_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canRegRxDataboxInvNumb"
    VALUE
    0x8080518C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canRegRxDataboxInvState_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canRegRxDataboxInvState"
    VALUE
    0x80805190
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canRegRxDataboxOverlap_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canRegRxDataboxOverlap"
    VALUE
    0x80805194
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canRegRxDataboxParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canRegRxDataboxParam"
    VALUE
    0x80805198
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canRegTxBufInvState_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canRegTxBufInvState"
    VALUE
    0x8080519C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canRegTxBufOverlap_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canRegTxBufOverlap"
    VALUE
    0x808051A0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canRegTxBufParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canRegTxBufParam"
    VALUE
    0x808051A4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canRegTxDataboxInvNumb_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canRegTxDataboxInvNumb"
    VALUE
    0x808051A8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canRegTxDataboxInvState_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canRegTxDataboxInvState"
    VALUE
    0x808051AC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canRegTxDataboxOverlap_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canRegTxDataboxOverlap"
    VALUE
    0x808051B0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canRegTxDataboxParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canRegTxDataboxParam"
    VALUE
    0x808051B4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canResetTxBufParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canResetTxBufParam"
    VALUE
    0x808051B8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canSendDataBufOvfl_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canSendDataBufOvfl"
    VALUE
    0x808051BC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canSendDataParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canSendDataParam"
    VALUE
    0x808051C0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canSendDataboxNoInit_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canSendDataboxNoInit"
    VALUE
    0x808051C4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canSendDataboxParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canSendDataboxParam"
    VALUE
    0x808051C8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canSetTxCycleParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canSetTxCycleParam"
    VALUE
    0x808051CC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canStartParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canStartParam"
    VALUE
    0x808051D0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canStopParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canStopParam"
    VALUE
    0x808051D4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_can_ClearIpduGroup_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_can_ClearIpduGroup"
    VALUE
    0x808051D8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_can_ReceiveSignal_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_can_ReceiveSignal"
    VALUE
    0x808051DC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_can_SendSignal_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_can_SendSignal"
    VALUE
    0x808051E0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_can_SetIpduGroup_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_can_SetIpduGroup"
    VALUE
    0x808051E4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_dsmDTCJ1939_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_dsmDTCJ1939"
    VALUE
    0x808051E8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_dsmDelDTCJ1939_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_dsmDelDTCJ1939"
    VALUE
    0x808051EC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_dsmDelErrors_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_dsmDelErrors"
    VALUE
    0x808051F0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_dsmGetDFES_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_dsmGetDFES"
    VALUE
    0x808051F4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_dsmGetDTCJ1939_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_dsmGetDTCJ1939"
    VALUE
    0x808051F8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_dsmGetErrors_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_dsmGetErrors"
    VALUE
    0x808051FC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_dsmGetNumErrors_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_dsmGetNumErrors"
    VALUE
    0x80805200
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_dsmInitQueueOverflow_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_dsmInitQueueOverflow"
    VALUE
    0x80805204
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_dsmNumDTCJ1939_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_dsmNumDTCJ1939"
    VALUE
    0x80805208
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_dsmTesterror_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_dsmTesterror"
    VALUE
    0x8080520C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_dsmUpdateDebError_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_dsmUpdateDebError"
    VALUE
    0x80805210
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_dsmUpdateError_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_dsmUpdateError"
    VALUE
    0x80805214
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_dsmgetDFCStatus_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_dsmgetDFCStatus"
    VALUE
    0x80805218
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_dsmtestErrorDFC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_dsmtestErrorDFC"
    VALUE
    0x8080521C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inAi_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inAi"
    VALUE
    0x80805220
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inAic_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inAic"
    VALUE
    0x80805224
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inAicCfg_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inAicCfg"
    VALUE
    0x80805228
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inAicGetStatus_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inAicGetStatus"
    VALUE
    0x8080522C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inAid_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inAid"
    VALUE
    0x80805230
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inAidCfg_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inAidCfg"
    VALUE
    0x80805234
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inAiv_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inAiv"
    VALUE
    0x80805238
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inAivCfg_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inAivCfg"
    VALUE
    0x8080523C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inAivGetStatus_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inAivGetStatus"
    VALUE
    0x80805240
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inDi_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inDi"
    VALUE
    0x80805244
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inFi_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inFi"
    VALUE
    0x80805248
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inFiCfg_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inFiCfg"
    VALUE
    0x8080524C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inFiGetStatus_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inFiGetStatus"
    VALUE
    0x80805250
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inFi_Buffered_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inFi_Buffered"
    VALUE
    0x80805254
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inPhase_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inPhase"
    VALUE
    0x80805258
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inPhaseGetStatus_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inPhaseGetStatus"
    VALUE
    0x8080525C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inPhaseResetCounter_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inPhaseResetCounter"
    VALUE
    0x80805260
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inRi_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inRi"
    VALUE
    0x80805264
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inRiCfg_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inRiCfg"
    VALUE
    0x80805268
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inRiCfgTemp_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inRiCfgTemp"
    VALUE
    0x8080526C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inRiGetStatus_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inRiGetStatus"
    VALUE
    0x80805270
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inRiGetTemp_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inRiGetTemp"
    VALUE
    0x80805274
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inSentCopyFDFifo_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inSentCopyFDFifo"
    VALUE
    0x80805278
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inSentDisable_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inSentDisable"
    VALUE
    0x8080527C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inSentEnable_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inSentEnable"
    VALUE
    0x80805280
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inSentGetErrorStatus_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inSentGetErrorStatus"
    VALUE
    0x80805284
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inSentGetFD_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inSentGetFD"
    VALUE
    0x80805288
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inSentGetSD_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inSentGetSD"
    VALUE
    0x8080528C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inSentGetSDDatabox_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inSentGetSDDatabox"
    VALUE
    0x80805290
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inSentGetStatus_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inSentGetStatus"
    VALUE
    0x80805294
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inSentInitSDDatabox_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inSentInitSDDatabox"
    VALUE
    0x80805298
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inSentRegisterCopyFDFifo_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inSentRegisterCopyFDFifo"
    VALUE
    0x8080529C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inSentRegisterFDFifo_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inSentRegisterFDFifo"
    VALUE
    0x808052A0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inSentRegisterSDDataboxes_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inSentRegisterSDDataboxes"
    VALUE
    0x808052A4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_isobusCanRxBufferOverflow_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_isobusCanRxBufferOverflow"
    VALUE
    0x808052A8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_isobusGetCaAddrParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_isobusGetCaAddrParam"
    VALUE
    0x808052AC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_isobusGetDiagnosticParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_isobusGetDiagnosticParam"
    VALUE
    0x808052B0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_isobusGetRxDataboxStatusParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_isobusGetRxDataboxStatusParam"
    VALUE
    0x808052B4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_isobusGetStatusParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_isobusGetStatusParam"
    VALUE
    0x808052B8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_isobusInitCommCaMissing_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_isobusInitCommCaMissing"
    VALUE
    0x808052BC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_isobusInitCommParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_isobusInitCommParam"
    VALUE
    0x808052C0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_isobusInitCommState_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_isobusInitCommState"
    VALUE
    0x808052C4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_isobusInitDiagnosticParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_isobusInitDiagnosticParam"
    VALUE
    0x808052C8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_isobusInitFailureListParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_isobusInitFailureListParam"
    VALUE
    0x808052CC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_isobusInitRxDataboxParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_isobusInitRxDataboxParam"
    VALUE
    0x808052D0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_isobusInitTxDataboxParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_isobusInitTxDataboxParam"
    VALUE
    0x808052D4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_isobusRegRxDataboxOverlap_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_isobusRegRxDataboxOverlap"
    VALUE
    0x808052D8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_isobusRegRxDataboxParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_isobusRegRxDataboxParam"
    VALUE
    0x808052DC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_isobusRegRxDataboxState_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_isobusRegRxDataboxState"
    VALUE
    0x808052E0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_isobusRegTxDataboxOverlap_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_isobusRegTxDataboxOverlap"
    VALUE
    0x808052E4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_isobusRegTxDataboxParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_isobusRegTxDataboxParam"
    VALUE
    0x808052E8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_isobusRegTxDataboxState_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_isobusRegTxDataboxState"
    VALUE
    0x808052EC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_isobusRegisterErrClrCallbackParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_isobusRegisterErrClrCallbackParam"
    VALUE
    0x808052F0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_isobusRegisterInstancesOverlap_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_isobusRegisterInstancesOverlap"
    VALUE
    0x808052F4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_isobusRegisterInstancesParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_isobusRegisterInstancesParam"
    VALUE
    0x808052F8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_isobusRegisterInstancesState_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_isobusRegisterInstancesState"
    VALUE
    0x808052FC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_isobusSendDataboxParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_isobusSendDataboxParam"
    VALUE
    0x80805300
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_isobusSendRequestPGNParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_isobusSendRequestPGNParam"
    VALUE
    0x80805304
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_isobusSetCaAddrCaUsed_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_isobusSetCaAddrCaUsed"
    VALUE
    0x80805308
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_isobusSetCaAddrComm_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_isobusSetCaAddrComm"
    VALUE
    0x8080530C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_isobusSetCaAddrInvCan_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_isobusSetCaAddrInvCan"
    VALUE
    0x80805310
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_isobusSetCaAddrParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_isobusSetCaAddrParam"
    VALUE
    0x80805314
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_isobusSetCaInfoParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_isobusSetCaInfoParam"
    VALUE
    0x80805318
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_isobusSetCaNameParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_isobusSetCaNameParam"
    VALUE
    0x8080531C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_isobusSftyCanTxErr_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_isobusSftyCanTxErr"
    VALUE
    0x80805320
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_lin_ReceiveSignal_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_lin_ReceiveSignal"
    VALUE
    0x80805324
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_lin_SendSignal_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_lin_SendSignal"
    VALUE
    0x80805328
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_lin_getStatus_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_lin_getStatus"
    VALUE
    0x8080532C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_lin_gotoSleep_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_lin_gotoSleep"
    VALUE
    0x80805330
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_lin_scheduleRequest_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_lin_scheduleRequest"
    VALUE
    0x80805334
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_lin_wakeUp_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_lin_wakeUp"
    VALUE
    0x80805338
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_memFlsCfgShr_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_memFlsCfgShr"
    VALUE
    0x8080533C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_memGetStatus_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_memGetStatus"
    VALUE
    0x80805340
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_memMarkBlock_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_memMarkBlock"
    VALUE
    0x80805344
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_memReadApi1Error_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_memReadApi1Error"
    VALUE
    0x80805348
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_memReadApi2Error_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_memReadApi2Error"
    VALUE
    0x8080534C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_memReadBlock_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_memReadBlock"
    VALUE
    0x80805350
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_memReadCalibInputError_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_memReadCalibInputError"
    VALUE
    0x80805354
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_memReadCalibOuputError_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_memReadCalibOuputError"
    VALUE
    0x80805358
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_memReadSystemError_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_memReadSystemError"
    VALUE
    0x8080535C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_memWriteBlock_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_memWriteBlock"
    VALUE
    0x80805360
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_moOV_FirstConstADC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_moOV_FirstConstADC"
    VALUE
    0x80805364
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_moOV_SecondConstADC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_moOV_SecondConstADC"
    VALUE
    0x80805368
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_moUV_FirstConstADC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_moUV_FirstConstADC"
    VALUE
    0x8080536C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_moUV_SecondConstADC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_moUV_SecondConstADC"
    VALUE
    0x80805370
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_INH_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_INH"
    VALUE
    0x80805374
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_INHLatch_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_INHLatch"
    VALUE
    0x80805378
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_adcPDD_fail_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_adcPDD_fail"
    VALUE
    0x8080537C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_memoryProtection_err_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_memoryProtection_err"
    VALUE
    0x80805380
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA02OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA02OC"
    VALUE
    0x80805384
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA02Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA02Unintended"
    VALUE
    0x80805388
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA03OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA03OC"
    VALUE
    0x8080538C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA03Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA03Unintended"
    VALUE
    0x80805390
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA04OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA04OC"
    VALUE
    0x80805394
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA04Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA04Unintended"
    VALUE
    0x80805398
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA05OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA05OC"
    VALUE
    0x8080539C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA05Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA05Unintended"
    VALUE
    0x808053A0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA07OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA07OC"
    VALUE
    0x808053A4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA07Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA07Unintended"
    VALUE
    0x808053A8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA08OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA08OC"
    VALUE
    0x808053AC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA08Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA08Unintended"
    VALUE
    0x808053B0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA09OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA09OC"
    VALUE
    0x808053B4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA09Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA09Unintended"
    VALUE
    0x808053B8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA10OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA10OC"
    VALUE
    0x808053BC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA10Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA10Unintended"
    VALUE
    0x808053C0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA17OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA17OC"
    VALUE
    0x808053C4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA17Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA17Unintended"
    VALUE
    0x808053C8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA18OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA18OC"
    VALUE
    0x808053CC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA18Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA18Unintended"
    VALUE
    0x808053D0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA19OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA19OC"
    VALUE
    0x808053D4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA19Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA19Unintended"
    VALUE
    0x808053D8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA20OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA20OC"
    VALUE
    0x808053DC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA20Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA20Unintended"
    VALUE
    0x808053E0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA31OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA31OC"
    VALUE
    0x808053E4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA31Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA31Unintended"
    VALUE
    0x808053E8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA32OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA32OC"
    VALUE
    0x808053EC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA32Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA32Unintended"
    VALUE
    0x808053F0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA33OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA33OC"
    VALUE
    0x808053F4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA33Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA33Unintended"
    VALUE
    0x808053F8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA34OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA34OC"
    VALUE
    0x808053FC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA34Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA34Unintended"
    VALUE
    0x80805400
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA35OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA35OC"
    VALUE
    0x80805404
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA35Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA35Unintended"
    VALUE
    0x80805408
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA46OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA46OC"
    VALUE
    0x8080540C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA46Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA46Unintended"
    VALUE
    0x80805410
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA47OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA47OC"
    VALUE
    0x80805414
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA47Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA47Unintended"
    VALUE
    0x80805418
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA48OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA48OC"
    VALUE
    0x8080541C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA48Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA48Unintended"
    VALUE
    0x80805420
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA51OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA51OC"
    VALUE
    0x80805424
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA51Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA51Unintended"
    VALUE
    0x80805428
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA52OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA52OC"
    VALUE
    0x8080542C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA52Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA52Unintended"
    VALUE
    0x80805430
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA53OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA53OC"
    VALUE
    0x80805434
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA53Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA53Unintended"
    VALUE
    0x80805438
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA54OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA54OC"
    VALUE
    0x8080543C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA54Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA54Unintended"
    VALUE
    0x80805440
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outAov_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outAov"
    VALUE
    0x80805444
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outAovCfg_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outAovCfg"
    VALUE
    0x80805448
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outAovCfgPI_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outAovCfgPI"
    VALUE
    0x8080544C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outAovGetStatus_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outAovGetStatus"
    VALUE
    0x80805450
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outAovGetVoltage_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outAovGetVoltage"
    VALUE
    0x80805454
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outAovResetError_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outAovResetError"
    VALUE
    0x80805458
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outDo_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outDo"
    VALUE
    0x8080545C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outDoCfgPwrLs_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outDoCfgPwrLs"
    VALUE
    0x80805460
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outDoDisable_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outDoDisable"
    VALUE
    0x80805464
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outDoGetCurrent_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outDoGetCurrent"
    VALUE
    0x80805468
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outDoGetStatus_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outDoGetStatus"
    VALUE
    0x8080546C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outDoResetError_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outDoResetError"
    VALUE
    0x80805470
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK07OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK07OC"
    VALUE
    0x80805474
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK07Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK07Unintended"
    VALUE
    0x80805478
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK08OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK08OC"
    VALUE
    0x8080547C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK08Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK08Unintended"
    VALUE
    0x80805480
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK09OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK09OC"
    VALUE
    0x80805484
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK09Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK09Unintended"
    VALUE
    0x80805488
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK12OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK12OC"
    VALUE
    0x8080548C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK12Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK12Unintended"
    VALUE
    0x80805490
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK13OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK13OC"
    VALUE
    0x80805494
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK13Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK13Unintended"
    VALUE
    0x80805498
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK14OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK14OC"
    VALUE
    0x8080549C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK14Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK14Unintended"
    VALUE
    0x808054A0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK15OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK15OC"
    VALUE
    0x808054A4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK15Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK15Unintended"
    VALUE
    0x808054A8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK16OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK16OC"
    VALUE
    0x808054AC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK16Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK16Unintended"
    VALUE
    0x808054B0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK17OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK17OC"
    VALUE
    0x808054B4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK17Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK17Unintended"
    VALUE
    0x808054B8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK29OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK29OC"
    VALUE
    0x808054BC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK29Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK29Unintended"
    VALUE
    0x808054C0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK51OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK51OC"
    VALUE
    0x808054C4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK51Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK51Unintended"
    VALUE
    0x808054C8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK73OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK73OC"
    VALUE
    0x808054CC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK73Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK73Unintended"
    VALUE
    0x808054D0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outPo_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outPo"
    VALUE
    0x808054D4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outPoCfg_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outPoCfg"
    VALUE
    0x808054D8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outPoCfgPeriod_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outPoCfgPeriod"
    VALUE
    0x808054DC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outPoCfgPwrLs_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outPoCfgPwrLs"
    VALUE
    0x808054E0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outPoDisable_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outPoDisable"
    VALUE
    0x808054E4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outPoGetCurrent_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outPoGetCurrent"
    VALUE
    0x808054E8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outPoGetStatus_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outPoGetStatus"
    VALUE
    0x808054EC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outPoResetError_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outPoResetError"
    VALUE
    0x808054F0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outPoc_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outPoc"
    VALUE
    0x808054F4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outPocCfg_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outPocCfg"
    VALUE
    0x808054F8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outPocCfgDither_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outPocCfgDither"
    VALUE
    0x808054FC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outPocCfgPI_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outPocCfgPI"
    VALUE
    0x80805500
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outPod_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outPod"
    VALUE
    0x80805504
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outPodCfg_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outPodCfg"
    VALUE
    0x80805508
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outPodCfgPeriod_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outPodCfgPeriod"
    VALUE
    0x8080550C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_rsmFfiApiCallErr_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_rsmFfiApiCallErr"
    VALUE
    0x80805510
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safout_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safout"
    VALUE
    0x80805514
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutCfg_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutCfg"
    VALUE
    0x80805518
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl1_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl1"
    VALUE
    0x8080551C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl10_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl10"
    VALUE
    0x80805520
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl10Dev_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl10Dev"
    VALUE
    0x80805524
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl10OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl10OR"
    VALUE
    0x80805528
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl11_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl11"
    VALUE
    0x8080552C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl11Dev_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl11Dev"
    VALUE
    0x80805530
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl11OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl11OR"
    VALUE
    0x80805534
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl12_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl12"
    VALUE
    0x80805538
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl12Dev_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl12Dev"
    VALUE
    0x8080553C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl12OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl12OR"
    VALUE
    0x80805540
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl13_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl13"
    VALUE
    0x80805544
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl13Dev_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl13Dev"
    VALUE
    0x80805548
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl13OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl13OR"
    VALUE
    0x8080554C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl14_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl14"
    VALUE
    0x80805550
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl14Dev_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl14Dev"
    VALUE
    0x80805554
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl14OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl14OR"
    VALUE
    0x80805558
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl15_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl15"
    VALUE
    0x8080555C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl15Dev_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl15Dev"
    VALUE
    0x80805560
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl15OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl15OR"
    VALUE
    0x80805564
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl16_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl16"
    VALUE
    0x80805568
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl16Dev_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl16Dev"
    VALUE
    0x8080556C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl16OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl16OR"
    VALUE
    0x80805570
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl17_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl17"
    VALUE
    0x80805574
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl17Dev_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl17Dev"
    VALUE
    0x80805578
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl17OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl17OR"
    VALUE
    0x8080557C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl18_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl18"
    VALUE
    0x80805580
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl18Dev_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl18Dev"
    VALUE
    0x80805584
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl18OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl18OR"
    VALUE
    0x80805588
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl1Dev_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl1Dev"
    VALUE
    0x8080558C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl1OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl1OR"
    VALUE
    0x80805590
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl2_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl2"
    VALUE
    0x80805594
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl2Dev_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl2Dev"
    VALUE
    0x80805598
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl2OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl2OR"
    VALUE
    0x8080559C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl3_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl3"
    VALUE
    0x808055A0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl3Dev_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl3Dev"
    VALUE
    0x808055A4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl3OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl3OR"
    VALUE
    0x808055A8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl4_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl4"
    VALUE
    0x808055AC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl4Dev_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl4Dev"
    VALUE
    0x808055B0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl4OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl4OR"
    VALUE
    0x808055B4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl5_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl5"
    VALUE
    0x808055B8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl5Dev_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl5Dev"
    VALUE
    0x808055BC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl5OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl5OR"
    VALUE
    0x808055C0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl6_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl6"
    VALUE
    0x808055C4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl6Dev_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl6Dev"
    VALUE
    0x808055C8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl6OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl6OR"
    VALUE
    0x808055CC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl7_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl7"
    VALUE
    0x808055D0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl7Dev_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl7Dev"
    VALUE
    0x808055D4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl7OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl7OR"
    VALUE
    0x808055D8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl8_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl8"
    VALUE
    0x808055DC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl8Dev_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl8Dev"
    VALUE
    0x808055E0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl8OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl8OR"
    VALUE
    0x808055E4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl9_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl9"
    VALUE
    0x808055E8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl9Dev_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl9Dev"
    VALUE
    0x808055EC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl9OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl9OR"
    VALUE
    0x808055F0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutDevError_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutDevError"
    VALUE
    0x808055F4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutGetStatus_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutGetStatus"
    VALUE
    0x808055F8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutIgnoreError_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutIgnoreError"
    VALUE
    0x808055FC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutResetError_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutResetError"
    VALUE
    0x80805600
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutUnlock_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutUnlock"
    VALUE
    0x80805604
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safout_cfgDiag_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safout_cfgDiag"
    VALUE
    0x80805608
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_secAccessDenied_RC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_secAccessDenied_RC"
    VALUE
    0x8080560C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_secAccessDenied_WDBI_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_secAccessDenied_WDBI"
    VALUE
    0x80805610
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_secEvalRespKey_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_secEvalRespKey"
    VALUE
    0x80805614
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_secFlashingFailure_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_secFlashingFailure"
    VALUE
    0x80805618
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_secGetLevel_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_secGetLevel"
    VALUE
    0x8080561C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_secGetRnd_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_secGetRnd"
    VALUE
    0x80805620
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_secGetSeed_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_secGetSeed"
    VALUE
    0x80805624
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_secInvalidPassword_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_secInvalidPassword"
    VALUE
    0x80805628
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_secIsRequestAllowed_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_secIsRequestAllowed"
    VALUE
    0x8080562C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_secResetLevel_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_secResetLevel"
    VALUE
    0x80805630
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_secSaveSecret_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_secSaveSecret"
    VALUE
    0x80805634
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_secSetLevel_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_secSetLevel"
    VALUE
    0x80805638
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_sysAit_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_sysAit"
    VALUE
    0x8080563C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_sysAiv_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_sysAiv"
    VALUE
    0x80805640
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_sysDi_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_sysDi"
    VALUE
    0x80805644
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_sysDo_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_sysDo"
    VALUE
    0x80805648
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_sysGetVss_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_sysGetVss"
    VALUE
    0x8080564C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_sysInit_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_sysInit"
    VALUE
    0x80805650
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_sysOperHrIntegrityErr_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_sysOperHrIntegrityErr"
    VALUE
    0x80805654
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_sysOperHrsSaturated_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_sysOperHrsSaturated"
    VALUE
    0x80805658
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_sysSetVss_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_sysSetVss"
    VALUE
    0x8080565C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_sys_coreload_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_sys_coreload"
    VALUE
    0x80805660
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_sys_taskload_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_sys_taskload"
    VALUE
    0x80805664
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_OV_VSS1_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_OV_VSS1"
    VALUE
    0x80805668
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_OV_VSS2_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_OV_VSS2"
    VALUE
    0x8080566C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_UV_VSS1_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_UV_VSS1"
    VALUE
    0x80805670
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_UV_VSS2_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_UV_VSS2"
    VALUE
    0x80805674
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_CANSM_E_BUS_OFF_NETWORK_0_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_CANSM_E_BUS_OFF_NETWORK_0"
    VALUE
    0x80805678
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_CANSM_E_BUS_OFF_NETWORK_1_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_CANSM_E_BUS_OFF_NETWORK_1"
    VALUE
    0x8080567C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_CANSM_E_BUS_OFF_NETWORK_2_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_CANSM_E_BUS_OFF_NETWORK_2"
    VALUE
    0x80805680
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_CANSM_E_BUS_OFF_NETWORK_3_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_CANSM_E_BUS_OFF_NETWORK_3"
    VALUE
    0x80805684
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_CANTRCV_E_NO_TRCV_CONTROL_0_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_CANTRCV_E_NO_TRCV_CONTROL_0"
    VALUE
    0x80805688
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_CAN_E_TIMEOUT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_CAN_E_TIMEOUT"
    VALUE
    0x8080568C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_COMM_E_NET_START_IND_CHANNEL_0_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_COMM_E_NET_START_IND_CHANNEL_0"
    VALUE
    0x80805690
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_COMM_E_NET_START_IND_CHANNEL_1_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_COMM_E_NET_START_IND_CHANNEL_1"
    VALUE
    0x80805694
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_COMM_E_NET_START_IND_CHANNEL_2_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_COMM_E_NET_START_IND_CHANNEL_2"
    VALUE
    0x80805698
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_COMM_E_NET_START_IND_CHANNEL_3_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_COMM_E_NET_START_IND_CHANNEL_3"
    VALUE
    0x8080569C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_COMM_E_NET_START_IND_CHANNEL_4_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_COMM_E_NET_START_IND_CHANNEL_4"
    VALUE
    0x808056A0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_COMM_E_NET_START_IND_CHANNEL_5_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_COMM_E_NET_START_IND_CHANNEL_5"
    VALUE
    0x808056A4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_LIN_E_TIMEOUT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_LIN_E_TIMEOUT"
    VALUE
    0x808056A8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rba_MultiStackTrace_Threshold_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rba_MultiStackTrace_Threshold"
    VALUE
    0x808056AC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_ETH_E_ACCESS_0_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_ETH_E_ACCESS_0"
    VALUE
    0x808056B0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_RBA_IOEXTLIB_KEEPALIVE_DRV_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_RBA_IOEXTLIB_KEEPALIVE_DRV"
    VALUE
    0x808056B4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_RBA_IOEXTLIB_KEEPALIVE_INI_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_RBA_IOEXTLIB_KEEPALIVE_INI"
    VALUE
    0x808056B8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rba_MRly_Diag_Stk_Event_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rba_MRly_Diag_Stk_Event"
    VALUE
    0x808056BC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rba_MemDiagExtd_MemReadSngErr_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rba_MemDiagExtd_MemReadSngErr"
    VALUE
    0x808056C0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rba_MemDiag_MemReadErr_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rba_MemDiag_MemReadErr"
    VALUE
    0x808056C4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rba_MemDiag_MemWrErr_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rba_MemDiag_MemWrErr"
    VALUE
    0x808056C8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rba_SyC_IrrSwOffTrigEngRun_Event_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rba_SyC_IrrSwOffTrigEngRun_Event"
    VALUE
    0x808056CC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rba_T15_Diag_ComInVld_Event_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rba_T15_Diag_ComInVld_Event"
    VALUE
    0x808056D0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rba_T15_Diag_ComOff_HwOn_Event_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rba_T15_Diag_ComOff_HwOn_Event"
    VALUE
    0x808056D4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rba_T15_Diag_ComOn_HwOff_Event_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rba_T15_Diag_ComOn_HwOff_Event"
    VALUE
    0x808056D8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM0_0_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_0"
    VALUE
    0x808056DC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM0_1_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_1"
    VALUE
    0x808056E0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM0_10_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_10"
    VALUE
    0x808056E4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM0_11_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_11"
    VALUE
    0x808056E8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM0_13_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_13"
    VALUE
    0x808056EC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM0_14_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_14"
    VALUE
    0x808056F0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM0_2_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_2"
    VALUE
    0x808056F4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM0_22_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_22"
    VALUE
    0x808056F8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM0_23_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_23"
    VALUE
    0x808056FC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM0_4_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_4"
    VALUE
    0x80805700
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM0_5_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_5"
    VALUE
    0x80805704
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM0_7_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_7"
    VALUE
    0x80805708
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM0_8_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_8"
    VALUE
    0x8080570C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM10_16_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM10_16"
    VALUE
    0x80805710
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM10_17_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM10_17"
    VALUE
    0x80805714
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM10_21_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM10_21"
    VALUE
    0x80805718
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM11_0_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_0"
    VALUE
    0x8080571C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM11_1_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_1"
    VALUE
    0x80805720
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM11_2_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_2"
    VALUE
    0x80805724
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM11_3_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_3"
    VALUE
    0x80805728
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM11_4_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_4"
    VALUE
    0x8080572C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM11_5_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_5"
    VALUE
    0x80805730
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM11_8_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_8"
    VALUE
    0x80805734
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM11_9_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_9"
    VALUE
    0x80805738
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM1_0_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_0"
    VALUE
    0x8080573C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM1_1_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_1"
    VALUE
    0x80805740
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM1_10_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_10"
    VALUE
    0x80805744
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM1_11_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_11"
    VALUE
    0x80805748
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM1_13_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_13"
    VALUE
    0x8080574C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM1_14_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_14"
    VALUE
    0x80805750
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM1_2_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_2"
    VALUE
    0x80805754
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM1_22_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_22"
    VALUE
    0x80805758
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM1_23_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_23"
    VALUE
    0x8080575C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM1_4_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_4"
    VALUE
    0x80805760
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM1_5_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_5"
    VALUE
    0x80805764
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM1_7_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_7"
    VALUE
    0x80805768
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM1_8_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_8"
    VALUE
    0x8080576C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM21_0_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM21_0"
    VALUE
    0x80805770
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM21_16_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM21_16"
    VALUE
    0x80805774
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM21_3_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM21_3"
    VALUE
    0x80805778
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM2_1_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_1"
    VALUE
    0x8080577C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM2_10_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_10"
    VALUE
    0x80805780
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM2_11_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_11"
    VALUE
    0x80805784
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM2_13_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_13"
    VALUE
    0x80805788
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM2_14_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_14"
    VALUE
    0x8080578C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM2_2_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_2"
    VALUE
    0x80805790
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM2_22_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_22"
    VALUE
    0x80805794
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM2_23_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_23"
    VALUE
    0x80805798
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM2_4_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_4"
    VALUE
    0x8080579C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM2_5_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_5"
    VALUE
    0x808057A0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM2_7_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_7"
    VALUE
    0x808057A4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM2_8_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_8"
    VALUE
    0x808057A8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM3_1_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_1"
    VALUE
    0x808057AC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM3_10_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_10"
    VALUE
    0x808057B0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM3_11_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_11"
    VALUE
    0x808057B4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM3_13_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_13"
    VALUE
    0x808057B8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM3_14_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_14"
    VALUE
    0x808057BC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM3_2_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_2"
    VALUE
    0x808057C0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM3_22_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_22"
    VALUE
    0x808057C4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM3_23_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_23"
    VALUE
    0x808057C8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM3_4_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_4"
    VALUE
    0x808057CC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM3_5_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_5"
    VALUE
    0x808057D0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM3_7_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_7"
    VALUE
    0x808057D4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM3_8_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_8"
    VALUE
    0x808057D8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM6_0_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_0"
    VALUE
    0x808057DC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM6_11_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_11"
    VALUE
    0x808057E0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM6_12_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_12"
    VALUE
    0x808057E4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM6_14_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_14"
    VALUE
    0x808057E8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM6_15_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_15"
    VALUE
    0x808057EC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM6_17_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_17"
    VALUE
    0x808057F0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM6_18_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_18"
    VALUE
    0x808057F4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM6_2_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_2"
    VALUE
    0x808057F8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM6_20_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_20"
    VALUE
    0x808057FC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM6_21_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_21"
    VALUE
    0x80805800
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM6_25_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_25"
    VALUE
    0x80805804
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM6_4_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_4"
    VALUE
    0x80805808
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM6_5_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_5"
    VALUE
    0x8080580C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM6_7_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_7"
    VALUE
    0x80805810
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM6_8_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_8"
    VALUE
    0x80805814
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM7_1_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_1"
    VALUE
    0x80805818
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM7_12_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_12"
    VALUE
    0x8080581C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM7_13_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_13"
    VALUE
    0x80805820
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM7_14_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_14"
    VALUE
    0x80805824
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM7_15_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_15"
    VALUE
    0x80805828
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM7_16_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_16"
    VALUE
    0x8080582C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM7_17_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_17"
    VALUE
    0x80805830
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM7_2_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_2"
    VALUE
    0x80805834
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM7_20_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_20"
    VALUE
    0x80805838
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM7_25_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_25"
    VALUE
    0x8080583C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM7_26_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_26"
    VALUE
    0x80805840
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM7_28_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_28"
    VALUE
    0x80805844
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM7_29_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_29"
    VALUE
    0x80805848
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM7_30_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_30"
    VALUE
    0x8080584C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM7_31_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_31"
    VALUE
    0x80805850
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM8_0_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_0"
    VALUE
    0x80805854
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM8_1_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_1"
    VALUE
    0x80805858
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM8_10_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_10"
    VALUE
    0x8080585C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM8_11_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_11"
    VALUE
    0x80805860
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM8_12_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_12"
    VALUE
    0x80805864
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM8_13_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_13"
    VALUE
    0x80805868
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM8_16_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_16"
    VALUE
    0x8080586C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM8_18_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_18"
    VALUE
    0x80805870
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM8_2_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_2"
    VALUE
    0x80805874
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM8_3_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_3"
    VALUE
    0x80805878
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM8_30_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_30"
    VALUE
    0x8080587C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM8_31_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_31"
    VALUE
    0x80805880
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM8_4_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_4"
    VALUE
    0x80805884
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM9_0_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM9_0"
    VALUE
    0x80805888
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM9_1_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM9_1"
    VALUE
    0x8080588C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM9_15_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM9_15"
    VALUE
    0x80805890
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM9_3_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM9_3"
    VALUE
    0x80805894
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MoCSOPICO_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MoCSOPICO"
    VALUE
    0x80805898
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MoFVarPostBldSel_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MoFVarPostBldSel"
    VALUE
    0x8080589C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MoSysCtrlReIni_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MoSysCtrlReIni"
    VALUE
    0x808058A0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MoXEMMHwLTMCUFW_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MoXEMMHwLTMCUFW"
    VALUE
    0x808058A4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MoXEMMHwLTMonBIST_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MoXEMMHwLTMonBIST"
    VALUE
    0x808058A8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MoXEMMHwLTRegMonTest_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MoXEMMHwLTRegMonTest"
    VALUE
    0x808058AC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MoXEMMHwLTStbySMUAlvTest_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MoXEMMHwLTStbySMUAlvTest"
    VALUE
    0x808058B0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MoXEMMHwLTTempSens_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MoXEMMHwLTTempSens"
    VALUE
    0x808058B4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MoXEMMHwLTUCBCfg_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MoXEMMHwLTUCBCfg"
    VALUE
    0x808058B8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_OCWDAABEActv_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_OCWDAABEActv"
    VALUE
    0x808058BC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_OCWDACom_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_OCWDACom"
    VALUE
    0x808058C0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_OCWDAErrPin_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_OCWDAErrPin"
    VALUE
    0x808058C4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_SWReset_0_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_SWReset_0"
    VALUE
    0x808058C8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_SWReset_1_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_SWReset_1"
    VALUE
    0x808058CC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_SWReset_2_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_SWReset_2"
    VALUE
    0x808058D0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDebFault1_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDebFault1"
    VALUE
    0x808058D4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_Unused_C
    "J1939FMI specific trouble code / "
    VALUE
    0x808058D8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    READ_ONLY

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_TimeInRowDebFault_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_TimeInRowDebFault"
    VALUE
    0x808058D9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_EventInRowDebFault_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_EventInRowDebFault"
    VALUE
    0x808058DA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_DevLibBattUHi_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_DevLibBattUHi"
    VALUE
    0x808058DB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_DevLibBattULo_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_DevLibBattULo"
    VALUE
    0x808058DC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_TimeUpDownDebFault_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_TimeUpDownDebFault"
    VALUE
    0x808058DD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA13OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA13OR"
    VALUE
    0x808058DE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA13SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA13SCB"
    VALUE
    0x808058DF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA13SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA13SCG"
    VALUE
    0x808058E0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA14OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA14OR"
    VALUE
    0x808058E1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA14SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA14SCB"
    VALUE
    0x808058E2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA14SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA14SCG"
    VALUE
    0x808058E3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA21OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA21OR"
    VALUE
    0x808058E4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA21SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA21SCB"
    VALUE
    0x808058E5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA21SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA21SCG"
    VALUE
    0x808058E6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA22OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA22OR"
    VALUE
    0x808058E7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA22SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA22SCB"
    VALUE
    0x808058E8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA22SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA22SCG"
    VALUE
    0x808058E9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA23OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA23OR"
    VALUE
    0x808058EA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA23SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA23SCB"
    VALUE
    0x808058EB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA23SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA23SCG"
    VALUE
    0x808058EC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA24OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA24OR"
    VALUE
    0x808058ED
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA24SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA24SCB"
    VALUE
    0x808058EE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA24SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA24SCG"
    VALUE
    0x808058EF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA25OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA25OR"
    VALUE
    0x808058F0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA25SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA25SCB"
    VALUE
    0x808058F1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA25SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA25SCG"
    VALUE
    0x808058F2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA26OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA26OR"
    VALUE
    0x808058F3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA26SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA26SCB"
    VALUE
    0x808058F4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA26SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA26SCG"
    VALUE
    0x808058F5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA27OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA27OR"
    VALUE
    0x808058F6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA27SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA27SCB"
    VALUE
    0x808058F7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA27SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA27SCG"
    VALUE
    0x808058F8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA28OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA28OR"
    VALUE
    0x808058F9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA28SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA28SCB"
    VALUE
    0x808058FA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA28SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA28SCG"
    VALUE
    0x808058FB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA29OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA29OR"
    VALUE
    0x808058FC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA29SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA29SCB"
    VALUE
    0x808058FD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA29SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA29SCG"
    VALUE
    0x808058FE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA36AicSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA36AicSCB"
    VALUE
    0x808058FF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA36AicSCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA36AicSCG"
    VALUE
    0x80805900
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA36OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA36OR"
    VALUE
    0x80805901
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA36SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA36SCB"
    VALUE
    0x80805902
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA36SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA36SCG"
    VALUE
    0x80805903
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA36ShuntSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA36ShuntSCB"
    VALUE
    0x80805904
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA37AicSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA37AicSCB"
    VALUE
    0x80805905
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA37AicSCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA37AicSCG"
    VALUE
    0x80805906
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA37OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA37OR"
    VALUE
    0x80805907
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA37SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA37SCB"
    VALUE
    0x80805908
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA37SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA37SCG"
    VALUE
    0x80805909
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA37ShuntSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA37ShuntSCB"
    VALUE
    0x8080590A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA38AicSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA38AicSCB"
    VALUE
    0x8080590B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA38AicSCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA38AicSCG"
    VALUE
    0x8080590C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA38OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA38OR"
    VALUE
    0x8080590D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA38SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA38SCB"
    VALUE
    0x8080590E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA38SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA38SCG"
    VALUE
    0x8080590F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA38ShuntSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA38ShuntSCB"
    VALUE
    0x80805910
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA39AicSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA39AicSCB"
    VALUE
    0x80805911
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA39AicSCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA39AicSCG"
    VALUE
    0x80805912
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA39OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA39OR"
    VALUE
    0x80805913
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA39SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA39SCB"
    VALUE
    0x80805914
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA39SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA39SCG"
    VALUE
    0x80805915
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA39ShuntSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA39ShuntSCB"
    VALUE
    0x80805916
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA40OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA40OR"
    VALUE
    0x80805917
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA40SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA40SCB"
    VALUE
    0x80805918
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA40SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA40SCG"
    VALUE
    0x80805919
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA41OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA41OR"
    VALUE
    0x8080591A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA41SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA41SCB"
    VALUE
    0x8080591B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA41SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA41SCG"
    VALUE
    0x8080591C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA42OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA42OR"
    VALUE
    0x8080591D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA42SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA42SCB"
    VALUE
    0x8080591E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA42SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA42SCG"
    VALUE
    0x8080591F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA43AicSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA43AicSCB"
    VALUE
    0x80805920
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA43AicSCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA43AicSCG"
    VALUE
    0x80805921
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA43OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA43OR"
    VALUE
    0x80805922
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA43SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA43SCB"
    VALUE
    0x80805923
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA43SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA43SCG"
    VALUE
    0x80805924
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA43ShuntSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA43ShuntSCB"
    VALUE
    0x80805925
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA44OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA44OL"
    VALUE
    0x80805926
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA44SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA44SCB"
    VALUE
    0x80805927
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA44SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA44SCG"
    VALUE
    0x80805928
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA57OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA57OR"
    VALUE
    0x80805929
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA57SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA57SCB"
    VALUE
    0x8080592A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA57SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA57SCG"
    VALUE
    0x8080592B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA59OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA59OL"
    VALUE
    0x8080592C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA59SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA59SCB"
    VALUE
    0x8080592D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA59SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA59SCG"
    VALUE
    0x8080592E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK10OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK10OR"
    VALUE
    0x8080592F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK10SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK10SCB"
    VALUE
    0x80805930
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK10SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK10SCG"
    VALUE
    0x80805931
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK11OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK11OR"
    VALUE
    0x80805932
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK11SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK11SCB"
    VALUE
    0x80805933
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK11SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK11SCG"
    VALUE
    0x80805934
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK30AicSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK30AicSCB"
    VALUE
    0x80805935
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK30AicSCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK30AicSCG"
    VALUE
    0x80805936
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK30OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK30OR"
    VALUE
    0x80805937
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK30SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK30SCB"
    VALUE
    0x80805938
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK30SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK30SCG"
    VALUE
    0x80805939
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK30ShuntSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK30ShuntSCB"
    VALUE
    0x8080593A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK31OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK31OR"
    VALUE
    0x8080593B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK31SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK31SCB"
    VALUE
    0x8080593C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK31SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK31SCG"
    VALUE
    0x8080593D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK32OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK32OR"
    VALUE
    0x8080593E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK32SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK32SCB"
    VALUE
    0x8080593F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK32SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK32SCG"
    VALUE
    0x80805940
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK33OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK33OR"
    VALUE
    0x80805941
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK33SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK33SCB"
    VALUE
    0x80805942
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK33SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK33SCG"
    VALUE
    0x80805943
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK34OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK34OR"
    VALUE
    0x80805944
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK34SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK34SCB"
    VALUE
    0x80805945
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK34SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK34SCG"
    VALUE
    0x80805946
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK35OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK35OR"
    VALUE
    0x80805947
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK35SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK35SCB"
    VALUE
    0x80805948
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK35SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK35SCG"
    VALUE
    0x80805949
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK36OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK36OR"
    VALUE
    0x8080594A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK36SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK36SCB"
    VALUE
    0x8080594B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK36SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK36SCG"
    VALUE
    0x8080594C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK37AicSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK37AicSCB"
    VALUE
    0x8080594D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK37AicSCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK37AicSCG"
    VALUE
    0x8080594E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK37OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK37OR"
    VALUE
    0x8080594F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK37SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK37SCB"
    VALUE
    0x80805950
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK37SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK37SCG"
    VALUE
    0x80805951
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK37ShuntSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK37ShuntSCB"
    VALUE
    0x80805952
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK38AicSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK38AicSCB"
    VALUE
    0x80805953
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK38AicSCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK38AicSCG"
    VALUE
    0x80805954
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK38OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK38OR"
    VALUE
    0x80805955
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK38SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK38SCB"
    VALUE
    0x80805956
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK38SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK38SCG"
    VALUE
    0x80805957
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK38ShuntSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK38ShuntSCB"
    VALUE
    0x80805958
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK39AicSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK39AicSCB"
    VALUE
    0x80805959
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK39AicSCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK39AicSCG"
    VALUE
    0x8080595A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK39OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK39OR"
    VALUE
    0x8080595B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK39SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK39SCB"
    VALUE
    0x8080595C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK39SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK39SCG"
    VALUE
    0x8080595D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK39ShuntSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK39ShuntSCB"
    VALUE
    0x8080595E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK40AicSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK40AicSCB"
    VALUE
    0x8080595F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK40AicSCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK40AicSCG"
    VALUE
    0x80805960
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK40OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK40OR"
    VALUE
    0x80805961
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK40SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK40SCB"
    VALUE
    0x80805962
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK40SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK40SCG"
    VALUE
    0x80805963
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK40ShuntSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK40ShuntSCB"
    VALUE
    0x80805964
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK41AicSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK41AicSCB"
    VALUE
    0x80805965
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK41AicSCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK41AicSCG"
    VALUE
    0x80805966
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK41OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK41OR"
    VALUE
    0x80805967
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK41SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK41SCB"
    VALUE
    0x80805968
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK41SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK41SCG"
    VALUE
    0x80805969
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK41ShuntSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK41ShuntSCB"
    VALUE
    0x8080596A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK42AicSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK42AicSCB"
    VALUE
    0x8080596B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK42AicSCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK42AicSCG"
    VALUE
    0x8080596C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK42OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK42OR"
    VALUE
    0x8080596D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK42SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK42SCB"
    VALUE
    0x8080596E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK42SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK42SCG"
    VALUE
    0x8080596F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK42ShuntSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK42ShuntSCB"
    VALUE
    0x80805970
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK43OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK43OR"
    VALUE
    0x80805971
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK43SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK43SCB"
    VALUE
    0x80805972
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK43SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK43SCG"
    VALUE
    0x80805973
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK44AicSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK44AicSCB"
    VALUE
    0x80805974
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK44AicSCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK44AicSCG"
    VALUE
    0x80805975
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK44OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK44OR"
    VALUE
    0x80805976
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK44SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK44SCB"
    VALUE
    0x80805977
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK44SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK44SCG"
    VALUE
    0x80805978
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK44ShuntSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK44ShuntSCB"
    VALUE
    0x80805979
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK45AicSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK45AicSCB"
    VALUE
    0x8080597A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK45AicSCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK45AicSCG"
    VALUE
    0x8080597B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK45OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK45OR"
    VALUE
    0x8080597C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK45SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK45SCB"
    VALUE
    0x8080597D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK45SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK45SCG"
    VALUE
    0x8080597E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK45ShuntSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK45ShuntSCB"
    VALUE
    0x8080597F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK52OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK52OR"
    VALUE
    0x80805980
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK52SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK52SCB"
    VALUE
    0x80805981
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK52SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK52SCG"
    VALUE
    0x80805982
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK53OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK53OR"
    VALUE
    0x80805983
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK53SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK53SCB"
    VALUE
    0x80805984
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK53SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK53SCG"
    VALUE
    0x80805985
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK54AicSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK54AicSCB"
    VALUE
    0x80805986
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK54AicSCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK54AicSCG"
    VALUE
    0x80805987
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK54OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK54OR"
    VALUE
    0x80805988
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK54SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK54SCB"
    VALUE
    0x80805989
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK54SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK54SCG"
    VALUE
    0x8080598A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK54ShuntSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK54ShuntSCB"
    VALUE
    0x8080598B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK55AicSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK55AicSCB"
    VALUE
    0x8080598C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK55AicSCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK55AicSCG"
    VALUE
    0x8080598D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK55OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK55OR"
    VALUE
    0x8080598E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK55SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK55SCB"
    VALUE
    0x8080598F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK55SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK55SCG"
    VALUE
    0x80805990
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK55ShuntSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK55ShuntSCB"
    VALUE
    0x80805991
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK56OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK56OR"
    VALUE
    0x80805992
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK56SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK56SCB"
    VALUE
    0x80805993
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK56SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK56SCG"
    VALUE
    0x80805994
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK57OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK57OR"
    VALUE
    0x80805995
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK57SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK57SCB"
    VALUE
    0x80805996
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK57SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK57SCG"
    VALUE
    0x80805997
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK58OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK58OR"
    VALUE
    0x80805998
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK58SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK58SCB"
    VALUE
    0x80805999
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK58SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK58SCG"
    VALUE
    0x8080599A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK59OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK59OR"
    VALUE
    0x8080599B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK59SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK59SCB"
    VALUE
    0x8080599C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK59SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK59SCG"
    VALUE
    0x8080599D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK60OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK60OR"
    VALUE
    0x8080599E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK60SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK60SCB"
    VALUE
    0x8080599F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK60SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK60SCG"
    VALUE
    0x808059A0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK61AicSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK61AicSCB"
    VALUE
    0x808059A1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK61AicSCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK61AicSCG"
    VALUE
    0x808059A2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK61OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK61OR"
    VALUE
    0x808059A3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK61SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK61SCB"
    VALUE
    0x808059A4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK61SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK61SCG"
    VALUE
    0x808059A5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK61ShuntSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK61ShuntSCB"
    VALUE
    0x808059A6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK62OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK62OR"
    VALUE
    0x808059A7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK62SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK62SCB"
    VALUE
    0x808059A8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK62SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK62SCG"
    VALUE
    0x808059A9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK63AicSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK63AicSCB"
    VALUE
    0x808059AA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK63AicSCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK63AicSCG"
    VALUE
    0x808059AB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK63OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK63OR"
    VALUE
    0x808059AC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK63SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK63SCB"
    VALUE
    0x808059AD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK63SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK63SCG"
    VALUE
    0x808059AE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK63ShuntSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK63ShuntSCB"
    VALUE
    0x808059AF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK64AicSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK64AicSCB"
    VALUE
    0x808059B0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK64AicSCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK64AicSCG"
    VALUE
    0x808059B1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK64OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK64OR"
    VALUE
    0x808059B2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK64SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK64SCB"
    VALUE
    0x808059B3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK64SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK64SCG"
    VALUE
    0x808059B4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK64ShuntSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK64ShuntSCB"
    VALUE
    0x808059B5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK65AicSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK65AicSCB"
    VALUE
    0x808059B6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK65AicSCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK65AicSCG"
    VALUE
    0x808059B7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK65OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK65OR"
    VALUE
    0x808059B8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK65SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK65SCB"
    VALUE
    0x808059B9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK65SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK65SCG"
    VALUE
    0x808059BA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK65ShuntSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK65ShuntSCB"
    VALUE
    0x808059BB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK74OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK74OR"
    VALUE
    0x808059BC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK74SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK74SCB"
    VALUE
    0x808059BD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK74SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK74SCG"
    VALUE
    0x808059BE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK75OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK75OR"
    VALUE
    0x808059BF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK75SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK75SCB"
    VALUE
    0x808059C0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK75SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK75SCG"
    VALUE
    0x808059C1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK76OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK76OR"
    VALUE
    0x808059C2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK76SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK76SCB"
    VALUE
    0x808059C3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK76SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK76SCG"
    VALUE
    0x808059C4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK77OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK77OR"
    VALUE
    0x808059C5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK77SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK77SCB"
    VALUE
    0x808059C6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK77SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK77SCG"
    VALUE
    0x808059C7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK78OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK78OR"
    VALUE
    0x808059C8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK78SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK78SCB"
    VALUE
    0x808059C9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK78SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK78SCG"
    VALUE
    0x808059CA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_DvUBAT_FWs_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_DvUBAT_FWs"
    VALUE
    0x808059CB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_OVErr_VPR6_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_OVErr_VPR6"
    VALUE
    0x808059CC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_OVWarn_VPR6_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_OVWarn_VPR6"
    VALUE
    0x808059CD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3"
    VALUE
    0x808059CE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2"
    VALUE
    0x808059CF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_OV_UBAT_MON_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_OV_UBAT_MON"
    VALUE
    0x808059D0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_OV_UBRM24_FLEXIN_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_OV_UBRM24_FLEXIN"
    VALUE
    0x808059D1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_OV_UBRM24_LOADS_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_OV_UBRM24_LOADS"
    VALUE
    0x808059D2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_OV_UBRM24_MON_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_OV_UBRM24_MON"
    VALUE
    0x808059D3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_OV_VDD5_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_OV_VDD5"
    VALUE
    0x808059D4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_OV_VDD5_IN_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_OV_VDD5_IN"
    VALUE
    0x808059D5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_OV_VPR6_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_OV_VPR6"
    VALUE
    0x808059D6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_OV_VSS3_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_OV_VSS3"
    VALUE
    0x808059D7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_OV_VSS4_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_OV_VSS4"
    VALUE
    0x808059D8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_Temp1_HTErr_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_Temp1_HTErr"
    VALUE
    0x808059D9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_Temp1_HTWarn_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_Temp1_HTWarn"
    VALUE
    0x808059DA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_Temp2_HTErr_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_Temp2_HTErr"
    VALUE
    0x808059DB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_Temp2_HTWarn_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_Temp2_HTWarn"
    VALUE
    0x808059DC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3"
    VALUE
    0x808059DD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2"
    VALUE
    0x808059DE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_UV_VDD5_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_UV_VDD5"
    VALUE
    0x808059DF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_UV_VDD5_IN_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_UV_VDD5_IN"
    VALUE
    0x808059E0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_UV_VPR6_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_UV_VPR6"
    VALUE
    0x808059E1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_UV_VSS3_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_UV_VSS3"
    VALUE
    0x808059E2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_UV_VSS4_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_UV_VSS4"
    VALUE
    0x808059E3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA01OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA01OL"
    VALUE
    0x808059E4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA01OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA01OT"
    VALUE
    0x808059E5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA01SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA01SCB"
    VALUE
    0x808059E6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA01SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA01SCG"
    VALUE
    0x808059E7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA02OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA02OL"
    VALUE
    0x808059E8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA02OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA02OR"
    VALUE
    0x808059E9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA02OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA02OT"
    VALUE
    0x808059EA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA02SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA02SCB"
    VALUE
    0x808059EB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA02SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA02SCG"
    VALUE
    0x808059EC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA03OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA03OL"
    VALUE
    0x808059ED
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA03OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA03OT"
    VALUE
    0x808059EE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA03SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA03SCB"
    VALUE
    0x808059EF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA03SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA03SCG"
    VALUE
    0x808059F0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA04OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA04OL"
    VALUE
    0x808059F1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA04OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA04OT"
    VALUE
    0x808059F2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA04SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA04SCB"
    VALUE
    0x808059F3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA04SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA04SCG"
    VALUE
    0x808059F4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA05OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA05OL"
    VALUE
    0x808059F5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA05OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA05OR"
    VALUE
    0x808059F6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA05OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA05OT"
    VALUE
    0x808059F7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA05SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA05SCB"
    VALUE
    0x808059F8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA05SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA05SCG"
    VALUE
    0x808059F9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA06OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA06OL"
    VALUE
    0x808059FA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA06OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA06OR"
    VALUE
    0x808059FB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA06OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA06OT"
    VALUE
    0x808059FC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA06SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA06SCB"
    VALUE
    0x808059FD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA06SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA06SCG"
    VALUE
    0x808059FE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA07OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA07OL"
    VALUE
    0x808059FF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA07OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA07OT"
    VALUE
    0x80805A00
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA07SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA07SCB"
    VALUE
    0x80805A01
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA07SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA07SCG"
    VALUE
    0x80805A02
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA08OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA08OL"
    VALUE
    0x80805A03
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA08OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA08OT"
    VALUE
    0x80805A04
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA08SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA08SCB"
    VALUE
    0x80805A05
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA08SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA08SCG"
    VALUE
    0x80805A06
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA09OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA09OL"
    VALUE
    0x80805A07
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA09OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA09OR"
    VALUE
    0x80805A08
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA09OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA09OT"
    VALUE
    0x80805A09
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA09SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA09SCB"
    VALUE
    0x80805A0A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA09SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA09SCG"
    VALUE
    0x80805A0B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA10OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA10OL"
    VALUE
    0x80805A0C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA10OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA10OT"
    VALUE
    0x80805A0D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA10SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA10SCB"
    VALUE
    0x80805A0E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA10SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA10SCG"
    VALUE
    0x80805A0F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA11OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA11OL"
    VALUE
    0x80805A10
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA11OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA11OT"
    VALUE
    0x80805A11
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA11SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA11SCB"
    VALUE
    0x80805A12
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA11SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA11SCG"
    VALUE
    0x80805A13
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA12OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA12OR"
    VALUE
    0x80805A14
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA12SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA12SCB"
    VALUE
    0x80805A15
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA12SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA12SCG"
    VALUE
    0x80805A16
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA16OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA16OL"
    VALUE
    0x80805A17
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA16OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA16OT"
    VALUE
    0x80805A18
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA16SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA16SCB"
    VALUE
    0x80805A19
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA16SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA16SCG"
    VALUE
    0x80805A1A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA17OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA17OL"
    VALUE
    0x80805A1B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA17OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA17OR"
    VALUE
    0x80805A1C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA17OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA17OT"
    VALUE
    0x80805A1D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA17SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA17SCB"
    VALUE
    0x80805A1E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA17SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA17SCG"
    VALUE
    0x80805A1F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA18OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA18OL"
    VALUE
    0x80805A20
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA18OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA18OT"
    VALUE
    0x80805A21
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA18SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA18SCB"
    VALUE
    0x80805A22
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA18SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA18SCG"
    VALUE
    0x80805A23
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA19OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA19OL"
    VALUE
    0x80805A24
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA19OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA19OR"
    VALUE
    0x80805A25
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA19OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA19OT"
    VALUE
    0x80805A26
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA19SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA19SCB"
    VALUE
    0x80805A27
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA19SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA19SCG"
    VALUE
    0x80805A28
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA20OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA20OL"
    VALUE
    0x80805A29
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA20OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA20OR"
    VALUE
    0x80805A2A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA20OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA20OT"
    VALUE
    0x80805A2B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA20SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA20SCB"
    VALUE
    0x80805A2C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA20SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA20SCG"
    VALUE
    0x80805A2D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA31OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA31OL"
    VALUE
    0x80805A2E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA31OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA31OR"
    VALUE
    0x80805A2F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA31OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA31OT"
    VALUE
    0x80805A30
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA31SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA31SCB"
    VALUE
    0x80805A31
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA31SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA31SCG"
    VALUE
    0x80805A32
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA32OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA32OL"
    VALUE
    0x80805A33
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA32OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA32OR"
    VALUE
    0x80805A34
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA32OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA32OT"
    VALUE
    0x80805A35
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA32SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA32SCB"
    VALUE
    0x80805A36
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA32SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA32SCG"
    VALUE
    0x80805A37
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA33OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA33OL"
    VALUE
    0x80805A38
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA33OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA33OR"
    VALUE
    0x80805A39
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA33OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA33OT"
    VALUE
    0x80805A3A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA33SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA33SCB"
    VALUE
    0x80805A3B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA33SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA33SCG"
    VALUE
    0x80805A3C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA34OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA34OL"
    VALUE
    0x80805A3D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA34OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA34OR"
    VALUE
    0x80805A3E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA34OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA34OT"
    VALUE
    0x80805A3F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA34SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA34SCB"
    VALUE
    0x80805A40
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA34SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA34SCG"
    VALUE
    0x80805A41
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA35OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA35OL"
    VALUE
    0x80805A42
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA35OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA35OR"
    VALUE
    0x80805A43
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA35OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA35OT"
    VALUE
    0x80805A44
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA35SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA35SCB"
    VALUE
    0x80805A45
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA35SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA35SCG"
    VALUE
    0x80805A46
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA46OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA46OL"
    VALUE
    0x80805A47
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA46OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA46OR"
    VALUE
    0x80805A48
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA46OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA46OT"
    VALUE
    0x80805A49
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA46SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA46SCB"
    VALUE
    0x80805A4A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA46SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA46SCG"
    VALUE
    0x80805A4B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA47OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA47OL"
    VALUE
    0x80805A4C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA47OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA47OR"
    VALUE
    0x80805A4D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA47OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA47OT"
    VALUE
    0x80805A4E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA47SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA47SCB"
    VALUE
    0x80805A4F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA47SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA47SCG"
    VALUE
    0x80805A50
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA48OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA48OL"
    VALUE
    0x80805A51
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA48OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA48OR"
    VALUE
    0x80805A52
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA48OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA48OT"
    VALUE
    0x80805A53
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA48SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA48SCB"
    VALUE
    0x80805A54
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA48SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA48SCG"
    VALUE
    0x80805A55
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA49OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA49OL"
    VALUE
    0x80805A56
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA49OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA49OT"
    VALUE
    0x80805A57
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA49SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA49SCB"
    VALUE
    0x80805A58
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA49SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA49SCG"
    VALUE
    0x80805A59
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA50OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA50OL"
    VALUE
    0x80805A5A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA50OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA50OT"
    VALUE
    0x80805A5B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA50SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA50SCB"
    VALUE
    0x80805A5C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA50SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA50SCG"
    VALUE
    0x80805A5D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA51OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA51OL"
    VALUE
    0x80805A5E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA51OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA51OR"
    VALUE
    0x80805A5F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA51OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA51OT"
    VALUE
    0x80805A60
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA51SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA51SCB"
    VALUE
    0x80805A61
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA51SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA51SCG"
    VALUE
    0x80805A62
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA52OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA52OL"
    VALUE
    0x80805A63
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA52OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA52OR"
    VALUE
    0x80805A64
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA52OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA52OT"
    VALUE
    0x80805A65
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA52SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA52SCB"
    VALUE
    0x80805A66
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA52SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA52SCG"
    VALUE
    0x80805A67
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA53OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA53OL"
    VALUE
    0x80805A68
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA53OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA53OR"
    VALUE
    0x80805A69
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA53OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA53OT"
    VALUE
    0x80805A6A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA53SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA53SCB"
    VALUE
    0x80805A6B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA53SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA53SCG"
    VALUE
    0x80805A6C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA54OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA54OL"
    VALUE
    0x80805A6D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA54OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA54OR"
    VALUE
    0x80805A6E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA54OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA54OT"
    VALUE
    0x80805A6F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA54SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA54SCB"
    VALUE
    0x80805A70
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA54SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA54SCG"
    VALUE
    0x80805A71
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA55OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA55OL"
    VALUE
    0x80805A72
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA55OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA55OT"
    VALUE
    0x80805A73
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA55SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA55SCB"
    VALUE
    0x80805A74
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA55SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA55SCG"
    VALUE
    0x80805A75
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA56OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA56OL"
    VALUE
    0x80805A76
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA56OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA56OT"
    VALUE
    0x80805A77
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA56SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA56SCB"
    VALUE
    0x80805A78
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA56SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA56SCG"
    VALUE
    0x80805A79
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA58OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA58OL"
    VALUE
    0x80805A7A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA58OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA58OT"
    VALUE
    0x80805A7B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA58SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA58SCB"
    VALUE
    0x80805A7C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA58SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA58SCG"
    VALUE
    0x80805A7D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK07OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK07OL"
    VALUE
    0x80805A7E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK07OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK07OR"
    VALUE
    0x80805A7F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK07OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK07OT"
    VALUE
    0x80805A80
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK07SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK07SCB"
    VALUE
    0x80805A81
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK07SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK07SCG"
    VALUE
    0x80805A82
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK08OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK08OL"
    VALUE
    0x80805A83
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK08OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK08OR"
    VALUE
    0x80805A84
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK08OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK08OT"
    VALUE
    0x80805A85
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK08SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK08SCB"
    VALUE
    0x80805A86
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK08SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK08SCG"
    VALUE
    0x80805A87
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK09OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK09OL"
    VALUE
    0x80805A88
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK09OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK09OR"
    VALUE
    0x80805A89
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK09OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK09OT"
    VALUE
    0x80805A8A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK09SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK09SCB"
    VALUE
    0x80805A8B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK09SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK09SCG"
    VALUE
    0x80805A8C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK12OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK12OL"
    VALUE
    0x80805A8D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK12OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK12OT"
    VALUE
    0x80805A8E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK12SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK12SCB"
    VALUE
    0x80805A8F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK12SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK12SCG"
    VALUE
    0x80805A90
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK13OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK13OL"
    VALUE
    0x80805A91
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK13OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK13OT"
    VALUE
    0x80805A92
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK13SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK13SCB"
    VALUE
    0x80805A93
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK13SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK13SCG"
    VALUE
    0x80805A94
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK14OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK14OL"
    VALUE
    0x80805A95
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK14OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK14OR"
    VALUE
    0x80805A96
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK14OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK14OT"
    VALUE
    0x80805A97
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK14SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK14SCB"
    VALUE
    0x80805A98
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK14SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK14SCG"
    VALUE
    0x80805A99
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK15OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK15OL"
    VALUE
    0x80805A9A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK15OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK15OR"
    VALUE
    0x80805A9B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK15OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK15OT"
    VALUE
    0x80805A9C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK15SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK15SCB"
    VALUE
    0x80805A9D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK15SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK15SCG"
    VALUE
    0x80805A9E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK16OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK16OL"
    VALUE
    0x80805A9F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK16OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK16OR"
    VALUE
    0x80805AA0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK16OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK16OT"
    VALUE
    0x80805AA1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK16SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK16SCB"
    VALUE
    0x80805AA2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK16SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK16SCG"
    VALUE
    0x80805AA3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK17OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK17OL"
    VALUE
    0x80805AA4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK17OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK17OR"
    VALUE
    0x80805AA5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK17OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK17OT"
    VALUE
    0x80805AA6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK17SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK17SCB"
    VALUE
    0x80805AA7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK17SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK17SCG"
    VALUE
    0x80805AA8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK25OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK25OR"
    VALUE
    0x80805AA9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK25SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK25SCB"
    VALUE
    0x80805AAA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK25SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK25SCG"
    VALUE
    0x80805AAB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK29OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK29OL"
    VALUE
    0x80805AAC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK29OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK29OR"
    VALUE
    0x80805AAD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK29OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK29OT"
    VALUE
    0x80805AAE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK29SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK29SCB"
    VALUE
    0x80805AAF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK29SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK29SCG"
    VALUE
    0x80805AB0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK51OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK51OL"
    VALUE
    0x80805AB1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK51OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK51OT"
    VALUE
    0x80805AB2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK51SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK51SCB"
    VALUE
    0x80805AB3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK51SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK51SCG"
    VALUE
    0x80805AB4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK62OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK62OR"
    VALUE
    0x80805AB5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK62SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK62SCB"
    VALUE
    0x80805AB6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK62SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK62SCG"
    VALUE
    0x80805AB7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK73OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK73OL"
    VALUE
    0x80805AB8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK73OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK73OR"
    VALUE
    0x80805AB9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK73OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK73OT"
    VALUE
    0x80805ABA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK73SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK73SCB"
    VALUE
    0x80805ABB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK73SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK73SCG"
    VALUE
    0x80805ABC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK80OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK80OL"
    VALUE
    0x80805ABD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK80OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK80OT"
    VALUE
    0x80805ABE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK80SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK80SCB"
    VALUE
    0x80805ABF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK80SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK80SCG"
    VALUE
    0x80805AC0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK81OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK81OL"
    VALUE
    0x80805AC1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK81OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK81OT"
    VALUE
    0x80805AC2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK81SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK81SCB"
    VALUE
    0x80805AC3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK81SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK81SCG"
    VALUE
    0x80805AC4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK82OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK82OL"
    VALUE
    0x80805AC5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK82OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK82OT"
    VALUE
    0x80805AC6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK82SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK82SCB"
    VALUE
    0x80805AC7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK82SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK82SCG"
    VALUE
    0x80805AC8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK83OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK83OL"
    VALUE
    0x80805AC9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK83OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK83OT"
    VALUE
    0x80805ACA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK83SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK83SCB"
    VALUE
    0x80805ACB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK83SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK83SCG"
    VALUE
    0x80805ACC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK84OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK84OL"
    VALUE
    0x80805ACD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK84OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK84OT"
    VALUE
    0x80805ACE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK84SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK84SCB"
    VALUE
    0x80805ACF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK84SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK84SCG"
    VALUE
    0x80805AD0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK85OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK85OL"
    VALUE
    0x80805AD1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK85OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK85OT"
    VALUE
    0x80805AD2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK85SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK85SCB"
    VALUE
    0x80805AD3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK85SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK85SCG"
    VALUE
    0x80805AD4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK86OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK86OL"
    VALUE
    0x80805AD5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK86OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK86OT"
    VALUE
    0x80805AD6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK86SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK86SCB"
    VALUE
    0x80805AD7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK86SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK86SCG"
    VALUE
    0x80805AD8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK87OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK87OL"
    VALUE
    0x80805AD9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK87OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK87OT"
    VALUE
    0x80805ADA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK87SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK87SCB"
    VALUE
    0x80805ADB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK87SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK87SCG"
    VALUE
    0x80805ADC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_EventUpDownDebFault_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_EventUpDownDebFault"
    VALUE
    0x80805ADD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_DSMDummy_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_DSMDummy"
    VALUE
    0x80805ADE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canGetDataNoBuf_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canGetDataNoBuf"
    VALUE
    0x80805ADF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canGetDataParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canGetDataParam"
    VALUE
    0x80805AE0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canGetDataboxNoInit_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canGetDataboxNoInit"
    VALUE
    0x80805AE1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canGetDataboxParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canGetDataboxParam"
    VALUE
    0x80805AE2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canGetRxBufStatusParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canGetRxBufStatusParam"
    VALUE
    0x80805AE3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canGetStatusParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canGetStatusParam"
    VALUE
    0x80805AE4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canGetTxBufStatusParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canGetTxBufStatusParam"
    VALUE
    0x80805AE5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canInitParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canInitParam"
    VALUE
    0x80805AE6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canInitRxDataboxOverlap_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canInitRxDataboxOverlap"
    VALUE
    0x80805AE7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canInitRxDataboxParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canInitRxDataboxParam"
    VALUE
    0x80805AE8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canInitTxDataboxParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canInitTxDataboxParam"
    VALUE
    0x80805AE9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canIpduGroupControl_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canIpduGroupControl"
    VALUE
    0x80805AEA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canIsDataboxFreeNoInit_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canIsDataboxFreeNoInit"
    VALUE
    0x80805AEB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canIsDataboxFreeParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canIsDataboxFreeParam"
    VALUE
    0x80805AEC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canIsTxEmptyParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canIsTxEmptyParam"
    VALUE
    0x80805AED
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canRegBusOffCallbInvState_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canRegBusOffCallbInvState"
    VALUE
    0x80805AEE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canRegBusOffCallbParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canRegBusOffCallbParam"
    VALUE
    0x80805AEF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canRegRxBufInvState_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canRegRxBufInvState"
    VALUE
    0x80805AF0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canRegRxBufOverlap_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canRegRxBufOverlap"
    VALUE
    0x80805AF1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canRegRxBufParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canRegRxBufParam"
    VALUE
    0x80805AF2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canRegRxCallbInvState_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canRegRxCallbInvState"
    VALUE
    0x80805AF3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canRegRxCallbParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canRegRxCallbParam"
    VALUE
    0x80805AF4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canRegRxDataboxInvNumb_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canRegRxDataboxInvNumb"
    VALUE
    0x80805AF5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canRegRxDataboxInvState_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canRegRxDataboxInvState"
    VALUE
    0x80805AF6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canRegRxDataboxOverlap_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canRegRxDataboxOverlap"
    VALUE
    0x80805AF7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canRegRxDataboxParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canRegRxDataboxParam"
    VALUE
    0x80805AF8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canRegTxBufInvState_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canRegTxBufInvState"
    VALUE
    0x80805AF9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canRegTxBufOverlap_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canRegTxBufOverlap"
    VALUE
    0x80805AFA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canRegTxBufParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canRegTxBufParam"
    VALUE
    0x80805AFB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canRegTxDataboxInvNumb_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canRegTxDataboxInvNumb"
    VALUE
    0x80805AFC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canRegTxDataboxInvState_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canRegTxDataboxInvState"
    VALUE
    0x80805AFD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canRegTxDataboxOverlap_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canRegTxDataboxOverlap"
    VALUE
    0x80805AFE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canRegTxDataboxParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canRegTxDataboxParam"
    VALUE
    0x80805AFF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canResetTxBufParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canResetTxBufParam"
    VALUE
    0x80805B00
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canSendDataBufOvfl_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canSendDataBufOvfl"
    VALUE
    0x80805B01
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canSendDataParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canSendDataParam"
    VALUE
    0x80805B02
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canSendDataboxNoInit_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canSendDataboxNoInit"
    VALUE
    0x80805B03
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canSendDataboxParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canSendDataboxParam"
    VALUE
    0x80805B04
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canSetTxCycleParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canSetTxCycleParam"
    VALUE
    0x80805B05
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canStartParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canStartParam"
    VALUE
    0x80805B06
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canStopParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canStopParam"
    VALUE
    0x80805B07
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_can_ClearIpduGroup_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_can_ClearIpduGroup"
    VALUE
    0x80805B08
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_can_ReceiveSignal_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_can_ReceiveSignal"
    VALUE
    0x80805B09
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_can_SendSignal_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_can_SendSignal"
    VALUE
    0x80805B0A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_can_SetIpduGroup_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_can_SetIpduGroup"
    VALUE
    0x80805B0B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_dsmDTCJ1939_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_dsmDTCJ1939"
    VALUE
    0x80805B0C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_dsmDelDTCJ1939_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_dsmDelDTCJ1939"
    VALUE
    0x80805B0D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_dsmDelErrors_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_dsmDelErrors"
    VALUE
    0x80805B0E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_dsmGetDFES_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_dsmGetDFES"
    VALUE
    0x80805B0F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_dsmGetDTCJ1939_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_dsmGetDTCJ1939"
    VALUE
    0x80805B10
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_dsmGetErrors_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_dsmGetErrors"
    VALUE
    0x80805B11
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_dsmGetNumErrors_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_dsmGetNumErrors"
    VALUE
    0x80805B12
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_dsmInitQueueOverflow_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_dsmInitQueueOverflow"
    VALUE
    0x80805B13
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_dsmNumDTCJ1939_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_dsmNumDTCJ1939"
    VALUE
    0x80805B14
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_dsmTesterror_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_dsmTesterror"
    VALUE
    0x80805B15
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_dsmUpdateDebError_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_dsmUpdateDebError"
    VALUE
    0x80805B16
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_dsmUpdateError_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_dsmUpdateError"
    VALUE
    0x80805B17
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_dsmgetDFCStatus_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_dsmgetDFCStatus"
    VALUE
    0x80805B18
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_dsmtestErrorDFC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_dsmtestErrorDFC"
    VALUE
    0x80805B19
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inAi_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inAi"
    VALUE
    0x80805B1A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inAic_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inAic"
    VALUE
    0x80805B1B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inAicCfg_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inAicCfg"
    VALUE
    0x80805B1C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inAicGetStatus_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inAicGetStatus"
    VALUE
    0x80805B1D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inAid_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inAid"
    VALUE
    0x80805B1E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inAidCfg_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inAidCfg"
    VALUE
    0x80805B1F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inAiv_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inAiv"
    VALUE
    0x80805B20
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inAivCfg_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inAivCfg"
    VALUE
    0x80805B21
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inAivGetStatus_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inAivGetStatus"
    VALUE
    0x80805B22
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inDi_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inDi"
    VALUE
    0x80805B23
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inFi_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inFi"
    VALUE
    0x80805B24
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inFiCfg_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inFiCfg"
    VALUE
    0x80805B25
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inFiGetStatus_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inFiGetStatus"
    VALUE
    0x80805B26
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inFi_Buffered_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inFi_Buffered"
    VALUE
    0x80805B27
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inPhase_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inPhase"
    VALUE
    0x80805B28
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inPhaseGetStatus_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inPhaseGetStatus"
    VALUE
    0x80805B29
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inPhaseResetCounter_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inPhaseResetCounter"
    VALUE
    0x80805B2A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inRi_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inRi"
    VALUE
    0x80805B2B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inRiCfg_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inRiCfg"
    VALUE
    0x80805B2C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inRiCfgTemp_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inRiCfgTemp"
    VALUE
    0x80805B2D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inRiGetStatus_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inRiGetStatus"
    VALUE
    0x80805B2E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inRiGetTemp_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inRiGetTemp"
    VALUE
    0x80805B2F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inSentCopyFDFifo_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inSentCopyFDFifo"
    VALUE
    0x80805B30
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inSentDisable_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inSentDisable"
    VALUE
    0x80805B31
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inSentEnable_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inSentEnable"
    VALUE
    0x80805B32
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inSentGetErrorStatus_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inSentGetErrorStatus"
    VALUE
    0x80805B33
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inSentGetFD_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inSentGetFD"
    VALUE
    0x80805B34
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inSentGetSD_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inSentGetSD"
    VALUE
    0x80805B35
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inSentGetSDDatabox_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inSentGetSDDatabox"
    VALUE
    0x80805B36
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inSentGetStatus_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inSentGetStatus"
    VALUE
    0x80805B37
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inSentInitSDDatabox_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inSentInitSDDatabox"
    VALUE
    0x80805B38
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inSentRegisterCopyFDFifo_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inSentRegisterCopyFDFifo"
    VALUE
    0x80805B39
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inSentRegisterFDFifo_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inSentRegisterFDFifo"
    VALUE
    0x80805B3A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inSentRegisterSDDataboxes_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inSentRegisterSDDataboxes"
    VALUE
    0x80805B3B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_isobusCanRxBufferOverflow_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_isobusCanRxBufferOverflow"
    VALUE
    0x80805B3C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_isobusGetCaAddrParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_isobusGetCaAddrParam"
    VALUE
    0x80805B3D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_isobusGetDiagnosticParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_isobusGetDiagnosticParam"
    VALUE
    0x80805B3E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_isobusGetRxDataboxStatusParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_isobusGetRxDataboxStatusParam"
    VALUE
    0x80805B3F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_isobusGetStatusParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_isobusGetStatusParam"
    VALUE
    0x80805B40
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_isobusInitCommCaMissing_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_isobusInitCommCaMissing"
    VALUE
    0x80805B41
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_isobusInitCommParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_isobusInitCommParam"
    VALUE
    0x80805B42
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_isobusInitCommState_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_isobusInitCommState"
    VALUE
    0x80805B43
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_isobusInitDiagnosticParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_isobusInitDiagnosticParam"
    VALUE
    0x80805B44
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_isobusInitFailureListParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_isobusInitFailureListParam"
    VALUE
    0x80805B45
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_isobusInitRxDataboxParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_isobusInitRxDataboxParam"
    VALUE
    0x80805B46
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_isobusInitTxDataboxParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_isobusInitTxDataboxParam"
    VALUE
    0x80805B47
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_isobusRegRxDataboxOverlap_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_isobusRegRxDataboxOverlap"
    VALUE
    0x80805B48
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_isobusRegRxDataboxParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_isobusRegRxDataboxParam"
    VALUE
    0x80805B49
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_isobusRegRxDataboxState_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_isobusRegRxDataboxState"
    VALUE
    0x80805B4A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_isobusRegTxDataboxOverlap_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_isobusRegTxDataboxOverlap"
    VALUE
    0x80805B4B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_isobusRegTxDataboxParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_isobusRegTxDataboxParam"
    VALUE
    0x80805B4C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_isobusRegTxDataboxState_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_isobusRegTxDataboxState"
    VALUE
    0x80805B4D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_isobusRegisterErrClrCallbackParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_isobusRegisterErrClrCallbackParam"
    VALUE
    0x80805B4E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_isobusRegisterInstancesOverlap_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_isobusRegisterInstancesOverlap"
    VALUE
    0x80805B4F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_isobusRegisterInstancesParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_isobusRegisterInstancesParam"
    VALUE
    0x80805B50
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_isobusRegisterInstancesState_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_isobusRegisterInstancesState"
    VALUE
    0x80805B51
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_isobusSendDataboxParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_isobusSendDataboxParam"
    VALUE
    0x80805B52
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_isobusSendRequestPGNParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_isobusSendRequestPGNParam"
    VALUE
    0x80805B53
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_isobusSetCaAddrCaUsed_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_isobusSetCaAddrCaUsed"
    VALUE
    0x80805B54
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_isobusSetCaAddrComm_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_isobusSetCaAddrComm"
    VALUE
    0x80805B55
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_isobusSetCaAddrInvCan_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_isobusSetCaAddrInvCan"
    VALUE
    0x80805B56
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_isobusSetCaAddrParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_isobusSetCaAddrParam"
    VALUE
    0x80805B57
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_isobusSetCaInfoParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_isobusSetCaInfoParam"
    VALUE
    0x80805B58
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_isobusSetCaNameParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_isobusSetCaNameParam"
    VALUE
    0x80805B59
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_isobusSftyCanTxErr_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_isobusSftyCanTxErr"
    VALUE
    0x80805B5A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_lin_ReceiveSignal_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_lin_ReceiveSignal"
    VALUE
    0x80805B5B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_lin_SendSignal_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_lin_SendSignal"
    VALUE
    0x80805B5C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_lin_getStatus_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_lin_getStatus"
    VALUE
    0x80805B5D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_lin_gotoSleep_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_lin_gotoSleep"
    VALUE
    0x80805B5E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_lin_scheduleRequest_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_lin_scheduleRequest"
    VALUE
    0x80805B5F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_lin_wakeUp_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_lin_wakeUp"
    VALUE
    0x80805B60
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_memFlsCfgShr_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_memFlsCfgShr"
    VALUE
    0x80805B61
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_memGetStatus_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_memGetStatus"
    VALUE
    0x80805B62
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_memMarkBlock_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_memMarkBlock"
    VALUE
    0x80805B63
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_memReadApi1Error_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_memReadApi1Error"
    VALUE
    0x80805B64
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_memReadApi2Error_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_memReadApi2Error"
    VALUE
    0x80805B65
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_memReadBlock_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_memReadBlock"
    VALUE
    0x80805B66
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_memReadCalibInputError_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_memReadCalibInputError"
    VALUE
    0x80805B67
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_memReadCalibOuputError_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_memReadCalibOuputError"
    VALUE
    0x80805B68
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_memReadSystemError_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_memReadSystemError"
    VALUE
    0x80805B69
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_memWriteBlock_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_memWriteBlock"
    VALUE
    0x80805B6A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_moOV_FirstConstADC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_moOV_FirstConstADC"
    VALUE
    0x80805B6B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_moOV_SecondConstADC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_moOV_SecondConstADC"
    VALUE
    0x80805B6C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_moUV_FirstConstADC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_moUV_FirstConstADC"
    VALUE
    0x80805B6D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_moUV_SecondConstADC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_moUV_SecondConstADC"
    VALUE
    0x80805B6E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_INH_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_INH"
    VALUE
    0x80805B6F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_INHLatch_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_INHLatch"
    VALUE
    0x80805B70
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_adcPDD_fail_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_adcPDD_fail"
    VALUE
    0x80805B71
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_memoryProtection_err_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_memoryProtection_err"
    VALUE
    0x80805B72
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA02OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA02OC"
    VALUE
    0x80805B73
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA02Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA02Unintended"
    VALUE
    0x80805B74
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA03OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA03OC"
    VALUE
    0x80805B75
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA03Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA03Unintended"
    VALUE
    0x80805B76
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA04OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA04OC"
    VALUE
    0x80805B77
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA04Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA04Unintended"
    VALUE
    0x80805B78
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA05OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA05OC"
    VALUE
    0x80805B79
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA05Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA05Unintended"
    VALUE
    0x80805B7A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA07OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA07OC"
    VALUE
    0x80805B7B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA07Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA07Unintended"
    VALUE
    0x80805B7C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA08OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA08OC"
    VALUE
    0x80805B7D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA08Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA08Unintended"
    VALUE
    0x80805B7E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA09OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA09OC"
    VALUE
    0x80805B7F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA09Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA09Unintended"
    VALUE
    0x80805B80
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA10OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA10OC"
    VALUE
    0x80805B81
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA10Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA10Unintended"
    VALUE
    0x80805B82
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA17OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA17OC"
    VALUE
    0x80805B83
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA17Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA17Unintended"
    VALUE
    0x80805B84
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA18OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA18OC"
    VALUE
    0x80805B85
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA18Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA18Unintended"
    VALUE
    0x80805B86
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA19OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA19OC"
    VALUE
    0x80805B87
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA19Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA19Unintended"
    VALUE
    0x80805B88
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA20OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA20OC"
    VALUE
    0x80805B89
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA20Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA20Unintended"
    VALUE
    0x80805B8A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA31OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA31OC"
    VALUE
    0x80805B8B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA31Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA31Unintended"
    VALUE
    0x80805B8C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA32OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA32OC"
    VALUE
    0x80805B8D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA32Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA32Unintended"
    VALUE
    0x80805B8E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA33OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA33OC"
    VALUE
    0x80805B8F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA33Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA33Unintended"
    VALUE
    0x80805B90
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA34OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA34OC"
    VALUE
    0x80805B91
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA34Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA34Unintended"
    VALUE
    0x80805B92
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA35OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA35OC"
    VALUE
    0x80805B93
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA35Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA35Unintended"
    VALUE
    0x80805B94
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA46OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA46OC"
    VALUE
    0x80805B95
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA46Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA46Unintended"
    VALUE
    0x80805B96
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA47OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA47OC"
    VALUE
    0x80805B97
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA47Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA47Unintended"
    VALUE
    0x80805B98
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA48OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA48OC"
    VALUE
    0x80805B99
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA48Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA48Unintended"
    VALUE
    0x80805B9A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA51OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA51OC"
    VALUE
    0x80805B9B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA51Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA51Unintended"
    VALUE
    0x80805B9C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA52OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA52OC"
    VALUE
    0x80805B9D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA52Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA52Unintended"
    VALUE
    0x80805B9E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA53OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA53OC"
    VALUE
    0x80805B9F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA53Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA53Unintended"
    VALUE
    0x80805BA0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA54OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA54OC"
    VALUE
    0x80805BA1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA54Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA54Unintended"
    VALUE
    0x80805BA2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outAov_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outAov"
    VALUE
    0x80805BA3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outAovCfg_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outAovCfg"
    VALUE
    0x80805BA4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outAovCfgPI_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outAovCfgPI"
    VALUE
    0x80805BA5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outAovGetStatus_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outAovGetStatus"
    VALUE
    0x80805BA6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outAovGetVoltage_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outAovGetVoltage"
    VALUE
    0x80805BA7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outAovResetError_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outAovResetError"
    VALUE
    0x80805BA8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outDo_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outDo"
    VALUE
    0x80805BA9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outDoCfgPwrLs_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outDoCfgPwrLs"
    VALUE
    0x80805BAA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outDoDisable_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outDoDisable"
    VALUE
    0x80805BAB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outDoGetCurrent_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outDoGetCurrent"
    VALUE
    0x80805BAC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outDoGetStatus_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outDoGetStatus"
    VALUE
    0x80805BAD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outDoResetError_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outDoResetError"
    VALUE
    0x80805BAE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK07OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK07OC"
    VALUE
    0x80805BAF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK07Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK07Unintended"
    VALUE
    0x80805BB0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK08OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK08OC"
    VALUE
    0x80805BB1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK08Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK08Unintended"
    VALUE
    0x80805BB2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK09OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK09OC"
    VALUE
    0x80805BB3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK09Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK09Unintended"
    VALUE
    0x80805BB4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK12OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK12OC"
    VALUE
    0x80805BB5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK12Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK12Unintended"
    VALUE
    0x80805BB6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK13OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK13OC"
    VALUE
    0x80805BB7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK13Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK13Unintended"
    VALUE
    0x80805BB8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK14OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK14OC"
    VALUE
    0x80805BB9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK14Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK14Unintended"
    VALUE
    0x80805BBA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK15OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK15OC"
    VALUE
    0x80805BBB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

