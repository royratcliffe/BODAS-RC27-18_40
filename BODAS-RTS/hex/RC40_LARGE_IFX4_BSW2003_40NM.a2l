    DIUMPR_tiCont.SigActv_38
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 38"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x600340B2

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_39
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 39"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x600340B3

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiEngOpCum
    "cumulative time since engine start (for general denominator condition)"
    UWORD
    DIUMPR_ti100ms
    1
    100
    0.00
    6553.500

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x60034082

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiEngOpCumPDTC
    "cumulative time since engine start (for PDTC condition)"
    UWORD
    DIUMPR_ti100ms
    1
    100
    0.00
    6553.500

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6003407C

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiIdl
    "continuous vehicle operation at idle (for general denominator condition)"
    UWORD
    DIUMPR_ti100ms
    1
    100
    0.00
    6553.500

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x60034080

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiIdlPDTC
    "continuous vehicle operation at idle (for PDTC driving cycle condition)"
    UWORD
    DIUMPR_ti100ms
    1
    100
    0.00
    6553.500

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6003407A

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiSigActv
    "Accumulated activation time"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    25.50

    
    FORMAT "%5.2"
    MATRIX_DIM 40  
    ECU_ADDRESS 0x600340DC

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiVehSpdCum
    "cumulative vehicle operation at or above 25 miles per hour (for general denominator condition)"
    UWORD
    DIUMPR_ti100ms
    1
    100
    0.00
    6553.500

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x60034084

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiVehSpdCumPDTC
    "cumulative vehicle operation at or above 25 miles per hour (for PDTC cycle condition)"
    UWORD
    DIUMPR_ti100ms
    1
    100
    0.00
    6553.500

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6003407E

/end MEASUREMENT

/begin MEASUREMENT

    dps_error
    "last read Pmd_GetErr() content of state OBSERVING"
    UWORD
    dez
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x70002B5E

/end MEASUREMENT

/begin MEASUREMENT

    dps_errStat
    "read Pmd_GetErr() content in state VERIFY or RECOVERY; this content is compared to dps_error"
    UWORD
    dez
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x70002B5C

/end MEASUREMENT

/begin MEASUREMENT

    dps_errStat_sum_rec
    "contains dps_errStat read during RECOVERY state"
    UWORD
    dez
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x70002B5A

/end MEASUREMENT

/begin MEASUREMENT

    dps_errStat_sum_ver
    "contains dps_errStat read during VERIFY state"
    UWORD
    dez
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x70002B58

/end MEASUREMENT

/begin MEASUREMENT

    dps_index
    "Indicates which powerstage is being observed"
    UBYTE
    dez
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x70002B63

/end MEASUREMENT

/begin MEASUREMENT

    dps_recoveryTime
    "Timer Recovery"
    UBYTE
    t_q0p1
    1
    100
    0.00
    25.50

    
    FORMAT "%5.2"
    
    ECU_ADDRESS 0x70002B62

/end MEASUREMENT

/begin MEASUREMENT

    dps_state
    "Index Statemachine"
    UBYTE
    dez
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x70002B61

/end MEASUREMENT

/begin MEASUREMENT

    dps_verifyTime
    "Timer Verify"
    UBYTE
    t_q0p1
    1
    100
    0.00
    25.50

    
    FORMAT "%5.2"
    
    ECU_ADDRESS 0x70002B60

/end MEASUREMENT

/begin MEASUREMENT

    DrvPrgSwt_numCurrCAN
    "Value of the driving program that is sent on the CAN"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C756

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    DrvPrgSwt_st
    "State of the driving program"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C755

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    DrvPrgSwt_stEffModReqd
    "Status efficiency mode is requested"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C754

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_DynPrio.FId_Unused
    "dynamic priority / "
    SWORD
    DFC_OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B8DA

/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_DynPrio.FId_InhibitAlways
    "dynamic priority / Dynamic priority of scheduled function identifier FId_InhibitAlways"
    SWORD
    DFC_OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B8DC

/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_PhysPrio.FId_Unused
    "physical priority / "
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE6F

/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_PhysPrio.FId_InhibitAlways
    "physical priority / Physical priority of scheduled function identifier FId_InhibitAlways"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE70

/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_RmpPrio.FId_Unused
    "Ramp priority / "
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B8D2

/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_RmpPrio.FId_InhibitAlways
    "Ramp priority / Ramp priority of scheduled function identifier FId_InhibitAlways"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B8D4

/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_St.FId_Unused
    "Scheduler Status / "
    UBYTE
    DSCHED_StVerb
    1
    100
    0.00
    238.000000000

    
    FORMAT "%13.9"
    
    ECU_ADDRESS 0x6000CE71

/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_St.FId_InhibitAlways
    "Scheduler Status / Scheduler status of function identifier FId_InhibitAlways"
    UBYTE
    DSCHED_StVerb
    1
    100
    0.00
    238.000000000

    
    FORMAT "%13.9"
    
    ECU_ADDRESS 0x6000CE72

/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_stDrvMode
    "Status of current operation mode"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C3D8

/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_stOpMode
    "Current system-mode as provided by system-mode-manager"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6000B314

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_WhyExcl.FId_Unused
    "exclusion reason / "
    UWORD
    DSCHED_FIdExcCauseVerb
    1
    100
    0.00
    255.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000B8D6

/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_WhyExcl.FId_InhibitAlways
    "exclusion reason / Exclusion cause of scheduled function identifier FId_InhibitAlways"
    UWORD
    DSCHED_FIdExcCauseVerb
    1
    100
    0.00
    255.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000B8D8

/end MEASUREMENT

/begin MEASUREMENT

    DSMAUX_ctObdDCy
    "Number of OBD driving cycle since diagnostic trouble codes cleared"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x60037B22

/end MEASUREMENT

/begin MEASUREMENT

    DSMAUX_ctObdDCy_msg
    "Number of OBD driving cycle since diagnostic trouble codes cleared"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B538

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    DSMAUX_ctWUC
    "Number of warm-ups since diagnostic trouble codes cleared"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036E1C

/end MEASUREMENT

/begin MEASUREMENT

    DSMAUX_ctWUC_msg
    "Number of warm-ups since diagnostic trouble codes cleared"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C699

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    DSMAUX_DTRG.DTRG_Time200ms
    "Trigger state / Trigger DTRG_Time200ms"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037B14

/end MEASUREMENT

/begin MEASUREMENT

    DSMAUX_DTRG.DTRG_SimilarCondHLC
    "Trigger state / Trigger DTRG_SimilarCondHLC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037B15

/end MEASUREMENT

/begin MEASUREMENT

    DSMAUX_DTRG.DTRG_DrivingCycleFLC
    "Trigger state / Trigger DTRG_DrivingCycleFLC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037B16

/end MEASUREMENT

/begin MEASUREMENT

    DSMAUX_DTRG.DTRG_AlwaysTrue
    "Trigger state / Trigger DTRG_AlwaysTrue"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037B17

/end MEASUREMENT

/begin MEASUREMENT

    DSMAUX_DTRG.DTRG_WarmUpCycleTime
    "Trigger state / Trigger DTRG_WarmUpCycleTime"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037B18

/end MEASUREMENT

/begin MEASUREMENT

    DSMAUX_DTRG.DTRG_WarmUpCycle
    "Trigger state / Trigger DTRG_WarmUpCycle"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037B19

/end MEASUREMENT

/begin MEASUREMENT

    DSMAUX_DTRG.DTRG_DrivingCycleSpeed
    "Trigger state / Trigger DTRG_DrivingCycleSpeed"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037B1A

/end MEASUREMENT

/begin MEASUREMENT

    DSMAUX_DTRG.DTRG_DrivingCycleHLC
    "Trigger state / Trigger DTRG_DrivingCycleHLC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037B1B

/end MEASUREMENT

/begin MEASUREMENT

    DSMAUX_DTRG.DTRG_NoTrigger
    "Trigger state / Trigger DTRG_NoTrigger"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037B1C

/end MEASUREMENT

/begin MEASUREMENT

    DSMAUX_DTRG.DTRG_Distance100m
    "Trigger state / Trigger DTRG_Distance100m"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037B1D

/end MEASUREMENT

/begin MEASUREMENT

    DSMAUX_DTRG.DTRG_TimeFLCOFFROAD
    "Trigger state / Trigger DTRG_TimeFLCOFFROAD"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037B1E

/end MEASUREMENT

/begin MEASUREMENT

    DSMAUX_stClrProc
    "Statemachine for clear requests"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE7E

/end MEASUREMENT

/begin MEASUREMENT

    DSMAUX_stClrTaskFin
    "End flag for OS_DSM_Clear_Task run"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE7D

/end MEASUREMENT

/begin MEASUREMENT

    DSMAUX_stDCy
    "Status OBD driving cycle"
    UBYTE
    DSMAUX_stDCyVerb
    1
    100
    0.00
    3.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x60037B20

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    DSMAUX_stDCy_msg
    "Status OBD driving cycle"
    UBYTE
    DSMAUX_stDCyVerb
    1
    100
    0.00
    3.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6000C698

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    DSMAUX_stDsmClrActv
    "Indicator of a running DSM clear procedure"
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x1
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6000C7B2

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    DSMAUX_stStrtEnd
    "Condition normal engine operation was attained"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE76

/end MEASUREMENT

/begin MEASUREMENT

    DSMAUX_stTranGlbJob
    "Current transition job"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE80

/end MEASUREMENT

/begin MEASUREMENT

    DSMAUX_stTranGlbRun
    "Transition job is running"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE7F

/end MEASUREMENT

/begin MEASUREMENT

    DSMAUX_stTranReq
    "Queue of transition request"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    MATRIX_DIM 4  
    ECU_ADDRESS 0x60034070

/end MEASUREMENT

/begin MEASUREMENT

    DSMAUX_tClntStrt
    "coolant temperature at start"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000B8EC

/end MEASUREMENT

/begin MEASUREMENT

    DSMDur_ctGlb
    "Global duration counters (32 bit values)"
    ULONG
    DFES_OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    MATRIX_DIM 4  
    ECU_ADDRESS 0x60037B34

/end MEASUREMENT

/begin MEASUREMENT

    DSMDur_ctPID21h
    "counter for distance travelled while MIL is activated"
    ULONG
    DSMDUR_10m_Counter
    1
    100
    0.00
    42949672.9500

    
    FORMAT "%13.4"
    
    ECU_ADDRESS 0x60036E14

/end MEASUREMENT

/begin MEASUREMENT

    DSMDur_ctPID31h
    "counter for distance since diagnostic trouble codes cleared"
    ULONG
    DSMDUR_10m_Counter
    1
    100
    0.00
    42949672.9500

    
    FORMAT "%13.4"
    
    ECU_ADDRESS 0x60036E10

/end MEASUREMENT

/begin MEASUREMENT

    DSMDur_lRef
    "distance when the next DSMDur increment will be counted"
    SLONG
    OneToOne
    1
    100
    -2147483648.00
    2147483647.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x60004BEC

/end MEASUREMENT

/begin MEASUREMENT

    DSMDur_lRef10m
    "distance where next 10m increment will be counted"
    SLONG
    OneToOne
    1
    100
    -2147483648.00
    2147483647.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x60004BE8

/end MEASUREMENT

/begin MEASUREMENT

    DSMDur_stGlb
    "Global duration counter states"
    UBYTE
    DSMDur_StDispl_Verb
    1
    100
    0.00
    2.00000000000

    
    FORMAT "%13.11"
    MATRIX_DIM 4  
    ECU_ADDRESS 0x60037B30

/end MEASUREMENT

/begin MEASUREMENT

    DSMDur_stPID21h
    "state of the counter for distance travelled while MIL is activated"
    UBYTE
    DSMDur_StDispl_Verb
    1
    100
    0.00
    2.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x60037B2F

/end MEASUREMENT

/begin MEASUREMENT

    DSMDur_stWUCLst
    "warm up cycle reached"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60034074

/end MEASUREMENT

/begin MEASUREMENT

    DSMDur_tiRef
    "time when next DSMDur increment will be counted"
    SLONG
    OneToOne
    1
    100
    -2147483648.00
    2147483647.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x60004BE4

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_stGrpRdy
    "Readiness calculation, ready status"
    UWORD
    DSMRdy_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x60037B54

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_stGrpRdyDFES
    "Readiness calculation, ready status from DFES status"
    UWORD
    DSMRdy_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B8F2

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_stGrpRdyScan
    "Readiness calculation, ready status from check scanning"
    UWORD
    DSMRdy_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B8F4

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_stGrpSup
    "Readiness calculation, supported status"
    UWORD
    DSMRdy_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B8F0

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.RdyMisf_mp
    "Reason (name of fault check) / DFC for group Misf not tested since clear"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C320

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.RdyFlSys_mp
    "Reason (name of fault check) / DFC for group FlSys not tested since clear"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C322

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.RdyComprCmpnt_mp
    "Reason (name of fault check) / DFC for group ComprCmpnt not tested since clear"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C324

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.RdyHCCat_mp
    "Reason (name of fault check) / DFC for group HCCat not tested since clear"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C326

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.RdyNOxCat_mp
    "Reason (name of fault check) / DFC for group NOxCat not tested since clear"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C328

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.RdyResv_mp
    "Reason (name of fault check) / DFC for group Resv not tested since clear"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C32A

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.RdyBP_mp
    "Reason (name of fault check) / DFC for group BP not tested since clear"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C32C

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.RdyAC_mp
    "Reason (name of fault check) / DFC for group AC not tested since clear"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C32E

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.RdyEGSens_mp
    "Reason (name of fault check) / DFC for group EGSens not tested since clear"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C330

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.RdyPMFlt_mp
    "Reason (name of fault check) / DFC for group PMFlt not tested since clear"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C332

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.RdyEGR_mp
    "Reason (name of fault check) / DFC for group EGR not tested since clear"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C334

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.CyclCmplMisf_mp
    "Reason (name of fault check) / DFC for group Misf not tested in this cycle"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C336

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.CyclCmplFlSys_mp
    "Reason (name of fault check) / DFC for group FlSys not tested in this cycle"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C338

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.CyclCmplComprCmpnt_mp
    "Reason (name of fault check) / DFC for group ComprCmpnt not tested in this cycle"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C33A

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.CyclCmplHCCat_mp
    "Reason (name of fault check) / DFC for group HCCat not tested in this cycle"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C33C

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.CyclCmplNOxCat_mp
    "Reason (name of fault check) / DFC for group NOxCat not tested in this cycle"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C33E

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.CyclCmplResv_mp
    "Reason (name of fault check) / DFC for group Resv not tested in this cycle"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C340

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.CyclCmplBP_mp
    "Reason (name of fault check) / DFC for group BP not tested in this cycle"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C342

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.CyclCmplAC_mp
    "Reason (name of fault check) / DFC for group AC not tested in this cycle"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C344

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.CyclCmplEGSens_mp
    "Reason (name of fault check) / DFC for group EGSens not tested in this cycle"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C346

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.CyclCmplPMFlt_mp
    "Reason (name of fault check) / DFC for group PMFlt not tested in this cycle"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C348

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.CyclCmplEGR_mp
    "Reason (name of fault check) / DFC for group EGR not tested in this cycle"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C34A

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.LockMisf_mp
    "Reason (name of fault check) / Disabled DFC for group Misf"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C34C

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.LockFlSys_mp
    "Reason (name of fault check) / Disabled DFC for group FlSys"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C34E

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.LockComprCmpnt_mp
    "Reason (name of fault check) / Disabled DFC for group ComprCmpnt"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C350

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.LockHCCat_mp
    "Reason (name of fault check) / Disabled DFC for group HCCat"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C352

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.LockNOxCat_mp
    "Reason (name of fault check) / Disabled DFC for group NOxCat"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C354

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.LockResv_mp
    "Reason (name of fault check) / Disabled DFC for group Resv"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C356

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.LockBP_mp
    "Reason (name of fault check) / Disabled DFC for group BP"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C358

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.LockAC_mp
    "Reason (name of fault check) / Disabled DFC for group AC"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C35A

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.LockEGSens_mp
    "Reason (name of fault check) / Disabled DFC for group EGSens"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C35C

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.LockPMFlt_mp
    "Reason (name of fault check) / Disabled DFC for group PMFlt"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C35E

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.LockEGR_mp
    "Reason (name of fault check) / Disabled DFC for group EGR"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C360

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_xPId1
    "Readiness calculation, result for PID01"
    ULONG
    DSMRdy_OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6000332C

/end MEASUREMENT

/begin MEASUREMENT

    DSM_CoEngtiNormalOBD
    "DSM internal variable to store the copy of the Engine running time - for OBD requirement"
    ULONG
    Time_sec_q1_COMPU
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x60004BD0

/end MEASUREMENT

/begin MEASUREMENT

    DSM_CoEOMstOpModeActTSync
    "DSM internal variable to store the copy of the Diesel Particulate Filter Active Regeneration Status."
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x60004BC8

/end MEASUREMENT

/begin MEASUREMENT

    DSM_CoEOMstOpModePos
    "DSM internal variable to store the copy of the Bit mask of the possible operation modes for the DSM-Scheduler"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B8E8

/end MEASUREMENT

/begin MEASUREMENT

    DSM_CoEOMstTransActv
    "DSM internal variable to store the copy of the Status if an operation mode change is active"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE74

/end MEASUREMENT

/begin MEASUREMENT

    DSM_DisblMode_mp
    "Actual disable mode to prevent error memory entries (provided by DSM configuration)"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x700301B6

/end MEASUREMENT

/begin MEASUREMENT

    DSM_ECUId_mp
    "ECU identifier (e.g. master/slave systems), provided by DSM configuration"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x7003038E

/end MEASUREMENT

/begin MEASUREMENT

    DSM_GlbDalTotDst
    "DSM internal variable to store the copy of the total distance since first start"
    SLONG
    Length
    1
    100
    -2147483648.00
    2147483647.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x60004BCC

/end MEASUREMENT

/begin MEASUREMENT

    DSM_nEng
    ""
    SWORD
    EngN
    1
    100
    -16384.00
    16383.50

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B8EA

/end MEASUREMENT

/begin MEASUREMENT

    DSM_PDTCDisbl_mp
    "Disable state of permanent DTC storage, as long as the value is not zero no permanent DTC will be stored."
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x7003038D

/end MEASUREMENT

/begin MEASUREMENT

    DSM_pEnv
    "DSM internal variable to store the copy of the Environment pressure"
    SWORD
    Pres_hPa
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B8E2

/end MEASUREMENT

/begin MEASUREMENT

    DSM_PthSetstOvrRunCoord
    "DSM internal variable to store the copy of the State of overrun detection of the overrun coordinator (0: no overrun; 1:overrun)"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE73

/end MEASUREMENT

/begin MEASUREMENT

    DSM_rAPP
    "DSM internal variable to store the copy of the Standardized accelerator pedal position"
    SWORD
    Prc
    1
    100
    -400.0000
    399.9878

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0x6000B8E6

/end MEASUREMENT

/begin MEASUREMENT

    DSM_stFadeOut
    ""
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B54C

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    DSM_stMILReqd
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x1
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6000C6B9

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    DSM_stPostDrive
    "Status of DSM postdrive control"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE7B

/end MEASUREMENT

/begin MEASUREMENT

    DSM_stProtdRamVld
    "DFES protected ram content is valid"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60034050

/end MEASUREMENT

/begin MEASUREMENT

    DSM_stReInit
    "Status of reinitialization in DSM after cancelled postdrive"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE7C

/end MEASUREMENT

/begin MEASUREMENT

    DSM_stStrEnd
    "DSM internal variable to store the copy of the engine start finished (provided by DSM configuration)"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE75

/end MEASUREMENT

/begin MEASUREMENT

    DSM_stWiggle_mp
    "wiggle test requested by ext. tester (provided by DSM configuration)"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x7003038C

/end MEASUREMENT

/begin MEASUREMENT

    DSM_tEngDS
    "DSM internal variable to store the copy of the Coolant temperature at engine output"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000B8DE

/end MEASUREMENT

/begin MEASUREMENT

    DSM_tEnv
    "DSM internal variable to store the copy of the Temperature of environment air"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000B8E0

/end MEASUREMENT

/begin MEASUREMENT

    DSM_TripChgAndClrFinshd
    "Message to indicate completion of clear triggered by DSM after initialization"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7AF

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    DSM_TripChgFinshd
    "Trip change of DSM finished"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7AE

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    DSM_vVeh
    "DSM internal variable to store the copy of the Vehicle speed"
    SWORD
    Vel
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0x6000B8E4

/end MEASUREMENT

/begin MEASUREMENT

    DSM_xTabVersion
    "DSM version indentification signature"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C3D2

/end MEASUREMENT

/begin MEASUREMENT

    DSQ_st.DSQ_DSMInhibitAlways
    "Status signal quality / Status of signal quality DSQ_DSMInhibitAlways"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE83

/end MEASUREMENT

/begin MEASUREMENT

    DSQ_st.DSQ_ErrLmpActrMIL
    "Status signal quality / Status of signal quality DSQ_ErrLmpActrMIL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE84

/end MEASUREMENT

/begin MEASUREMENT

    DSQ_st.DSQ_ErrLmpActrSVS
    "Status signal quality / Status of signal quality DSQ_ErrLmpActrSVS"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE85

/end MEASUREMENT

/begin MEASUREMENT

    DSQ_st.DSQ_StopLmp
    "Status signal quality / Status of signal quality DSQ_StopLmp"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE86

/end MEASUREMENT

/begin MEASUREMENT

    DSQ_st.DSQ_T15TurnOfDly
    "Status signal quality / Status of signal quality DSQ_T15TurnOfDly"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE87

/end MEASUREMENT

/begin MEASUREMENT

    DSQ_st.DSQ_WrnLmp
    "Status signal quality / Status of signal quality DSQ_WrnLmp"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE88

/end MEASUREMENT

/begin MEASUREMENT

    DSQ_stClct_mp
    "Collected states of all signal qualities (set if signal quality > 0)"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    MATRIX_DIM 1  
    ECU_ADDRESS 0x700301E8

/end MEASUREMENT

/begin MEASUREMENT

    DTR_valLoLim.DTR_Dummy
    "lower limits (Mode06) / lower limit of diagnostic test result DTR_Dummy"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x60037B4C

/end MEASUREMENT

/begin MEASUREMENT

    DTR_valTst.DTR_Dummy
    "last test value (Mode06) / last test result of DTR_Dummy"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x60037B50

/end MEASUREMENT

/begin MEASUREMENT

    DTR_valUpLim.DTR_Dummy
    "upper limits (Mode06) / upper limit of diagnostic test result DTR_Dummy"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x60037B4E

/end MEASUREMENT

/begin MEASUREMENT

    EcuTemp_dataDigSens
    ""
    SLONG
    TempDiff_1Deg
    1
    100
    -2147483648.00
    2147483647.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x60003390

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Eep_ctAbsCallWrFkt
    "16-bit-counter which counts the function calls to Eep_Write and Eep_Init over all driving cycles"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x60036E18

/end MEASUREMENT

/begin MEASUREMENT

    Eep_ctCallWrFkt
    "Counter which counts the function calls to Eep_Write and Eep_Init during one driving cycle"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6003681C

/end MEASUREMENT

/begin MEASUREMENT

    Eep_ctMaxCallWrFkt
    "Maximum value of Eep_ctCallWrFkt"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x60036E1A

/end MEASUREMENT

/begin MEASUREMENT

    Eep_EnvRamHist
    "History state ENVRAM"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C930

/end MEASUREMENT

/begin MEASUREMENT

    Eep_EnvRamInvld
    "Invalidity state ENVRAM"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C931

/end MEASUREMENT

/begin MEASUREMENT

    Eep_PostdrvBlkIdx_s16
    "Block Index of currently stored block"
    SWORD
    OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B6D6

/end MEASUREMENT

/begin MEASUREMENT

    Eep_stBlk
    "Status array with status of each EEP block"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    MATRIX_DIM 14  
    ECU_ADDRESS 0x6000B6D8

/end MEASUREMENT

/begin MEASUREMENT

    Eep_stMain
    "Main state of EEP"
    SLONG
    Eep_MainStates_Verb
    1
    100
    0.00
    14.0000000000

    
    FORMAT "%13.10"
    
    ECU_ADDRESS 0x600033E8

/end MEASUREMENT

/begin MEASUREMENT

    Eep_stPostDrv
    "Status of EEP process in PostDrive / PreDrive"
    UBYTE
    Eep_PostDrvState_Verb
    1
    100
    0.00
    4.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6000C92E

/end MEASUREMENT

/begin MEASUREMENT

    EngDa_tEng
    "Engine temperature"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000B59A

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    EngDa_tFld
    "Engine temperature field"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    MATRIX_DIM 1  
    ECU_ADDRESS 0x6000B598

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    EngDem_stErr
    "Engine speed in case of a system error of the engine"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C753

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    EnvP_p
    "env. pressure, measured or modelled"
    SWORD
    Pres_hPa
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B596

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    EnvP_p_f
    "Actual physical value"
    FLOAT32_IEEE
    RBPtCel_p_1p0_1
    1
    100
    -1.00000000E+037
    1.00000000E+037

    
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x600033A0

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    EnvT_t
    "Enviroment temperature signal (with replacement reaction in case of sensor error)"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000B594

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    EnvT_t_f
    "envt"
    FLOAT32_IEEE
    RBPtCel_t_1p0_3
    1
    100
    -1.00000000E+037
    1.00000000E+037

    
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000339C

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    EnvT_t_f_Sq
    ""
    UBYTE
    SigQly_COMPU_VERB
    1
    100
    0.00
    15.0000000000

    
    FORMAT "%13.10"
    
    ECU_ADDRESS 0x6000C6AA

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    EnvT_t_Sq
    ""
    UBYTE
    SigQly_COMPU_VERB
    1
    100
    0.00
    15.0000000000

    
    FORMAT "%13.10"
    
    ECU_ADDRESS 0x6000C6AB

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    EnvT_uRaw
    "Sensor signal raw voltage"
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000B592

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    EpmCrS_tiIncPer
    "current tooth-time on crankshaft"
    SLONG
    GptaClc6_ti_COMPU
    1
    100
    -858993459.200
    858993458.800

    
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x600033C4

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Epm_nEng
    "Average engine speed of one cylinder segment"
    SWORD
    EngN
    1
    100
    -16384.00
    16383.50

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B590

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Epm_nEngLRes
    "engine speed with low resolution"
    UBYTE
    EngN_LRes
    1
    100
    0.00
    10200.

    
    FORMAT "%5.0"
    
    ECU_ADDRESS 0x6000C752

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Epm_numCyl
    "Real number of cylinder"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C751

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Epm_stSpd
    "Selection of engine speed"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C750

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Epm_tiSpd2Zero
    "Timeout timer until engine speed will set to zero"
    UWORD
    Time_ms
    1
    100
    0.00
    655350.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0x6000B496

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    ErrLmp_stExtReqRdy
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037C22

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    ErrLmp_stMIL
    "MIL status indicator"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C74F

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    ErrLmp_stMILDigOut
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C74E

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    ErrLmp_stMILDigOut_mp
    "Measuring point for output value for mil-test"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x7003038B

/end MEASUREMENT

/begin MEASUREMENT

    ErrLmp_stMILReq
    "MIL request status"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C74D

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    ErrLmp_stMilReqBlink
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037C25

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    ErrLmp_stMilReqContns
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037C26

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    ErrLmp_stMilReqOnDem
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037C23

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    ErrLmp_stMilReqSho
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037C24

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    ErrLmp_stMIL_b6
    "MIL status indicator bit6"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C74C

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    ErrLmp_stOrdGlwLmp
    "Status of order to glowlamp"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C74B

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    ErrLmp_stSVS
    "SVS Lamp status"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C74A

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    ErrLmp_stSVSDigOut
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C749

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    ErrLmp_stSVSDigOut_mp
    "Measuring point for output value for svs-test"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x7003038A

/end MEASUREMENT

/begin MEASUREMENT

    ErrLmp_stSVSReq
    "SVS request status"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C748

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    ESC_stStackErr
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C672

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Etc_ctCurRunTst
    "Stores the number of actual running engine tests"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C747

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    ExhMod_pRelPfilDs
    "Modelled relative pressure downstream of particulate filter"
    SWORD
    Pres_hPa
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B58E

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    ExhMod_pRelPfilDs_f
    "Modelled relative pressure downstream of particulate filter"
    FLOAT32_IEEE
    RBPtCel_p_1p0_1
    1
    100
    -1.00000000E+037
    1.00000000E+037

    
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x60003398

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Exh_tFld
    "message array for exhaust gas temperature sensor"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    MATRIX_DIM 1  
    ECU_ADDRESS 0x6000B58C

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    FanCtl_stHotLmp
    "FanCtl_Spd"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C746

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    FanCtl_stOk
    "Status defect-free control of KMTR"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6B8

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Fan_r1Ps
    ""
    SWORD
    DtyCyc
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0x6000B58A

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Fan_r2Ps
    ""
    SWORD
    Prc
    1
    100
    -400.0000
    399.9878

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0x6000B588

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Fan_rPs
    "PWM output ratio for fan actuator 1"
    SWORD
    DtyCyc
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0x6000B586

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    FlSys_volFlConsDspl
    "display of the total fuel consumption [ul]"
    SLONG
    FlConsum_ul
    1
    100
    -2147483648.00
    2147483647.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6000338C

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    GEVCtl_flgReqRefAdpnIntk
    "Request of condition: edge adaption camshaft intake"
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x1
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x700000D2

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    GlbDa_lTotDst
    "total distance since first start"
    SLONG
    Length
    1
    100
    -2147483648.00
    2147483647.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x60003388

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    GlbSrvGovrOutpRamp_I.FirstIniFlag
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x1
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x70002AC8

/end MEASUREMENT

/begin MEASUREMENT

    HLSDem_nMaxDspl
    "Maximum engine speed limit for display"
    SWORD
    EngN
    1
    100
    -16384.00
    16383.50

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B584

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    HLSDem_nSetPLo
    "Effective steady-state idle speed"
    SWORD
    EngN
    1
    100
    -16384.00
    16383.50

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B582

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    HLSDem_stNMaxWarnDspl
    "Status active engine speed limitation warning for display"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C745

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    I15031_FILLSIG1
    "Fillsignal for not supported signals with the size of 1 Byte"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C744

/end MEASUREMENT

/begin MEASUREMENT

    I15031_FILLSIG2
    "Fillsignal for not supported signals with the size of 2 Bytes"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B548

/end MEASUREMENT

/begin MEASUREMENT

    I15031_FILLSIG4
    "Fillsignal for not supported signals with the size of 4 Bytes"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x60003378

/end MEASUREMENT

/begin MEASUREMENT

    I15031_ITIDSuppSrv9
    "To store support infotype bits in mode9"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    MATRIX_DIM 8  
    ECU_ADDRESS 0x6000B3CC

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID13
    "Location of oxigen sensor"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C743

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID1C
    "OBD requirements to which vehicle is designed"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C742

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID1D
    "Location of oxygen sensors"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C741

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID4FA
    "External Test Equipment Configuration Information. Maximum value for Equivalence Ratio."
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C740

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID4FB
    "External Test Equipment Configuration Information. Maximum value for Oxygen Sensor Voltage."
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C73F

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID4FC
    "External Test Equipment Configuration Information. Maximum value for Oxygen Sensor Current."
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C73E

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID4FD
    "External Test Equipment Configuration Information. Maximum value for Intake Manifold Absolute Pressure."
    UBYTE
    OneToTenCarb
    1
    100
    0.00
    2550.

    
    FORMAT "%5.0"
    
    ECU_ADDRESS 0x6000C73D

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID50A
    "External Test Equipment Configuration Information. Maximum value for Air Flow Rate from Mass Air Flow Sensor"
    UBYTE
    OneToTenCarb
    1
    100
    0.00
    2550.

    
    FORMAT "%5.0"
    
    ECU_ADDRESS 0x6000C73C

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID50B
    "External Test Equipment Configuration Information. Demanded manifold Pressure"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C73B

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID50C
    "External Test Equipment Configuration Information. Engine Oil Level"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C73A

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID50D
    "External Test Equipment Configuration Information. Fuel Rail pressure control"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C739

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID5F
    "Emission requirements to which vehicle is designed"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C738

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID65A
    "Shows which Auxiliary Inputs / Outputs are supported in PID65"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C737

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID66A
    "Shows which Mass Air Flow Sensor data are supported in PID66"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C736

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID67A
    "Shows which Engine Coolant Temperature data are supported in PID67"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C735

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID68A
    "Shows which Intake Air Temperature Sensor data are supported in PID68"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C734

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID69A
    "Shows which Commanded EGR System data are supported in PID69"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C733

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID6AA
    "Shows which Commanded Diesel Intake Air Flow Control and Relative Intake Air Flow Position data are supported in PID6A"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C732

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID6BA
    "Shows which Exhaust Gas Recirculation Temperature data are supported in PID6B"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C731

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID6CA
    "Shows which Commanded Throttle Actuator Control and Relative Throttle Position data are supported in PID6C"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C730

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID6DA
    "Shows which Fuel Pressure Control System data are supported in PID6D"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C72F

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID6EA
    "Shows which Injection Pressure Control System data are supported in PID6E"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C72E

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID6FA
    "Shows which Turbocharger Compressor Inlet Pressure data are supported in PID6F"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C72D

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID70A
    "Shows which Boost Pressure Control data are supported in PID70"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C72C

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID71A
    "Shows which Variable Geometry Turbo (VGT) Control data are supported in PID71"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C72B

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID72A
    "Shows which Wastegate Control data are supported in PID72"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C72A

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID73A
    "Shows which Exhaust Pressure data are supported in PID73"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C729

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID74A
    "Shows which Turbocharger RPM data are supported in PID74"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C728

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID75A
    "Shows which Turbocharger A Temperature data are supported in PID75"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C727

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID76A
    "Shows which Turbocharger B Temperature data are supported in PID76"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C726

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID77A
    "Shows which Charge Air Cooler Temperature (CACT) data are supported in PID77"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C725

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID78A
    "Shows which Exhaust Gas Temperature (EGT) Bank 1 data are supported in PID78"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C724

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID79A
    "Shows which Exhaust Gas Temperature (EGT) Bank 2 data are supported in PID79"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C723

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID7AA
    "Shows which Particulate Filter (PF) Bank 1 data are supported in PID7A"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C722

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID7BA
    "Shows which Particulate Filter (PF) Bank 2 data are supported in PID7B"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C721

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID7CA
    "Shows which Particulate Filter (PF) Temperature data are supported in PID7C"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C720

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID7FA
    "Shows which Engine Run Time is supported in PID7F"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C71F

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID81A
    "Shows which Engine Run Time for AECD #1 - #5 is supported in PID81"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C71E

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID82A
    "Shows which Engine Run Time for AECD #6 - #10 is supported in PID82"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C71D

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID83A
    "Shows which NOx Sensor data are supported in PID83"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C71C

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID85A
    "Shows which NOx Control System data are supported in PID85"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C71B

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID86A
    "Shows which Particulate Matter (PM) Sensor data are supported in PID86"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C71A

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID87A
    "Shows which Intake Manifold Absolute Pressure data are supported in PID87"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C719

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID89A
    "Shows which Engine Run Time for AECD #11 - #15 is supported in PID89"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C718

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID8AA
    "Shows which Engine Run Time for AECD #16 - #20 is supported in PID8A"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C717

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID8BA
    "Shows which Aftertreatment Status is supported in PID8B ByteB."
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C716

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID8CA
    "Calibration for O2 Sensor Data support information(Sensor 1, Sensor 2)"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C715

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID8FA
    "Shows which PM (Particulate Matter) Sensor Output is supported in PID8F"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C714

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID92A
    "Fuel System Status support information"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C713

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID93A
    "WWH B1 counter support information"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C712

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID94A
    "Inducement Counters support information"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C711

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID97A
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C710

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID98A
    "Exhaust Gas Temperature Sensor Data support information(Bank 1)"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C70F

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID99A
    "Exhaust Gas Temperature Sensor Data support information"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C70E

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID9AA
    "Shows if HybridEV Vehicle State is supported in PID9A"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C70D

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID9BA
    "Diesel exhaust fluid sensor output"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C70C

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID9CA
    "O2 Sensor Data support information(Sensor 3, Sensor 4)"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C70B

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID9FA
    "Fuel system percentage use"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C70A

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PIDA1A
    "Displays the NOx Sensor Corrected Data supported in PIDA1"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C709

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PIDA3A
    "Evap System Vapor Pressure"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C708

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PIDA4A
    "Transmission Actual Gear"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C707

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PIDA5A
    "message to update byte A ini PIDA5 for Diesel Exhaust Fluid Dosing"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C706

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PIDA7A
    "Support of NOx Sensor Data"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C705

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PIDA8A
    "NOx Sensor Corrected"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C704

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PIDA9A
    "Motorcycle InputOutput Status"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C703

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PIDACA
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C702

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PIDSuppSrv1
    "PIDs supported in Service 1 are indicated in 32 bit measurement array"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    MATRIX_DIM 8  
    ECU_ADDRESS 0x6000B3AC

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PIDSuppSrv2
    "PIDs supported in Service 2 are indicated in 32 bit measurement array"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    MATRIX_DIM 8  
    ECU_ADDRESS 0x6000B38C

/end MEASUREMENT

/begin MEASUREMENT

    I15031_Srv12_Ext_DisablPIDSupp
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    MATRIX_DIM 8  
    ECU_ADDRESS 0x6000B36C

/end MEASUREMENT

/begin MEASUREMENT

    i15031_srv9_CVN_Calc_ui
    "State of CVN calculation"
    UBYTE
    I15031_srv9_CVN_CalcVerb
    1
    100
    0.00
    6.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C6D2

/end MEASUREMENT

/begin MEASUREMENT

    I15031_srv9_stCVNRecalc
    "Recalculation of CVN"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C700

/end MEASUREMENT

/begin MEASUREMENT

    I15031_srv9_ValidCVN
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C701

/end MEASUREMENT

/begin MEASUREMENT

    i15031_srv9_vt_ASWFrzStatus
    "Storage of freeze status in envram"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037C84

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    I15301_srv9_vt_stStorgFlsgPers_msg
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7B0

/end MEASUREMENT

/begin MEASUREMENT

    InjCtl_qSetUnBal
    "current injection quantity"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0x6000B580

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    LLim_stMaxActvLvlECU
    "demand from Lvl ECU for speed limiting"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6FF

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_bPFCNew
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x2
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6001C970

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_bSwShrNew
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x10
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6001C970

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_cntrInCorrRespTime
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CB48

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_cntrSyncMonModl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CB47

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_cntrWDAErrThd
    ""
    UBYTE
    OneToOne
    1
    100
    3.000
    4.000

    
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x6001CB36

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_cntrWDAErrThdCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CB46

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_cntrWDAErrThdMsg
    ""
    UBYTE
    dez
    1
    100
    3.000
    4.000

    
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x70002AEE

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_ctBusErr
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CB45

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_ctBusErrCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CB44

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_ctErrFC
    "error counter for failure in function controller"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CB35

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_ctErrFCCpl
    "RAM data redundancy for MoCCom_ctErrFC"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CB43

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_ctErrMM
    "error counter of monitoring module"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CB34

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_ctErrMMMsg
    "info for level 1: error counter of monitoring module"
    UBYTE
    dez
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x70002AED

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_ctErrMMOld
    "old value of the error count got from the monitoring module"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CB42

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_ctErrOSTimeout
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CB41

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_Query
    "Enlarged query from monitoring module"
    ULONG
    dez
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CB2C

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_Response
    "Response to the query from monitoring module"
    ULONG
    dez
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CB30

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_Response_mp
    ""
    ULONG
    dez
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x70030130

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_stBusErr
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CB40

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_stCheckState
    ""
    UBYTE
    MoCCom_stCheckState_Compu
    1
    100
    0.00
    7.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6001CB3F

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_stCheckStateCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CB3E

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_stComActvOld
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CB3D

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_stComActvOldCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CB3C

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_stComState
    ""
    UBYTE
    MoCCom_stComState_Compu
    1
    100
    0.00
    2.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6001CB3B

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_stErrEna
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CB3A

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_stErrEnaCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CB39

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_stQueryNew
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001C970

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_stWdgThdErr
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CB38

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_stWdgTiWinErr
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CB37

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_SwShrPtlResp
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CB28

/end MEASUREMENT

/begin MEASUREMENT

    MoCCPU_PartResp
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CB24

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCEMM_idxNumCurrErr
    ""
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6001C96E

/end MEASUREMENT

/begin MEASUREMENT

    MoCEMM_stEmmAlrms
    ""
    ULONG
    dez
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    MATRIX_DIM 22  
    ECU_ADDRESS 0x6001CCE0

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCEMM_stEmmAlrmsCpl
    ""
    ULONG
    dez
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    MATRIX_DIM 22  
    ECU_ADDRESS 0x6001CAC8

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCEMM_stEmmAlrmsMsg
    ""
    ULONG
    dez
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    MATRIX_DIM 22  
    ECU_ADDRESS 0x70002AF4

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCEMM_stEmmAlrmsNv
    ""
    ULONG
    dez
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    MATRIX_DIM 22  
    ECU_ADDRESS 0x60037C2C

/end MEASUREMENT

/begin MEASUREMENT

    MoCEMM_stEmmErrorPin
    ""
    UBYTE
    dez
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CD38

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCEMM_stEmmErrorPinCpl
    ""
    UBYTE
    dez
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CB23

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCEMM_stEmmGPIO
    ""
    UBYTE
    dez
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CB22

/end MEASUREMENT

/begin MEASUREMENT

    MoCEMM_stPwrOnRstHdl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CD3A

/end MEASUREMENT

/begin MEASUREMENT

    MoCEMM_stPwrOnRstHdlCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CB21

/end MEASUREMENT

/begin MEASUREMENT

    MoCEMM_stPwrOnRstReq
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CD39

/end MEASUREMENT

/begin MEASUREMENT

    MoCEMM_stPwrOnRstReqCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CB20

/end MEASUREMENT

/begin MEASUREMENT

    MoCEMM_structCurrReq.MoCEMM_cntrInfo
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x70002C18

/end MEASUREMENT

/begin MEASUREMENT

    MoCEMM_structCurrReq.MoCEMM_blkInfo
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    MATRIX_DIM 17  
    ECU_ADDRESS 0x70002C1C

/end MEASUREMENT

/begin MEASUREMENT

    MoCEMM_structCurrReq.MoCEMM_cntrInfoCpl
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x70002CC0

/end MEASUREMENT

/begin MEASUREMENT

    MoCEMM_structFlash.MoCEMM_cntrInfo
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x70002B6C

/end MEASUREMENT

/begin MEASUREMENT

    MoCEMM_structFlash.MoCEMM_blkInfo
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    MATRIX_DIM 41  
    ECU_ADDRESS 0x70002B70

/end MEASUREMENT

/begin MEASUREMENT

    MoCEMM_structFlash.MoCEMM_cntrInfoCpl
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x70002C14

/end MEASUREMENT

/begin MEASUREMENT

    MoCEMM_stSWErrorPinReqAry
    ""
    ULONG
    MoExe_Co_PFC_ID_Compu
    1
    100
    0.00
    16777471.0000

    
    FORMAT "%13.4"
    MATRIX_DIM 10  
    ECU_ADDRESS 0x70039BD4

/end MEASUREMENT

/begin MEASUREMENT

    MoCEMM_stSWErrorPinReqAryCpl
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    MATRIX_DIM 10  
    ECU_ADDRESS 0x70039BAC

/end MEASUREMENT

/begin MEASUREMENT

    MoCEMM_wdgTout
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x70039BA8

/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_aryCMPErrBit
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    MATRIX_DIM 4  
    ECU_ADDRESS 0x6001CCD9

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_aryCMPErrBitCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    MATRIX_DIM 4  
    ECU_ADDRESS 0x6001CAC3

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_bbOut1
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CCCC

/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_bbOut1Cpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CAC2

/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_cmpErrAryIdx
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CCD8

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_cmpErrAryIdxCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CAC1

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_cntrBadcase
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CCC8

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_cntrCMPErrbit
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CCC4

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_cntrCMPErrbitCpl
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CAB8

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_cntrCMPErrbitHeal
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CCD7

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_cntrCMPErrbitHealCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CAC0

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_cntrDebErr
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CCD6

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_cntrDebErrCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CABF

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_cntrDebErrMax
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CABE

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_cntrMCS1
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CCC0

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_cntrMCS1Old
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CCBC

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_cntrMCS1OldCpl
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CAB4

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_cntrMCS2
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CCB8

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_cntrMCS2Old
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CCB4

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_cntrMCS2OldCpl
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CAB0

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_cntrMsmCMPErrBit
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CCD5

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_cntrRouteSigErr
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CCD4

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_cntrRouteSigErrCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CABD

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_currChksVal
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CCB0

/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_currChksValCpl
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CAAC

/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_currMCSModlAryIdx
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CCD3

/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_flgCmpErr
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x1
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6001CCCC

/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_McsData_ptr1Cpl
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CAA8

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_McsData_ptr2Cpl
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CAA4

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_numMCS1Ch
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CCD2

/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_numMCS1Modl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CCD1

/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_numMCS2Ch
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CCD0

/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_numMCS2Modl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CCCF

/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_PtlResp
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CA94

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_PtlRespCpl
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CAA0

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_stBadcaseTrig
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CCAC

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_stErr
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CCCE

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_stErrChks
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CCCD

/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_stErrCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CABC

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_tiCurrMCSVal
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CCA8

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_tiCurrTskcall
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CA9C

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_tiExeMCS1_MP
    ""
    ULONG
    RBPtCel_ti_0p4_1
    1
    100
    0.00
    1717986918.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x7003012C

/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_tiExeMCS2_MP
    ""
    ULONG
    RBPtCel_ti_0p4_1
    1
    100
    0.00
    1717986918.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x70030128

/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_tiFallEdgeBadcase_MP
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x70030124

/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_tiFallEdgeMCS1_MP
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x70030120

/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_tiFallEdgeMCS2_MP
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x7003011C

/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_tiMCSTIMRead
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CCA4

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_tiPrevMCS1Trig_MP
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x70030118

/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_tiPrevMCS2Trig_MP
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x70030114

/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_tiPrevTskcall
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CA98

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_tiRisngEdgeMCS1_MP
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x70030110

/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_tiRisngEdgeMCS2_MP
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x7003010C

/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_tiTskCalldst_MP
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x70030108

/end MEASUREMENT

/begin MEASUREMENT

    MoCHwLogicTest_flgAlvTestChk
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x8
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6001C96C

/end MEASUREMENT

/begin MEASUREMENT

    MoCHwLogicTest_flgFwChk
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x1
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6001C96C

/end MEASUREMENT

/begin MEASUREMENT

    MoCHwLogicTest_flgMONBISTChk
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x2
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6001C96C

/end MEASUREMENT

/begin MEASUREMENT

    MoCHwLogicTest_flgSFFDChk
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x4
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6001C96C

/end MEASUREMENT

/begin MEASUREMENT

    MoCHwLogicTest_flgTempChk
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x10
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6001C96C

/end MEASUREMENT

/begin MEASUREMENT

    MoCHwLogicTest_flgUCBErrChk
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x20
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6001C96C

/end MEASUREMENT

/begin MEASUREMENT

    MoCHwLogicTest_PtlResp
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001C968

/end MEASUREMENT

/begin MEASUREMENT

    MoCHwLogicTest_stErr
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001C96C

/end MEASUREMENT

/begin MEASUREMENT

    MoCIWDH_bbLoc1
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CCA2

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCIWDH_bbLoc1Cpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CA90

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCIWDH_cntChksAry
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    MATRIX_DIM 1  
    ECU_ADDRESS 0x6001CCA1

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCIWDH_cntrRollgAry
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    MATRIX_DIM 1  
    ECU_ADDRESS 0x6001CC9C

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCIWDH_cntrRollgAryCpl
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    MATRIX_DIM 1  
    ECU_ADDRESS 0x6001CA8C

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCIWDH_flgConcatValErr
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x1
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6001CCA2

/end MEASUREMENT

/begin MEASUREMENT

    MoCIWDH_numChksAry
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    MATRIX_DIM 1  
    ECU_ADDRESS 0x6001CC98

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCIWDH_numConcatValAry
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    MATRIX_DIM 1  
    ECU_ADDRESS 0x6001CC94

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCIWDH_PtlResp
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CA84

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCIWDH_PtlRespCpl
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CA88

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCIWDH_stErrAry
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    MATRIX_DIM 1  
    ECU_ADDRESS 0x6001CCA0

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCMemStrtUp_adrEccErr
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x70039B94

/end MEASUREMENT

/begin MEASUREMENT

    MoCMemStrtUp_chkRamTest
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x70039BA5

/end MEASUREMENT

/begin MEASUREMENT

    MoCMemStrtUp_chkRomTest
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x70039BA4

/end MEASUREMENT

/begin MEASUREMENT

    MoCMemStrtUp_tiRamChk
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x70039BA0

/end MEASUREMENT

/begin MEASUREMENT

    MoCMemStrtUp_tiRomChk
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x70039B9C

/end MEASUREMENT

/begin MEASUREMENT

    MoCMemStrtUp_toutWdg
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x70039B98

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_adChkSumBlk
    ""
    ULONG
    dez
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    MATRIX_DIM 2  
    ECU_ADDRESS 0x6001C960

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_adChkSumBlkCpl
    ""
    ULONG
    dez
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    MATRIX_DIM 2  
    ECU_ADDRESS 0x6001CA74

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_ctDebErrChkROM
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CC91

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_ctDebErrChkROMCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CA80

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_ctDebHealChkROM
    ""
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6001CC70

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_ctDebHealChkROMCpl
    ""
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6001CA5C

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_ctLrnROM
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CC90

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_ctLrnROMCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CA7F

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_idxCSAry
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CC8F

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_idxCSAryCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CA7E

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_nrRomChk
    ""
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    MATRIX_DIM 1  
    ECU_ADDRESS 0x6001CC6E

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_nrRomChkCpl
    ""
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    MATRIX_DIM 1  
    ECU_ADDRESS 0x6001CA5A

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_nrRomChkSize
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CC88

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_numChkSumCurrent
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CC84

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_numChkSumCurrentCpl
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CA70

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_RomCurrentPtr
    ""
    ULONG
    default
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CC80

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_RomCurrentPtrCpl
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CA6C

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_stDataCycChkBlk
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    MATRIX_DIM 2  
    ECU_ADDRESS 0x6001CC8D

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_stDataCycChkBlkCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    MATRIX_DIM 2  
    ECU_ADDRESS 0x6001CA7C

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_stDisChk
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CC8C

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_tiROMAccus
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CC7C

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_tiROMAccusCpl
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CA68

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_tiROMus
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CC78

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_tiROMusCpl
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CA64

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_tiROMusOld
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CC74

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_tiROMusOldCpl
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CA60

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_vblStructCpl_Core1_10ms_Nr1.MoCMem_ctDebErrChkRAMOld
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CB98

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_vblStructCpl_Core1_10ms_Nr1.MoCMem_ctDebErrChkRAMCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CB99

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_vblStructCpl_Core1_10ms_Nr1.MoCMem_ctDebHealChkRAMCpl
    ""
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6001CB9A

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_vblStructCpl_Core1_10ms_Nr1.MoCMem_nrRamChkCpl
    ""
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6001CB9C

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_vblStructCpl_Core1_10ms_Nr1.MoCMem_nrStckChkCpl
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CBA0

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_vblStructCpl_Core1_10ms_Nr1.MoCMem_nrCSAChkCpl
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CBA4

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_vblStructCpl_Core1_10ms_Nr1.MoCMem_RamOffsetPtrCpl
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CBA8

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_vblStructCpl_Core1_10ms_Nr1.MoCMem_CSAOffsetPtrCpl
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CBB0

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_vblStructCpl_Core1_10ms_Nr1.MoCMem_StckOffsetPtrCpl
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CBAC

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_vblStructCpl_Core1_10ms_Nr1.Mo_RamCyclicCheckCpl
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CBB4

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_vblStructCpl_Core1_10ms_Nr1.MoCMem_ctLrnRAMCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CBB8

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_vblStructCpl_Core1_10ms_Nr1.MoCMem_tiRAMusOldCpl
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CBBC

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_vblStructCpl_Core1_10ms_Nr1.MoCMem_tiRAMAccusCpl
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CBC4

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_vblStructCpl_Core1_10ms_Nr1.MoCMem_tiRAMusCpl
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CBC0

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_vblStructCpl_Core1_10ms_Nr1.MoCMem_ctLrnErrHdlrCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CBC8

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_vblStructCpl_Core1_10ms_Nr1.MoCMem_tiErrHdlrusOldCpl
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CBD0

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_vblStructCpl_Core1_10ms_Nr1.MoCMem_tiErrHdlrusCpl
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CBCC

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_vblStructCpl_Core1_10ms_Nr1.MoCMem_tiErrHdlrAccusCpl
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CBD4

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_vblStructCpl_Core1_10ms_Nr1.MoCMem_numHealFacCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CBD8

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_vblStructEarlyClearedRAM_Core1_10ms_Nr1.MoCMem_st
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x70039B92

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_vblStructEarlyClearedRAM_Core1_10ms_Nr1.MoCMem_stCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x70039B93

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_vblStructNVRAM_Core1_10ms_Nr1.MoCMem_ctDebErrChkRAMMaxNv
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037C90

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_vblStructNVRAM_Core1_10ms_Nr1.MoCMem_ctDebErrChkRAMExcddThdNv
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037C91

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_vblStruct_Core1_10ms_Nr1.MoCMem_ctDebErrChkRAM
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001D0B4

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_vblStruct_Core1_10ms_Nr1.MoCMem_ctDebHealChkRAM
    ""
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6001D0B6

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_vblStruct_Core1_10ms_Nr1.MoCMem_nrRamChkSize
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001D0B8

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_vblStruct_Core1_10ms_Nr1.MoCMem_adrChkStckEnd
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001D0C0

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_vblStruct_Core1_10ms_Nr1.MoCMem_adrChkStckStrt
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001D0BC

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_vblStruct_Core1_10ms_Nr1.MoCMem_adrChkCSAStrt
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001D0C4

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_vblStruct_Core1_10ms_Nr1.MoCMem_adrChkCSAEnd
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001D0C8

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_vblStruct_Core1_10ms_Nr1.MoCMem_nrRamChk
    ""
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6001D0CC

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_vblStruct_Core1_10ms_Nr1.MoCMem_nrStckChk
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001D0D0

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_vblStruct_Core1_10ms_Nr1.MoCMem_nrCSAChk
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001D0D4

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_vblStruct_Core1_10ms_Nr1.MoCMem_StckOffsetPtr
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001D0D8

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_vblStruct_Core1_10ms_Nr1.MoCMem_CSAOffsetPtr
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001D0DC

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_vblStruct_Core1_10ms_Nr1.MoCMem_adrChkStckSP
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001D0E0

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_vblStruct_Core1_10ms_Nr1.MoCMem_RamOffsetPtr
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001D0E4

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_vblStruct_Core1_10ms_Nr1.MoCMem_ChkRAMStck
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    MATRIX_DIM 80  
    ECU_ADDRESS 0x6001D0E8

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_vblStruct_Core1_10ms_Nr1.MoCMem_ctLrnRAM
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001D228

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_vblStruct_Core1_10ms_Nr1.MoCMem_tiRAMus
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001D230

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_vblStruct_Core1_10ms_Nr1.MoCMem_tiRAMusOld
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001D22C

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_vblStruct_Core1_10ms_Nr1.MoCMem_tiRAMAccus
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001D234

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_vblStruct_Core1_10ms_Nr1.MoCMem_ctLrnErrHdlr
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001D238

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_vblStruct_Core1_10ms_Nr1.MoCMem_tiErrHdlrusOld
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001D23C

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_vblStruct_Core1_10ms_Nr1.MoCMem_tiErrHdlrus
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001D240

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_vblStruct_Core1_10ms_Nr1.MoCMem_tiErrHdlrAccus
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001D244

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_vblStruct_Core1_10ms_Nr1.MoCMem_numHealFac
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001D248

/end MEASUREMENT

/begin MEASUREMENT

    MoCPFC_Checksum
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CA50

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCPFC_Checkword
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CA54

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCPFC_Counter
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CA58

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCPFC_PtlResp
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CA4C

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCPFC_vblStructCpl_Core1_10ms_Nr1.MoCPFC_cntr
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CB64

/end MEASUREMENT

/begin MEASUREMENT

    MoCPFC_vblStructCpl_Core1_10ms_Nr1.MoCPFC_numChkword
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CB68

/end MEASUREMENT

/begin MEASUREMENT

    MoCPFC_vblStructCpl_Core1_10ms_Nr1.MoCPFC_numChks
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CB6C

/end MEASUREMENT

/begin MEASUREMENT

    MoCPFC_vblStructCpl_Core1_10ms_Nr1.MoCPFC_numConCatVal
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CB70

/end MEASUREMENT

/begin MEASUREMENT

    MoCPFC_vblStructCpl_Core1_10ms_Nr1.MoCPFC_cntrRollg
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CB74

/end MEASUREMENT

/begin MEASUREMENT

    MoCPFC_vblStructCpl_Core1_10ms_Nr1.MoCPFC_aryRingBuf
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    MATRIX_DIM 3  
    ECU_ADDRESS 0x6001CB78

/end MEASUREMENT

/begin MEASUREMENT

    MoCPFC_vblStructCpl_Core1_10ms_Nr1.MoCPFC_stWrErr
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CB84

/end MEASUREMENT

/begin MEASUREMENT

    MoCPFC_vblStructCpl_Core1_10ms_Nr1.MoCPFC_RingBuf_pst.startAdr
    ""
    ULONG
    default
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CB88

/end MEASUREMENT

/begin MEASUREMENT

    MoCPFC_vblStructCpl_Core1_10ms_Nr1.MoCPFC_RingBuf_pst.size
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CB8C

/end MEASUREMENT

/begin MEASUREMENT

    MoCPFC_vblStructCpl_Core1_10ms_Nr1.MoCPFC_RingBuf_pst.head
    ""
    ULONG
    default
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CB90

/end MEASUREMENT

/begin MEASUREMENT

    MoCPFC_vblStructCpl_Core1_10ms_Nr1.MoCPFC_RingBuf_pst.tail
    ""
    ULONG
    default
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CB94

/end MEASUREMENT

/begin MEASUREMENT

    MoCSCC_stLfastWrkarndActv_MP
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x70030389

/end MEASUREMENT

/begin MEASUREMENT

    MoCSCC_stMstInstFnd
    ""
    ULONG
    dez
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x60003328

/end MEASUREMENT

/begin MEASUREMENT

    MoCSCC_varStructCpl_Core1_10ms_Nr1.MoCSCC_stChpIdCpl
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CB5C

/end MEASUREMENT

/begin MEASUREMENT

    MoCSCC_varStructCpl_Core1_10ms_Nr1.MoCSCC_cntrDebCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CB60

/end MEASUREMENT

/begin MEASUREMENT

    MoCSCC_varStructCpl_Core1_10ms_Nr1.MoCSCC_stTrmDevCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CB61

/end MEASUREMENT

/begin MEASUREMENT

    MoCSCC_varStructNVRAM_Core1_10ms_Nr1.MoCSCC_cntrDebMaxNv
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037C8C

/end MEASUREMENT

/begin MEASUREMENT

    MoCSCC_varStructNVRAM_Core1_10ms_Nr1.MoCSCC_cntrDebExcddThdNv
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037C8D

/end MEASUREMENT

/begin MEASUREMENT

    MoCSCC_varStructNVRAM_Core1_10ms_Nr1.MoCSCC_cntrDebOld
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037C8E

/end MEASUREMENT

/begin MEASUREMENT

    MoCSCC_varStruct_Core1_10ms_Nr1.MoCSCC_stErr
    ""
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6001D0A4

/end MEASUREMENT

/begin MEASUREMENT

    MoCSCC_varStruct_Core1_10ms_Nr1.MoCSCC_cntrDeb
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001D0A6

/end MEASUREMENT

/begin MEASUREMENT

    MoCSCC_varStruct_Core1_10ms_Nr1.MoCSCC_stTrmDev
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001D0A7

/end MEASUREMENT

/begin MEASUREMENT

    MoCSCC_varStruct_Core1_10ms_Nr1.MoCSCC_stChpId
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001D0A8

/end MEASUREMENT

/begin MEASUREMENT

    MoCSCC_varStruct_Core1_10ms_Nr1.MoCSCC_stRGDChkMPU0
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001D0AC

/end MEASUREMENT

/begin MEASUREMENT

    MoCSCC_varStruct_Core1_10ms_Nr1.MoCSCC_stRGDChkMPU1
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001D0B0

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_aryCtrlLinesDia[0].MoCSOP_stCurrState
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CA00

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_aryCtrlLinesDia[0].MoCSOP_cntrDebDia
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CA04

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_aryCtrlLinesDia[1].MoCSOP_stCurrState
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CA08

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_aryCtrlLinesDia[1].MoCSOP_cntrDebDia
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CA0C

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_aryFeedbackLinesDia[0].MoCSOP_stCurrState
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001C9D0

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_aryFeedbackLinesDia[0].MoCSOP_cntrDebDia
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001C9D4

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_aryFeedbackLinesDia[1].MoCSOP_stCurrState
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001C9D8

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_aryFeedbackLinesDia[1].MoCSOP_cntrDebDia
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001C9DC

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_aryFeedbackLinesDia[2].MoCSOP_stCurrState
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001C9E0

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_aryFeedbackLinesDia[2].MoCSOP_cntrDebDia
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001C9E4

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_aryFeedbackLinesDia[3].MoCSOP_stCurrState
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001C9E8

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_aryFeedbackLinesDia[3].MoCSOP_cntrDebDia
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001C9EC

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_aryFeedbackLinesDia[4].MoCSOP_stCurrState
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001C9F0

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_aryFeedbackLinesDia[4].MoCSOP_cntrDebDia
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001C9F4

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_aryFeedbackLinesDia[5].MoCSOP_stCurrState
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001C9F8

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_aryFeedbackLinesDia[5].MoCSOP_cntrDebDia
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001C9FC

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_aryInhbLinesDia[0].MoCSOP_stCurrState
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001C9B8

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_aryInhbLinesDia[0].MoCSOP_cntrDebDia
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001C9BC

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_aryInhbLinesDia[1].MoCSOP_stCurrState
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001C9C0

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_aryInhbLinesDia[1].MoCSOP_cntrDebDia
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001C9C4

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_aryInhbLinesDia[2].MoCSOP_stCurrState
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001C9C8

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_aryInhbLinesDia[2].MoCSOP_cntrDebDia
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001C9CC

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_cntrBusErrInhbLine
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CC6D

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_cntrBusErrInhbLineCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CA48

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_cntrDebCtrlLinesActv
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CA47

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_cntrDebCtrlLinesActvCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CA46

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_cntrDebErrPinActv
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CA45

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_cntrDebErrPinActvCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CA44

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_cntrDebExtErrPinEveActv
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CA43

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_cntrDebExtErrPinEveActvCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CA42

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_cntrDebExtErrPinEveActv_MP
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    MATRIX_DIM 25  
    ECU_ADDRESS 0x70030370

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_cntrDebInhbLinePlausyChk
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CA41

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_cntrDebInhbLinePlausyChkCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CA40

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_cntrDebSycDrv
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CA3F

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_cntrDebSycDrvCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CA3E

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_cntrSignalSwtDelay
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CA3D

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_cntrSignalSwtDelayCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CA3C

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_ctBusErr
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CA3B

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_ctBusErr_MP
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    MATRIX_DIM 25  
    ECU_ADDRESS 0x70030357

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_ctDebSOPTst
    ""
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6001CA16

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_ctDebSOPTstCpl
    ""
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6001CA14

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_ctErrMM
    "Copy of the error counter from the monitoring module in function controller"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CA1D

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_ctErrMM_mp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    MATRIX_DIM 25  
    ECU_ADDRESS 0x7003033E

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_ctErrOSTimeout
    "error counter handling Alarm Task period"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CA3A

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_ctIdx
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CA39

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_ctRespOffsetTst
    ""
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6001CA12

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_ctRst
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036D07

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_ctRstCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036D06

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_flgABEStatus10ms
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x1
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6001CA38

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_flgErrPinActvd
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CA37

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_flgErrPinActvdCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CA36

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_flgReqSOPTest
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CC6C

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_flgReqSOPTestCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CA35

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_flgT15RisngEdge
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CC6B

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_flgT15RisngEdgeCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CA34

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_st
    ""
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x60036CFE

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_stActMsg
    "copy of the status variable for synchronizing shut off path test and query-/response communication"
    UBYTE
    dez
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x70002AEC

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_stActvMsg
    "Information for level 1, 2: Shut-off path test is on or WDA-line is active (injections disabled)"
    UBYTE
    dez
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x70002AEB

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_stBusErr
    ""
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6001CA10

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_stBusErr_MP
    ""
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    MATRIX_DIM 25  
    ECU_ADDRESS 0x70030184

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_stCheckState
    ""
    UBYTE
    MoCSOP_stCheckStateCtrlline_mp_Compu
    1
    100
    0.00
    14.0000000000

    
    FORMAT "%13.10"
    
    ECU_ADDRESS 0x6001CA33

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_stCheckStateCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CA32

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_stCheckState_mp
    ""
    UBYTE
    MoCSOP_stCheckStateCtrlline_mp_Compu
    1
    100
    0.00
    14.0000000000

    
    FORMAT "%13.10"
    MATRIX_DIM 25  
    ECU_ADDRESS 0x70030325

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_stComActv
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CA1C

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_stComActvCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CA1B

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_stCpl
    ""
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x60036D00

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_stCtrlLineUnderTest
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CA31

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_stDia
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CA30

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_stDiaCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CA2F

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_stEmmState_MP
    ""
    UBYTE
    MoCSOP_stEmmStateIFX_MP_Compu
    1
    100
    0.00
    32.0000000000

    
    FORMAT "%13.10"
    MATRIX_DIM 25  
    ECU_ADDRESS 0x7003030C

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_stErr
    "contains the state of the communication via SPI-subsystem to the monitoring module"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CA2E

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_stErrPinActvnReq
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CA2D

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_stErrPin_MP
    ""
    UBYTE
    MoCSOP_stErrPin_MP_Compu
    1
    100
    0.00
    1.00000000000

    
    FORMAT "%13.11"
    MATRIX_DIM 25  
    ECU_ADDRESS 0x700302F3

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_stErrReactn
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CA2C

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_stInhbLine
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CA2B

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_stInhbLine10ms
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CC68

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_stInhbLine10msCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CA2A

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_stInhbLineCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CA29

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_stInhbLineStatus
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036D05

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_stInhbLineStatusCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036D04

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_stInhbStrtCdn
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CC6A

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_stOvl
    ""
    UBYTE
    dez
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x70002AEA

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_stOvlCpl
    ""
    UBYTE
    dez
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x70002AE9

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_stOVTstStatusEval
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CA28

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_stOVTstStatusEvalCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CA27

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_stPVMTUnderTest
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CA26

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_stRdy
    "Status variable for synchronisation from shut-off path test and query/response communication (test is done completely)"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036D03

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_stRdyCan
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CA1A

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_stRdyCanCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CA25

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_stRdyCpl
    "Double storage for status variable for synchronisation from shut-off path test and query/response communication"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036D02

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_stRdyFr
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CA19

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_stRdyFrCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CA24

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_stRdyInj
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CA18

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_stRdyInjCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CA23

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_stRdyMsg
    "information for level 1,2 about status of synchronizing shut off path test and query-/resonse-communication"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6FC

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_stReqPSStatus
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CA22

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_stReqPSStatusBusErr
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CA21

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_stReqSOPTest
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CA20

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_stReqSOPTestCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CA1F

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_stT15Old
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CC69

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_stT15OldCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CA1E

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoExe_ctCyc
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CC67

/end MEASUREMENT

/begin MEASUREMENT

    MoExe_ctCycCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001C9B7

/end MEASUREMENT

/begin MEASUREMENT

    MoExe_varStructCpl_Core1_10ms_Nr1.MoExe_ctCycCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CB58

/end MEASUREMENT

/begin MEASUREMENT

    MoExe_varStruct_Core1_10ms_Nr1.MoExe_ctCyc
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001D0A1

/end MEASUREMENT

/begin MEASUREMENT

    MoFTrqPtd_cntrActvPostBldCfg
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CC66

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoFTrqPtd_cntrActvPostBldCfgCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001C9B6

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoFTrqPtd_cntrNegChkPostBldCfg
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CC65

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoFTrqPtd_cntrNegChkPostBldCfgCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001C9B5

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoFTrqPtd_cntrPosChkPostBldCfg
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CC64

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoFTrqPtd_cntrPosChkPostBldCfgCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001C9B4

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoFTrqPtd_cntrStabyChkPostBldCfg
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CC63

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoFTrqPtd_cntrStabyChkPostBldCfgCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001C9B3

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoFTrqPtd_cntrTestPostBldSel
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C671

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoFTrqPtd_flgAlt
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x8
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6001CC60

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoFTrqPtd_flgClrPostBldSel
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x1
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x700000CC

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoFTrqPtd_flgDrvgCycStabyChk_MP
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x1
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x700303AE

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoFTrqPtd_flgErrActPostBldCfg_MP
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x1
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x700303AD

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoFTrqPtd_flgErrNegChkPostBld_MP
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x1
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x700303AC

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoFTrqPtd_flgErrPosChk
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x2
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6001CC60

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoFTrqPtd_flgErrPosChk2
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x4
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6001CC60

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoFTrqPtd_flgErrPosChkPostBld_MP
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x1
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x700303AB

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoFTrqPtd_flgIrrvErrPostBldSel
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x1
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6001CC5F

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoFTrqPtd_flgIrrvErrPostBldSelMsg
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x1
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x700000D1

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoFTrqPtd_flgPostBldCfgRxd
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x1
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6001CC60

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoFTrqPtd_idxPostBldCfg
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CC62

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoFTrqPtd_idxPostBldCfgCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001C9B2

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoFTrqPtd_idxPostBldCfgIni
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CC61

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoFTrqPtd_idxPostBldCfgIniCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001C9B1

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoFTrqPtd_stRbGetActvPostBldVrntIdx_MP
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x700303AA

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoFTrqPtd_stRbMoInitCheckInverse_MP
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x700303A9

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoFTrqPtd_stRbMoInitCheck_MP
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x700303A8

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoFVarPostBldSel_bbLoc1Cpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001C9B0

/end MEASUREMENT

/begin MEASUREMENT

    MoFVarPostBldSel_bbOut1Cpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001C9AF

/end MEASUREMENT

/begin MEASUREMENT

    MoGlbl_bbLocExtdTskCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001C9A5

/end MEASUREMENT

/begin MEASUREMENT

    MoGlbl_vblStruct.Mo_stMoC
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CC50

/end MEASUREMENT

/begin MEASUREMENT

    MoGlbl_vblStructCpl.Mo_stCplChk
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001C990

/end MEASUREMENT

/begin MEASUREMENT

    MoGlbl_vblStructCpl.Mo_stMoCCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001C994

/end MEASUREMENT

/begin MEASUREMENT

    MoGlbl_vblStructCpl_Core1_10ms_Nr1.Mo_stCplChk
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CB50

/end MEASUREMENT

/begin MEASUREMENT

    MoGlbl_vblStructCpl_Core1_10ms_Nr1.Mo_stMoCCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CB54

/end MEASUREMENT

/begin MEASUREMENT

    MoGlbl_vblStruct_Core1_10ms_Nr1.Mo_stMoC
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001D0A0

/end MEASUREMENT

/begin MEASUREMENT

    MoSysCtrlCo_bbLoc1Cpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001C9AE

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoSysCtrlCo_bbOut1Cpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001C9AD

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoSysCtrl_ctErrReIniAllowd
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CC5D

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoSysCtrl_ctErrReIniAllowdCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001C9AC

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoSysCtrl_ctPostDrvLeave
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CC56

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoSysCtrl_ctPostDrvLeaveCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001C9AB

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoSysCtrl_ctPostDrvLeaveOld
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CC5C

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoSysCtrl_ctPostDrvLeaveOldCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001C9AA

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoSysCtrl_ctReIniAllowd
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CC5B

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoSysCtrl_ctReIniAllowdCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001C9A9

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoSysCtrl_ctReIniTst
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C670

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoSysCtrl_ctT15RsngEdgDetn
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CC5A

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoSysCtrl_ctT15RsngEdgDetnCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001C9A8

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoSysCtrl_ctT15RsngEdgDetnPlausy
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CC59

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoSysCtrl_ctT15RsngEdgDetnPlausyCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001C9A7

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoSysCtrl_ctT15RsngEdgTurnOff
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CC58

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoSysCtrl_ctT15RsngEdgTurnOffCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001C9A6

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoSysCtrl_flgErrReIniReq
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x40
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6001CC5E

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoSysCtrl_flgErrReIniReqMsg
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x1
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x700000D0

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoSysCtrl_flgIrvErrReIniReqMsg
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x1
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x700000CF

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoSysCtrl_flgReIniClr
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x1
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x700000CB

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoSysCtrl_flgReIniReq
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x1
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6001CC5E

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoSysCtrl_flgReIniReqAlwd
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x2
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6001CC5E

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoSysCtrl_flgReIniReqTrig
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x1
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6001CC57

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoSysCtrl_flgReIniReqTrigMsg
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x1
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x700000CE

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoSysCtrl_flgReIniTestMsg
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x1
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x700000CD

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoSysCtrl_flgT15
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x80
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6001CC5E

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoSysCtrl_flgT15Old
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x4
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6001CC5E

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoSysCtrl_flgT15PlausyErr
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x8
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6001CC5E

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoSysCtrl_flgT15PlausyErrOld
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x10
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6001CC5E

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoSysCtrl_flgT15RsngEdgTurnOff
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x20
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6001CC5E

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoXEMM_cntrPostDrvLeaveOld
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6A9

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoXEMM_stEMMAlrms
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    MATRIX_DIM 22  
    ECU_ADDRESS 0x600032CC

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoXEMM_stEMMAlrmsAftRst
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    MATRIX_DIM 22  
    ECU_ADDRESS 0x60003274

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoXEMM_stHwLTResult
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x60003324

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Mo_bAddConPFC
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x80
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6001CC52

/end MEASUREMENT

/begin MEASUREMENT

    Mo_bAddConPFCExtdTsk
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x80
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6001CC51

/end MEASUREMENT

/begin MEASUREMENT

    Mo_bAddDisblPreICORst
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x8
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6001CC52

/end MEASUREMENT

/begin MEASUREMENT

    Mo_bAddDisblPreICORstExtdTsk
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x8
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6001CC51

/end MEASUREMENT

/begin MEASUREMENT

    Mo_bCplChk
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x1
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6001CC54

/end MEASUREMENT

/begin MEASUREMENT

    Mo_bCplChkExtdTsk
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x1
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6001CC53

/end MEASUREMENT

/begin MEASUREMENT

    Mo_bEmgcyAir
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x20
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6001CC52

/end MEASUREMENT

/begin MEASUREMENT

    Mo_bICOL1
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x2
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6001CC52

/end MEASUREMENT

/begin MEASUREMENT

    Mo_bICOL2
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x1
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6001CC52

/end MEASUREMENT

/begin MEASUREMENT

    Mo_bICOL2ExtdTsk
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x1
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6001CC51

/end MEASUREMENT

/begin MEASUREMENT

    Mo_bIrvElMIdl
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x20
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6001CC55

/end MEASUREMENT

/begin MEASUREMENT

    Mo_bIrvHybLimpL1
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x2
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6001CC55

/end MEASUREMENT

/begin MEASUREMENT

    Mo_bIrvHybLimpL2
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x1
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6001CC55

/end MEASUREMENT

/begin MEASUREMENT

    Mo_bIrvHybP1LimpL2
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x10
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6001CC55

/end MEASUREMENT

/begin MEASUREMENT

    Mo_bIrvTrqLimL1
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x8
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6001CC55

/end MEASUREMENT

/begin MEASUREMENT

    Mo_bIrvTrqLimL2
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x4
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6001CC55

/end MEASUREMENT

/begin MEASUREMENT

    Mo_bLoVltg
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x4
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6001CC52

/end MEASUREMENT

/begin MEASUREMENT

    Mo_bNlh
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x10
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6001CC52

/end MEASUREMENT

/begin MEASUREMENT

    Mo_bRamErr
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x2
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6001CC54

/end MEASUREMENT

/begin MEASUREMENT

    Mo_bRamErrExtdTsk
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x2
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6001CC53

/end MEASUREMENT

/begin MEASUREMENT

    Mo_bRomErr
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x4
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6001CC54

/end MEASUREMENT

/begin MEASUREMENT

    Mo_bSyncLos
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x40
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6001CC52

/end MEASUREMENT

/begin MEASUREMENT

    Mo_ctRst
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036CFB

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Mo_ctRstCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036CFA

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Mo_ctRstMsg
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6A8

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Mo_flgICOMsg
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x1
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6000C69A

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Mo_flgIrrvErrSOPMsg
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x1
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6000C7AA

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Mo_stCplChk
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001C99C

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Mo_stErrHyb
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CC55

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Mo_stErrHybCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001C9A4

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Mo_stMoC
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CC54

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Mo_stMoCCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001C9A3

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Mo_stMoCExtdTsk
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CC53

/end MEASUREMENT

/begin MEASUREMENT

    Mo_stMoCExtdTskCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001C9A2

/end MEASUREMENT

/begin MEASUREMENT

    Mo_stMoCExtdTskMsg
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6A7

/end MEASUREMENT

/begin MEASUREMENT

    Mo_stMoCMsg
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6A6

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Mo_stMoF
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CC52

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Mo_stMoFCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001C9A1

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Mo_stMoFExtdTsk
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CC51

/end MEASUREMENT

/begin MEASUREMENT

    Mo_stMoFExtdTskCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001C9A0

/end MEASUREMENT

/begin MEASUREMENT

    Mo_stMoFExtdTskMsg
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6A5

/end MEASUREMENT

/begin MEASUREMENT

    Mo_stMoFMsg
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6A4

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Mo_stProtRAM
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036CFC

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Mo_stVldR32Chk
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001C998

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MRly_ctErlyOpng
    "Errorcounter-message to detect early opening of the main relay"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6FE

/end MEASUREMENT

/begin MEASUREMENT

    MRly_st
    "Request to switch on and off the main relay"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6B7

/end MEASUREMENT

/begin MEASUREMENT

    MRly_stAct
    "Status of main relay"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6FD

/end MEASUREMENT

/begin MEASUREMENT

    NEngInd_nOpt
    "Optimized engine speed sended to CAN"
    SWORD
    EngN
    1
    100
    -16384.00
    16383.50

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B57E

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    NMHigh_xSNI
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6FB

/end MEASUREMENT

/begin MEASUREMENT

    OCWDA_cntrPostDrvLeaveOld
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6A3

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    OCWDA_ctBattU
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6A2

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    OCWDA_ctDebActvErr
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6A1

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    OCWDA_ctDebErrNotActv
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6A0

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    OCWDA_ctTstOCWDA
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C69F

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    OCWDA_flgClrDebDFC
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C697

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    OCWDA_stABE
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x1
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6000C66F

/end MEASUREMENT

/begin MEASUREMENT

    OCWDA_stABEActv
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C69E

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    OCWDA_stCheckState
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x60003368

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    OCWDA_stErrMonPtt
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x60003364

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    OCWDA_stErrPinActv
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C69D

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    OCWDA_stWDAActv
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C69C

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    OilP_p
    "Oil pressure"
    SWORD
    Pres_hPa
    1
    100
    0.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B57C

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Oil_bPresWarn
    "status oil pressure warning"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6B6

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Oil_tSwmp
    "Oil temperature in oil sump"
    SWORD
    RBPtCel_t_0p1om273p14_1
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x70002AF0

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    PCR_pDesVal
    "Limited boost pressure setpoint"
    SWORD
    Pres_hPa
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B57A

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    PFltRgn_stTxtMsg
    "Status, text message for particle filter"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6FA

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    PhyMod_moiEng
    "moment of inertia"
    SWORD
    Moment_Inertia
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0x6000B578

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    PhyMod_trqDynEng
    "dynamic engine torque"
    SWORD
    Trq
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000B576

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    PspCtl_stFlPmpAct
    "Information ""auxiliar heater was on"""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6F9

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    PthSet_stOvrRunCoord
    "State of overrun detection of the overrun coordinator (0: no overrun; 1:overrun)"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6F8

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    rba_MemDiagExtd_nrLstReadSngErr
    "Block id of last occurred read error for single storage blocks"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x60036CF8

/end MEASUREMENT

/begin MEASUREMENT

    rba_MemDiag_flgInhbDiag
    "Diagnosis is inhibited"
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x1
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x700000C8

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    rba_MemDiag_nrLstReadErr
    "Block id of last occurred read error"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x60036CF6

/end MEASUREMENT

/begin MEASUREMENT

    rba_MemDiag_nrLstWrErr
    "Block id of last occurred write error"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x60036CF4

/end MEASUREMENT

/begin MEASUREMENT

    rba_MRly_Ctrl_State_en
    "Zustandsmaschine der Hauptrelaisansteuerung"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x700090C0

/end MEASUREMENT

/begin MEASUREMENT

    rba_MRly_Diag_StkState_en
    "State machine for main relay diagnosis"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x60010484

/end MEASUREMENT

/begin MEASUREMENT

    RBR_HW_INH_MV
    ""
    UWORD
    OneToOne
    1
    100
    1.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x70002B4E

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Reset_APP_rUnFlt
    "Protected copy of APP_rUnFlt for freeze frame"
    SWORD
    Prc
    1
    100
    -400.0000
    399.9878

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0x60036CF2

/end MEASUREMENT

/begin MEASUREMENT

    Reset_BattU_u
    "Battery voltage"
    SWORD
    Volt_Batt
    1
    100
    -655360.0
    655340.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0x60036CF0

/end MEASUREMENT

/begin MEASUREMENT

    Reset_CoETS_rTrq
    "Protected copy of CoETS_rTrq for freeze frame"
    SWORD
    Prc
    1
    100
    -400.0000
    399.9878

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0x60036CEE

/end MEASUREMENT

/begin MEASUREMENT

    Reset_Env_ctRst
    "Reset counter which counts all resets"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C66E

/end MEASUREMENT

/begin MEASUREMENT

    Reset_Env_xGrp
    "Reset group of last reset"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C66D

/end MEASUREMENT

/begin MEASUREMENT

    Reset_Env_xId
    "Reset-ID of the last reset reason (Copy of Reset_Env.xId)"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B498

/end MEASUREMENT

/begin MEASUREMENT

    Reset_Epm_nEng
    "Protected copy of Epm_nEng for freeze frame"
    SWORD
    EngN
    1
    100
    -16384.00
    16383.50

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x60036CEC

/end MEASUREMENT

/begin MEASUREMENT

    Reset_GlbDa_lTotDst
    "total distance since first start captured at software reset"
    SLONG
    Length
    1
    100
    -2147483648.00
    2147483647.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x60036CE8

/end MEASUREMENT

/begin MEASUREMENT

    Reset_T15_st
    "Protected copy of T15_st for freeze frame"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036CE6

/end MEASUREMENT

/begin MEASUREMENT

    Reset_VehV_v
    "Protected copy of Veh_v for freeze frame"
    SWORD
    Vel
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0x60036CE4

/end MEASUREMENT

/begin MEASUREMENT

    SCRCtl_stAcoustic
    "SCR acoustic warning information for Display-ECU"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6F7

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    SCRCtl_stDsplStgy
    "calibrated display strategy to be sent over CAN"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6F6

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    SCRCtl_stWarnText
    "SCR warning text for Display-ECU"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6F5

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Sia_stErrLmpReq
    ""
    SWORD
    Pres_hPa
    1
    100
    0.00
    255.0000

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0x6000B56E

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    SLmpCtl_rOilLvl
    "Quantized oil quantity in percent"
    SWORD
    Prc
    1
    100
    -400.0000
    399.9878

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0x6000B574

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    SLmpCtl_stOil
    "Bit register for the status of the oil label"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B546

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    SLmpCtl_volOil
    "Oil quantity between minimum and maximum for display"
    SWORD
    volFilgLvl_ml
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B572

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    SSEUI_stDemNoStopCanMeas
    "Status of StartStop-Stop prohibition for CAN version MQB"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B544

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    SSEUI_stStrtDesCanMeas
    "Status of StartStop-start request for CAN version MQB"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6F4

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    StopLmp_stDigOut_mp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    1.000

    BIT_MASK 0x1
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x700302F2

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    StopLmp_stReq
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6F2

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    StopLmp_stSrc
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6F1

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    StrtCtl_stStrtStopDspl
    "Number of the requested disply in the Combi"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6F0

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    StrtCtl_stT75
    "Status of terminal T75 during start event"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6EF

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Strt_st
    "Status activation starter relay"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6EE

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Strt_stStaActv
    "State starter=active"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6ED

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    StSys_stStrtDisengaFrm
    "state of starter disengaging bit for frame manager"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6B5

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    StSys_stStrtRlsFrm
    "state of starter release bit for frame manager"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6F3

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    SwAdp_Hbr_Dcyc
    "Duty-Cycle of the H-bridge"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C66B

/end MEASUREMENT

/begin MEASUREMENT

    SwAdp_Hbr_Period
    "Peroid of the H-bridge"
    SWORD
    OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B494

/end MEASUREMENT

/begin MEASUREMENT

    SWAdp_rPwmInDutycycle
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x60003270

/end MEASUREMENT

/begin MEASUREMENT

    SWAdp_stDIOin
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6000326C

/end MEASUREMENT

/begin MEASUREMENT

    SwAdp_stHbr_OnOff
    "Status variable to check the Swadp H-bridge is in ON or OFF state"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C66A

/end MEASUREMENT

/begin MEASUREMENT

    SWAdp_stPwmInSignal
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C669

/end MEASUREMENT

/begin MEASUREMENT

    SWAdp_tiPwmInPeriod
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x60003268

/end MEASUREMENT

/begin MEASUREMENT

    SWaPmp_tiHtgPmp
    "Maximum after-run time sent to climat control unit through CAN"
    SWORD
    TimeEngOn
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B570

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    SwSVW_bBrkStopReqSupp
    "Software sharing variable for Brake stop request support"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6EC

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    SwsVW_bRstrtActv
    "restart engine active"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6E7

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    SwsVW_bStopActv
    "stop phase active"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6E6

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    SwSVW_bStopReqEnaIdc
    "Software sharing variable for stop request enable indication"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6B4

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    SwsVW_bVlvGbxClg
    "bit valve gearbox cooling open"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6B3

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    SwsVW_bVlvGbxClgPrs
    "bit valve gearbox cooling present"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6B2

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    SwSVW_noSetDrvModStrtStopSwt
    "StartStop switch charisma driveprogram reply"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6EB

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    SwsVW_numGearActDspl
    "actual gear from shiftup-information"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6E5

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    SwsVW_numGearDesDspl
    "desired gear from shiftup-information"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6E4

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    SwSVW_stLmpOutStrtStopSwt
    "desired StartStop switch lamp status"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6EA

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    SwSVW_stStopInhIdcCordStrtStop
    "binary output of stop inhibition reasons from startstop coordinator for external display"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B542

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    SwSVW_stStrtReqIdcCordStrtStop
    "binary output of start request reasons from startstop coordinator for external display"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6E9

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    SwSVW_stStrtStopCharStrtStopSwt
    "StartStop charisma status"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6E8

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    SwsVW_stStrtStopDrv
    "Driver stop request for CAN"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6E3

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    SwsVW_stStrtStopSys
    "system status for start/stop"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6E2

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    SwsVW_stVlvHeat
    "status of valve heating-closing"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6E1

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    SwsVW_stWtPmpEng
    "status of water pump of engine"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6E0

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    SyC_ctDrvEnter
    "Global drive cycle counter which is incremented when system state SyC_Drive is entered"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6DF

/end MEASUREMENT

/begin MEASUREMENT

    SyC_ctIrrSwOff
    "Counter for detection of irregular switch-off of the ECU"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6DE

/end MEASUREMENT

/begin MEASUREMENT

    SyC_ctPostDrvLeave
    "Global drive cycle counter which is incremented when system state SyC_PostDrive is left"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6DD

/end MEASUREMENT

/begin MEASUREMENT

    SyC_stMn
    "Current system/ECU state"
    UBYTE
    ExeCon_State_01
    1
    100
    0.00
    3.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6000C6DC

/end MEASUREMENT

/begin MEASUREMENT

    SyC_stMnOld
    "Previous system/ECU state"
    UBYTE
    ExeCon_State_01
    1
    100
    0.00
    3.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6000C6DB

/end MEASUREMENT

/begin MEASUREMENT

    SyC_stPostDrv
    "PostDrive control state"
    UBYTE
    SyC_PostDrv_State
    1
    100
    0.00
    8.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6000C6DA

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    SyC_stPostDrvDel
    "post-drive delay request"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6B1

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    SyC_stPreDrv
    "PreDrive control state"
    UBYTE
    SyC_PreDrv_State
    1
    100
    0.00
    9.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6000C6D9

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    SyC_stPreDrvDel
    "Variable to check if predrive is prolonged or not"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6B0

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    SyC_stSub
    "Current system/ECU sub-state"
    UBYTE
    ExeCon_State_02
    1
    100
    0.00
    6.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6000C6D8

/end MEASUREMENT

/begin MEASUREMENT

    SyC_stSubOld
    "Previous system/ECU sub-state"
    UBYTE
    ExeCon_State_02
    1
    100
    0.00
    6.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6000C6D7

/end MEASUREMENT

/begin MEASUREMENT

    SyC_stSwtOn_mp
    "Status current reason for switching-on ECU"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x700302F1

/end MEASUREMENT

/begin MEASUREMENT

    SyC_tiBoot_mp
    "Time from ECU switch-on until system state SYC_INI is reached"
    ULONG
    Time_usec_q1_COMPU
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x70030104

/end MEASUREMENT

/begin MEASUREMENT

    SyC_tiDrv
    "Time since state SYC_DRIVE was reached"
    ULONG
    Time_msec_q10_COMPU
    1
    100
    0.00
    42949672950.0

    
    FORMAT "%13.1"
    
    ECU_ADDRESS 0x60003374

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    SyC_tiFrst10ms
    "Time from ECU boot until the first 10ms task"
    UWORD
    Time_msec_q1_COMPU
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B540

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    SyC_tiIniEnd_mp
    "Duration of system state SYC_INIEND"
    UWORD
    Time_usec_q1_COMPU
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x70030182

/end MEASUREMENT

/begin MEASUREMENT

    SyC_tiIniSyn_mp
    "Duration of system state SYC_INISYN"
    UWORD
    Time_usec_q1_COMPU
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x70030180

/end MEASUREMENT

/begin MEASUREMENT

    SyC_tiIni_mp
    "Duration of system state SYC_INI"
    ULONG
    Time_usec_q1_COMPU
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x70030100

/end MEASUREMENT

/begin MEASUREMENT

    SyC_tiPostDrv
    "Time since state SYC_POSTDRIVE was reached"
    ULONG
    Time_msec_q10_COMPU
    1
    100
    0.00
    42949672950.0

    
    FORMAT "%13.1"
    
    ECU_ADDRESS 0x60003370

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    SyC_tiPreDrv
    "Time since state SYC_PREDRIVE was reached"
    ULONG
    Time_msec_q10_COMPU
    1
    100
    0.00
    42949672950.0

    
    FORMAT "%13.1"
    
    ECU_ADDRESS 0x6000336C

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    T15_flgOn
    "Terminal 15 state"
    UBYTE
    OneToOne
    1
    100
    0.00
    1.000

    BIT_MASK 0x1
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x6000C7AC

/end MEASUREMENT

/begin MEASUREMENT

    T15_st
    "Terminal 15 status after debouncing"
    UBYTE
    OneToOne
    1
    100
    0.00
    1.000

    BIT_MASK 0x1
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x6000C6AF

/end MEASUREMENT

/begin MEASUREMENT

    T15_stRaw
    "Raw value of Terminal 15 status"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6D6

/end MEASUREMENT

/begin MEASUREMENT

    T15_stRawTurnOffDly_Sq
    ""
    UBYTE
    SigQly_COMPU_VERB
    1
    100
    0.00
    15.0000000000

    
    FORMAT "%13.10"
    
    ECU_ADDRESS 0x6000C69B

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    TECU_t
    "ECU Temperature."
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000B56C

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    test_bypass_rbaBypDrv_N_Rpl_u32
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6000A50C

    /begin IF_DATA ASAP1B_Bypass
    /begin KP_BLOB
        BUFFER_OFFSET    "rba_BypEtk_test_bypass_rbaBypDrv_N_Rpl_u32_bypass_CST.Vector_u16"
        SOURCE_ID        "rba_BypEtk_test_bypass_rbaBypDrv_N_Rpl_u32_bypass_CST.Channel_u16"
    /end KP_BLOB
    /end IF_DATA


/end MEASUREMENT

/begin MEASUREMENT

    test_bypass_rbaBypDrv_N_Rpl_u32_BefRpl
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001224C

/end MEASUREMENT

/begin MEASUREMENT

    test_bypass_rbaBypDrv_T_Add_f32
    ""
    FLOAT32_IEEE
    OneToOne
    1
    100
    -100000000.000
    100000000.000

    
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A510

    /begin IF_DATA ASAP1B_Bypass
    /begin KP_BLOB
        BUFFER_OFFSET    "rba_BypEtk_test_bypass_rbaBypDrv_T_Add_f32_bypass_CST.Vector_u16"
        SOURCE_ID        "rba_BypEtk_test_bypass_rbaBypDrv_T_Add_f32_bypass_CST.Channel_u16"
    /end KP_BLOB
    /end IF_DATA


/end MEASUREMENT

/begin MEASUREMENT

    test_bypass_rbaBypDrv_T_Add_f32_BefAdd
    ""
    FLOAT32_IEEE
    OneToOne
    1
    100
    -100000000.000
    100000000.000

    
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x60012248

/end MEASUREMENT

/begin MEASUREMENT

    test_bypass_rbaBypDrv_T_Add_s16
    ""
    SWORD
    OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C258

    /begin IF_DATA ASAP1B_Bypass
    /begin KP_BLOB
        BUFFER_OFFSET    "rba_BypEtk_test_bypass_rbaBypDrv_T_Add_s16_bypass_CST.Vector_u16"
        SOURCE_ID        "rba_BypEtk_test_bypass_rbaBypDrv_T_Add_s16_bypass_CST.Channel_u16"
    /end KP_BLOB
    /end IF_DATA


/end MEASUREMENT

/begin MEASUREMENT

    test_bypass_rbaBypDrv_T_Add_s16_BefAdd
    ""
    SWORD
    OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x60012244

/end MEASUREMENT

/begin MEASUREMENT

    test_bypass_rbaBypDrv_T_Add_s32
    ""
    SLONG
    OneToOne
    1
    100
    -2147483648.00
    2147483647.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6000A520

    /begin IF_DATA ASAP1B_Bypass
    /begin KP_BLOB
        BUFFER_OFFSET    "rba_BypEtk_test_bypass_rbaBypDrv_T_Add_s32_bypass_CST.Vector_u16"
        SOURCE_ID        "rba_BypEtk_test_bypass_rbaBypDrv_T_Add_s32_bypass_CST.Channel_u16"
    /end KP_BLOB
    /end IF_DATA


/end MEASUREMENT

/begin MEASUREMENT

    test_bypass_rbaBypDrv_T_Add_s32_BefAdd
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x60012240

/end MEASUREMENT

/begin MEASUREMENT

    test_bypass_rbaBypDrv_T_Add_s8
    ""
    SBYTE
    OneToOne
    1
    100
    -128.0
    127.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CFDC

    /begin IF_DATA ASAP1B_Bypass
    /begin KP_BLOB
        BUFFER_OFFSET    "rba_BypEtk_test_bypass_rbaBypDrv_T_Add_s8_bypass_CST.Vector_u16"
        SOURCE_ID        "rba_BypEtk_test_bypass_rbaBypDrv_T_Add_s8_bypass_CST.Channel_u16"
    /end KP_BLOB
    /end IF_DATA


/end MEASUREMENT

/begin MEASUREMENT

    test_bypass_rbaBypDrv_T_Add_s8_BefAdd
    ""
    SBYTE
    OneToOne
    1
    100
    -128.0
    127.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001223E

/end MEASUREMENT

/begin MEASUREMENT

    test_bypass_rbaBypDrv_T_Add_u16
    ""
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C25A

    /begin IF_DATA ASAP1B_Bypass
    /begin KP_BLOB
        BUFFER_OFFSET    "rba_BypEtk_test_bypass_rbaBypDrv_T_Add_u16_bypass_CST.Vector_u16"
        SOURCE_ID        "rba_BypEtk_test_bypass_rbaBypDrv_T_Add_u16_bypass_CST.Channel_u16"
    /end KP_BLOB
    /end IF_DATA


/end MEASUREMENT

/begin MEASUREMENT

    test_bypass_rbaBypDrv_T_Add_u16_BefAdd
    ""
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6001223C

/end MEASUREMENT

/begin MEASUREMENT

    test_bypass_rbaBypDrv_T_Add_u32
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6000A524

    /begin IF_DATA ASAP1B_Bypass
    /begin KP_BLOB
        BUFFER_OFFSET    "rba_BypEtk_test_bypass_rbaBypDrv_T_Add_u32_bypass_CST.Vector_u16"
        SOURCE_ID        "rba_BypEtk_test_bypass_rbaBypDrv_T_Add_u32_bypass_CST.Channel_u16"
    /end KP_BLOB
    /end IF_DATA


/end MEASUREMENT

/begin MEASUREMENT

    test_bypass_rbaBypDrv_T_Add_u32_BefAdd
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x60012238

/end MEASUREMENT

/begin MEASUREMENT

    test_bypass_rbaBypDrv_T_Add_u8
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CFDD

    /begin IF_DATA ASAP1B_Bypass
    /begin KP_BLOB
        BUFFER_OFFSET    "rba_BypEtk_test_bypass_rbaBypDrv_T_Add_u8_bypass_CST.Vector_u16"
        SOURCE_ID        "rba_BypEtk_test_bypass_rbaBypDrv_T_Add_u8_bypass_CST.Channel_u16"
    /end KP_BLOB
    /end IF_DATA


/end MEASUREMENT

/begin MEASUREMENT

    test_bypass_rbaBypDrv_T_Add_u8_BefAdd
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60012234

/end MEASUREMENT

/begin MEASUREMENT

    test_bypass_rbaBypDrv_T_Rpl_f32
    ""
    FLOAT32_IEEE
    OneToOne
    1
    100
    -100000000.000
    100000000.000

    
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A514

    /begin IF_DATA ASAP1B_Bypass
    /begin KP_BLOB
        BUFFER_OFFSET    "rba_BypEtk_test_bypass_rbaBypDrv_T_Rpl_f32_bypass_CST.Vector_u16"
        SOURCE_ID        "rba_BypEtk_test_bypass_rbaBypDrv_T_Rpl_f32_bypass_CST.Channel_u16"
    /end KP_BLOB
    /end IF_DATA


/end MEASUREMENT

/begin MEASUREMENT

    test_bypass_rbaBypDrv_T_Rpl_f32_BefRpl
    ""
    FLOAT32_IEEE
    OneToOne
    1
    100
    -100000000.000
    100000000.000

    
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x60012230

/end MEASUREMENT

/begin MEASUREMENT

    test_bypass_rbaBypDrv_T_Rpl_s16
    ""
    SWORD
    OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C254

    /begin IF_DATA ASAP1B_Bypass
    /begin KP_BLOB
        BUFFER_OFFSET    "rba_BypEtk_test_bypass_rbaBypDrv_T_Rpl_s16_bypass_CST.Vector_u16"
        SOURCE_ID        "rba_BypEtk_test_bypass_rbaBypDrv_T_Rpl_s16_bypass_CST.Channel_u16"
    /end KP_BLOB
    /end IF_DATA


/end MEASUREMENT

/begin MEASUREMENT

    test_bypass_rbaBypDrv_T_Rpl_s16_BefRpl
    ""
    SWORD
    OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6001222C

/end MEASUREMENT

/begin MEASUREMENT

    test_bypass_rbaBypDrv_T_Rpl_s32
    ""
    SLONG
    OneToOne
    1
    100
    -2147483648.00
    2147483647.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6000A518

    /begin IF_DATA ASAP1B_Bypass
    /begin KP_BLOB
        BUFFER_OFFSET    "rba_BypEtk_test_bypass_rbaBypDrv_T_Rpl_s32_bypass_CST.Vector_u16"
        SOURCE_ID        "rba_BypEtk_test_bypass_rbaBypDrv_T_Rpl_s32_bypass_CST.Channel_u16"
    /end KP_BLOB
    /end IF_DATA


/end MEASUREMENT

/begin MEASUREMENT

    test_bypass_rbaBypDrv_T_Rpl_s32_BefRpl
    ""
    SLONG
    OneToOne
    1
    100
    -2147483648.00
    2147483647.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x60012228

/end MEASUREMENT

/begin MEASUREMENT

    test_bypass_rbaBypDrv_T_Rpl_s8
    ""
    SBYTE
    OneToOne
    1
    100
    -128.0
    127.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CFDA

    /begin IF_DATA ASAP1B_Bypass
    /begin KP_BLOB
        BUFFER_OFFSET    "rba_BypEtk_test_bypass_rbaBypDrv_T_Rpl_s8_bypass_CST.Vector_u16"
        SOURCE_ID        "rba_BypEtk_test_bypass_rbaBypDrv_T_Rpl_s8_bypass_CST.Channel_u16"
    /end KP_BLOB
    /end IF_DATA


/end MEASUREMENT

/begin MEASUREMENT

    test_bypass_rbaBypDrv_T_Rpl_s8_BefRpl
    ""
    SBYTE
    OneToOne
    1
    100
    -128.0
    127.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60012226

/end MEASUREMENT

/begin MEASUREMENT

    test_bypass_rbaBypDrv_T_Rpl_u16
    ""
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C256

    /begin IF_DATA ASAP1B_Bypass
    /begin KP_BLOB
        BUFFER_OFFSET    "rba_BypEtk_test_bypass_rbaBypDrv_T_Rpl_u16_bypass_CST.Vector_u16"
        SOURCE_ID        "rba_BypEtk_test_bypass_rbaBypDrv_T_Rpl_u16_bypass_CST.Channel_u16"
    /end KP_BLOB
    /end IF_DATA


/end MEASUREMENT

/begin MEASUREMENT

    test_bypass_rbaBypDrv_T_Rpl_u16_BefRpl
    ""
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x60012224

/end MEASUREMENT

/begin MEASUREMENT

    test_bypass_rbaBypDrv_T_Rpl_u32
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6000A51C

    /begin IF_DATA ASAP1B_Bypass
    /begin KP_BLOB
        BUFFER_OFFSET    "rba_BypEtk_test_bypass_rbaBypDrv_T_Rpl_u32_bypass_CST.Vector_u16"
        SOURCE_ID        "rba_BypEtk_test_bypass_rbaBypDrv_T_Rpl_u32_bypass_CST.Channel_u16"
    /end KP_BLOB
    /end IF_DATA


/end MEASUREMENT

/begin MEASUREMENT

    test_bypass_rbaBypDrv_T_Rpl_u32_BefRpl
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x60012220

/end MEASUREMENT

/begin MEASUREMENT

    test_bypass_rbaBypDrv_T_Rpl_u8
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CFDB

    /begin IF_DATA ASAP1B_Bypass
    /begin KP_BLOB
        BUFFER_OFFSET    "rba_BypEtk_test_bypass_rbaBypDrv_T_Rpl_u8_bypass_CST.Vector_u16"
        SOURCE_ID        "rba_BypEtk_test_bypass_rbaBypDrv_T_Rpl_u8_bypass_CST.Channel_u16"
    /end KP_BLOB
    /end IF_DATA


/end MEASUREMENT

/begin MEASUREMENT

    test_bypass_rbaBypDrv_T_Rpl_u8_BefRepl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001221C

/end MEASUREMENT

/begin MEASUREMENT

    test_bypass_rba_BypEhooksModifier_u32
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6000A528

/end MEASUREMENT

/begin MEASUREMENT

    test_bypass_rba_Svbb_ct10ms
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CFDF

/end MEASUREMENT

/begin MEASUREMENT

    test_bypass_rba_Svbb_ctSeg1
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CFDE

/end MEASUREMENT

/begin MEASUREMENT

    upssp_w
    "Voltage from electric pressure sensor"
    UWORD
    spg_q0p00488
    1
    100
    0.00
    319.9951

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0x70002B56

/end MEASUREMENT

/begin MEASUREMENT

    upwg1_w
    "Voltage PWG potentiometer 1 (word)"
    UWORD
    spg_uw_q0p00488
    1
    100
    0.00
    319.9951

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0x70002B54

/end MEASUREMENT

/begin MEASUREMENT

    upwg2_w
    "Voltage PWG potentiometer 2 (word)"
    UWORD
    spg_uw_q0p00488
    1
    100
    0.00
    319.9951

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0x70002B52

/end MEASUREMENT

/begin MEASUREMENT

    usfk_w
    "output voltage oxygen sensor (4.88mV/LSB) downstream front catalyst"
    UWORD
    spg_uw_q0p00488_o1
    1
    100
    -1.0000
    318.9951

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0x70002B50

/end MEASUREMENT

/begin MEASUREMENT

    VehV_v
    "Vehicle speed"
    SWORD
    Vel
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0x6000B56A

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    WaPmp_stInfoSysExt
    "ITM pump warning"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6D5

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    WrnLmp_stDigOut
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6AE

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    WrnLmp_stDigOut_mp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    1.000

    BIT_MASK 0x1
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x700302F0

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    WrnLmp_stReq
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6D4

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    WrnLmp_stSrc
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6D3

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT



/***********   Start of merged FUNCTION blocks    ***********/

/begin FUNCTION

    Com
    "13.12.1  McFunction Com Created by MCFunctionUpdater"
    /begin DEF_CHARACTERISTIC
        Com_stComIPdu_C_xRxPduCtrl_C Com_stComIPdu_C_xTxPduCtrl_C Com_stComIPdu_D_xRxPduCtrl_C Com_stComIPdu_D_xTxPduCtrl_C Com_stComIPdu_canFd_1_xRxPduCtrl_C 
        Com_stComIPdu_canFd_1_xTxPduCtrl_C Com_stNM_TX_FAPduCtrl_C 
    /end DEF_CHARACTERISTIC
    /begin LOC_MEASUREMENT
        Com_SigType_u16 Com_SigType_u32 Com_SigType_u64 Com_SigType_u8 Com_dComIPdu_C_xRxByte 
        Com_dComIPdu_C_xTxByte Com_dComIPdu_D_xRxByte Com_dComIPdu_D_xTxByte Com_dComIPdu_canFd_1_xRxByte Com_dComIPdu_canFd_1_xTxByte 
        Com_dNM_TX_FAByte 
    /end LOC_MEASUREMENT

    FUNCTION_VERSION    "13.12.1"

/end FUNCTION

/begin FUNCTION

    rba_BypEtk
    "McFunction rba_BypEtk Created by MCFunctionUpdater"
    /begin DEF_CHARACTERISTIC
        rba_BypEtk_test_bypass_rbaBypDrv_N_Rpl_u32_bypass_CST.Channel_u16 rba_BypEtk_test_bypass_rbaBypDrv_N_Rpl_u32_bypass_CST.Vector_u16 rba_BypEtk_test_bypass_rbaBypDrv_T_Add_f32_bypass_CST.Channel_u16 rba_BypEtk_test_bypass_rbaBypDrv_T_Add_f32_bypass_CST.Vector_u16 rba_BypEtk_test_bypass_rbaBypDrv_T_Add_s16_bypass_CST.Channel_u16 
        rba_BypEtk_test_bypass_rbaBypDrv_T_Add_s16_bypass_CST.Vector_u16 rba_BypEtk_test_bypass_rbaBypDrv_T_Add_s32_bypass_CST.Channel_u16 rba_BypEtk_test_bypass_rbaBypDrv_T_Add_s32_bypass_CST.Vector_u16 rba_BypEtk_test_bypass_rbaBypDrv_T_Add_s8_bypass_CST.Channel_u16 rba_BypEtk_test_bypass_rbaBypDrv_T_Add_s8_bypass_CST.Vector_u16 
        rba_BypEtk_test_bypass_rbaBypDrv_T_Add_u16_bypass_CST.Channel_u16 rba_BypEtk_test_bypass_rbaBypDrv_T_Add_u16_bypass_CST.Vector_u16 rba_BypEtk_test_bypass_rbaBypDrv_T_Add_u32_bypass_CST.Channel_u16 rba_BypEtk_test_bypass_rbaBypDrv_T_Add_u32_bypass_CST.Vector_u16 rba_BypEtk_test_bypass_rbaBypDrv_T_Add_u8_bypass_CST.Channel_u16 
        rba_BypEtk_test_bypass_rbaBypDrv_T_Add_u8_bypass_CST.Vector_u16 rba_BypEtk_test_bypass_rbaBypDrv_T_Rpl_f32_bypass_CST.Channel_u16 rba_BypEtk_test_bypass_rbaBypDrv_T_Rpl_f32_bypass_CST.Vector_u16 rba_BypEtk_test_bypass_rbaBypDrv_T_Rpl_s16_bypass_CST.Channel_u16 rba_BypEtk_test_bypass_rbaBypDrv_T_Rpl_s16_bypass_CST.Vector_u16 
        rba_BypEtk_test_bypass_rbaBypDrv_T_Rpl_s32_bypass_CST.Channel_u16 rba_BypEtk_test_bypass_rbaBypDrv_T_Rpl_s32_bypass_CST.Vector_u16 rba_BypEtk_test_bypass_rbaBypDrv_T_Rpl_s8_bypass_CST.Channel_u16 rba_BypEtk_test_bypass_rbaBypDrv_T_Rpl_s8_bypass_CST.Vector_u16 rba_BypEtk_test_bypass_rbaBypDrv_T_Rpl_u16_bypass_CST.Channel_u16 
        rba_BypEtk_test_bypass_rbaBypDrv_T_Rpl_u16_bypass_CST.Vector_u16 rba_BypEtk_test_bypass_rbaBypDrv_T_Rpl_u32_bypass_CST.Channel_u16 rba_BypEtk_test_bypass_rbaBypDrv_T_Rpl_u32_bypass_CST.Vector_u16 rba_BypEtk_test_bypass_rbaBypDrv_T_Rpl_u8_bypass_CST.Channel_u16 rba_BypEtk_test_bypass_rbaBypDrv_T_Rpl_u8_bypass_CST.Vector_u16 
        
    /end DEF_CHARACTERISTIC

/end FUNCTION

/begin FUNCTION

    rba_CalWup
    "1.41.0  McFunction rba_CalWup Created by MCFunctionUpdater"
    /begin DEF_CHARACTERISTIC
        rba_CalWup_Finish_C rba_CalWup_WakeupEnable_C 
    /end DEF_CHARACTERISTIC

    FUNCTION_VERSION    "1.41.0"

/end FUNCTION

/begin FUNCTION

    rba_Etks
    "1.41.0  McFunction rba_Etks Created by MCFunctionUpdater"
    /begin DEF_CHARACTERISTIC
        rba_Etks_swt3rdPartySupp_C 
    /end DEF_CHARACTERISTIC

    FUNCTION_VERSION    "1.41.0"

/end FUNCTION

/begin FUNCTION

    rba_IoSigHlfBr
    "1.18.0  McFunction rba_IoSigHlfBr Created by MCFunctionUpdater"
    /begin DEF_CHARACTERISTIC
        rba_IoSigHlfBr_bds_Pb_preDefRef_vrnt01_HBR1_C 
    /end DEF_CHARACTERISTIC

    FUNCTION_VERSION    "1.18.0"

/end FUNCTION

/begin FUNCTION

    rba_MRly
    "1.29.0    Main Relay"
    /begin DEF_CHARACTERISTIC
        rba_MRly_Diag_Stk_tiOkError_C 
    /end DEF_CHARACTERISTIC
    /begin LOC_MEASUREMENT
        rba_MRly_Ctrl_State_MP 
    /end LOC_MEASUREMENT

    FUNCTION_VERSION    "1.29.0"

/end FUNCTION

/begin FUNCTION

    rba_OsMeasmt
    "1.11.0    Os Runtime Measurement"
    /begin DEF_CHARACTERISTIC
        rba_MultiStackTrace_ResetMaxValues rba_MultiStackTrace_ThresholdSwitch rba_OsMeasmt_ResetMaxCoreLoadValues_C rba_OsMeasmt_ResetResponseTimeValues_C rba_OsMeasmt_SwTrace_InitMode_C 
        
    /end DEF_CHARACTERISTIC
    /begin LOC_MEASUREMENT
        rba_MultiStackTrace_ThresholdTable rba_OsMeasmt_CoreLoad[0].curCycleMax rba_OsMeasmt_CoreLoad[0].current rba_OsMeasmt_CoreLoad[0].lifeTimeMax rba_OsMeasmt_CoreLoad[1].curCycleMax 
        rba_OsMeasmt_CoreLoad[1].current rba_OsMeasmt_CoreLoad[1].lifeTimeMax rba_OsMeasmt_CoreLoad[2].curCycleMax rba_OsMeasmt_CoreLoad[2].current rba_OsMeasmt_CoreLoad[2].lifeTimeMax 
        rba_OsMeasmt_CoreLoad[3].curCycleMax rba_OsMeasmt_CoreLoad[3].current rba_OsMeasmt_CoreLoad[3].lifeTimeMax rba_OsMeasmt_OS_1000ms_Task.CETCurrent rba_OsMeasmt_OS_1000ms_Task.CETCurrentLoad 
        rba_OsMeasmt_OS_1000ms_Task.CETCurrentLoadMax rba_OsMeasmt_OS_1000ms_Task.CETCycleMax rba_OsMeasmt_OS_1000ms_Task.RespTimeCurrent rba_OsMeasmt_OS_1000ms_Task.RespTimeCycleMax rba_OsMeasmt_OS_1000ms_Task.RespTimeLifetimeMax 
        rba_OsMeasmt_OS_100ms_Task.CETCurrent rba_OsMeasmt_OS_100ms_Task.CETCurrentLoad rba_OsMeasmt_OS_100ms_Task.CETCurrentLoadMax rba_OsMeasmt_OS_100ms_Task.CETCycleMax rba_OsMeasmt_OS_100ms_Task.RespTimeCurrent 
        rba_OsMeasmt_OS_100ms_Task.RespTimeCycleMax rba_OsMeasmt_OS_100ms_Task.RespTimeLifetimeMax rba_OsMeasmt_OS_10ms_Task.CETCurrent rba_OsMeasmt_OS_10ms_Task.CETCurrentLoad rba_OsMeasmt_OS_10ms_Task.CETCurrentLoadMax 
        rba_OsMeasmt_OS_10ms_Task.CETCycleMax rba_OsMeasmt_OS_10ms_Task.RespTimeCurrent rba_OsMeasmt_OS_10ms_Task.RespTimeCycleMax rba_OsMeasmt_OS_10ms_Task.RespTimeLifetimeMax rba_OsMeasmt_OS_1ms_Task.CETCurrent 
        rba_OsMeasmt_OS_1ms_Task.CETCurrentLoad rba_OsMeasmt_OS_1ms_Task.CETCurrentLoadMax rba_OsMeasmt_OS_1ms_Task.CETCycleMax rba_OsMeasmt_OS_1ms_Task.RespTimeCurrent rba_OsMeasmt_OS_1ms_Task.RespTimeCycleMax 
        rba_OsMeasmt_OS_1ms_Task.RespTimeLifetimeMax rba_OsMeasmt_OS_200ms_Task.CETCurrent rba_OsMeasmt_OS_200ms_Task.CETCurrentLoad rba_OsMeasmt_OS_200ms_Task.CETCurrentLoadMax rba_OsMeasmt_OS_200ms_Task.CETCycleMax 
        rba_OsMeasmt_OS_200ms_Task.RespTimeCurrent rba_OsMeasmt_OS_200ms_Task.RespTimeCycleMax rba_OsMeasmt_OS_200ms_Task.RespTimeLifetimeMax rba_OsMeasmt_OS_20ms_Task.CETCurrent rba_OsMeasmt_OS_20ms_Task.CETCurrentLoad 
        rba_OsMeasmt_OS_20ms_Task.CETCurrentLoadMax rba_OsMeasmt_OS_20ms_Task.CETCycleMax rba_OsMeasmt_OS_20ms_Task.RespTimeCurrent rba_OsMeasmt_OS_20ms_Task.RespTimeCycleMax rba_OsMeasmt_OS_20ms_Task.RespTimeLifetimeMax 
        rba_OsMeasmt_OS_2ms_Task.CETCurrent rba_OsMeasmt_OS_2ms_Task.CETCurrentLoad rba_OsMeasmt_OS_2ms_Task.CETCurrentLoadMax rba_OsMeasmt_OS_2ms_Task.CETCycleMax rba_OsMeasmt_OS_2ms_Task.RespTimeCurrent 
        rba_OsMeasmt_OS_2ms_Task.RespTimeCycleMax rba_OsMeasmt_OS_2ms_Task.RespTimeLifetimeMax rba_OsMeasmt_OS_40ms_Task.CETCurrent rba_OsMeasmt_OS_40ms_Task.CETCurrentLoad rba_OsMeasmt_OS_40ms_Task.CETCurrentLoadMax 
        rba_OsMeasmt_OS_40ms_Task.CETCycleMax rba_OsMeasmt_OS_40ms_Task.RespTimeCurrent rba_OsMeasmt_OS_40ms_Task.RespTimeCycleMax rba_OsMeasmt_OS_40ms_Task.RespTimeLifetimeMax rba_OsMeasmt_OS_50ms_Task.CETCurrent 
        rba_OsMeasmt_OS_50ms_Task.CETCurrentLoad rba_OsMeasmt_OS_50ms_Task.CETCurrentLoadMax rba_OsMeasmt_OS_50ms_Task.CETCycleMax rba_OsMeasmt_OS_50ms_Task.RespTimeCurrent rba_OsMeasmt_OS_50ms_Task.RespTimeCycleMax 
        rba_OsMeasmt_OS_50ms_Task.RespTimeLifetimeMax rba_OsMeasmt_OS_5ms_Task.CETCurrent rba_OsMeasmt_OS_5ms_Task.CETCurrentLoad rba_OsMeasmt_OS_5ms_Task.CETCurrentLoadMax rba_OsMeasmt_OS_5ms_Task.CETCycleMax 
        rba_OsMeasmt_OS_5ms_Task.RespTimeCurrent rba_OsMeasmt_OS_5ms_Task.RespTimeCycleMax rba_OsMeasmt_OS_5ms_Task.RespTimeLifetimeMax rba_OsMeasmt_OS_80ms_Task.CETCurrent rba_OsMeasmt_OS_80ms_Task.CETCurrentLoad 
        rba_OsMeasmt_OS_80ms_Task.CETCurrentLoadMax rba_OsMeasmt_OS_80ms_Task.CETCycleMax rba_OsMeasmt_OS_80ms_Task.RespTimeCurrent rba_OsMeasmt_OS_80ms_Task.RespTimeCycleMax rba_OsMeasmt_OS_80ms_Task.RespTimeLifetimeMax 
        
    /end LOC_MEASUREMENT

    FUNCTION_VERSION    "1.11.0"

/end FUNCTION

/begin FUNCTION

    rba_Reset
    "1.41.1  McFunction rba_Reset Created by MCFunctionUpdater"
    /begin DEF_CHARACTERISTIC
        rba_Reset_rstExtHistBuf_C rba_Reset_rstHistBuf_C rba_Reset_xGrpId_C rba_Reset_xTrgId_C 
    /end DEF_CHARACTERISTIC
    /begin LOC_MEASUREMENT
        rba_Reset_ApplEnv_st.CntrRst_u8 rba_Reset_ApplEnv_st.Grp_en rba_Reset_ApplEnv_st.Id_en rba_Reset_ApplEnv_st.Loc_u32 rba_Reset_ApplEnv_st.UserValue_u32 
        rba_Reset_ExtHistBuf_ast[0].Addr_u32 rba_Reset_ExtHistBuf_ast[0].Cntr_u16 rba_Reset_ExtHistBuf_ast[0].ResetId_en rba_Reset_ExtHistBuf_ast[0].SwId_u32_1 rba_Reset_ExtHistBuf_ast[0].SwId_u32_2 
        rba_Reset_ExtHistBuf_ast[1].Addr_u32 rba_Reset_ExtHistBuf_ast[1].Cntr_u16 rba_Reset_ExtHistBuf_ast[1].ResetId_en rba_Reset_ExtHistBuf_ast[1].SwId_u32_1 rba_Reset_ExtHistBuf_ast[1].SwId_u32_2 
        rba_Reset_ExtHistBuf_ast[2].Addr_u32 rba_Reset_ExtHistBuf_ast[2].Cntr_u16 rba_Reset_ExtHistBuf_ast[2].ResetId_en rba_Reset_ExtHistBuf_ast[2].SwId_u32_1 rba_Reset_ExtHistBuf_ast[2].SwId_u32_2 
        rba_Reset_ExtHistBuf_ast[3].Addr_u32 rba_Reset_ExtHistBuf_ast[3].Cntr_u16 rba_Reset_ExtHistBuf_ast[3].ResetId_en rba_Reset_ExtHistBuf_ast[3].SwId_u32_1 rba_Reset_ExtHistBuf_ast[3].SwId_u32_2 
        rba_Reset_ExtHistBuf_ast[4].Addr_u32 rba_Reset_ExtHistBuf_ast[4].Cntr_u16 rba_Reset_ExtHistBuf_ast[4].ResetId_en rba_Reset_ExtHistBuf_ast[4].SwId_u32_1 rba_Reset_ExtHistBuf_ast[4].SwId_u32_2 
        rba_Reset_ExtHistBuf_ast[5].Addr_u32 rba_Reset_ExtHistBuf_ast[5].Cntr_u16 rba_Reset_ExtHistBuf_ast[5].ResetId_en rba_Reset_ExtHistBuf_ast[5].SwId_u32_1 rba_Reset_ExtHistBuf_ast[5].SwId_u32_2 
        rba_Reset_ExtHistBuf_ast[6].Addr_u32 rba_Reset_ExtHistBuf_ast[6].Cntr_u16 rba_Reset_ExtHistBuf_ast[6].ResetId_en rba_Reset_ExtHistBuf_ast[6].SwId_u32_1 rba_Reset_ExtHistBuf_ast[6].SwId_u32_2 
        rba_Reset_ExtHistBuf_ast[7].Addr_u32 rba_Reset_ExtHistBuf_ast[7].Cntr_u16 rba_Reset_ExtHistBuf_ast[7].ResetId_en rba_Reset_ExtHistBuf_ast[7].SwId_u32_1 rba_Reset_ExtHistBuf_ast[7].SwId_u32_2 
        rba_Reset_ExtHistBuf_ast[8].Addr_u32 rba_Reset_ExtHistBuf_ast[8].Cntr_u16 rba_Reset_ExtHistBuf_ast[8].ResetId_en rba_Reset_ExtHistBuf_ast[8].SwId_u32_1 rba_Reset_ExtHistBuf_ast[8].SwId_u32_2 
        rba_Reset_ExtHistBuf_ast[9].Addr_u32 rba_Reset_ExtHistBuf_ast[9].Cntr_u16 rba_Reset_ExtHistBuf_ast[9].ResetId_en rba_Reset_ExtHistBuf_ast[9].SwId_u32_1 rba_Reset_ExtHistBuf_ast[9].SwId_u32_2 
        rba_Reset_HistBuf_a 
    /end LOC_MEASUREMENT

    FUNCTION_VERSION    "1.41.1"

/end FUNCTION

/begin FUNCTION

    rba_SvbbEtk
    "1.41.0  McFunction rba_SvbbEtk Created by MCFunctionUpdater"
    /begin DEF_CHARACTERISTIC
        rba_SvbbEtk_Enable_C rba_SvbbEtk_MaxLostRaster_C rba_SvbbEtk_WaitForBypconfigInIni_C 
    /end DEF_CHARACTERISTIC
    /begin LOC_MEASUREMENT
        rba_SvbbEtk_ControlVar[0].Control_u8 rba_SvbbEtk_ControlVar[0].ErrCntPost_u8 rba_SvbbEtk_ControlVar[0].ErrCntPre_u8 rba_SvbbEtk_ControlVar[0].FailedTriggerCounter_u8 rba_SvbbEtk_ControlVar[1].Control_u8 
        rba_SvbbEtk_ControlVar[1].ErrCntPost_u8 rba_SvbbEtk_ControlVar[1].ErrCntPre_u8 rba_SvbbEtk_ControlVar[1].FailedTriggerCounter_u8 rba_SvbbEtk_ControlVar[2].Control_u8 rba_SvbbEtk_ControlVar[2].ErrCntPost_u8 
        rba_SvbbEtk_ControlVar[2].ErrCntPre_u8 rba_SvbbEtk_ControlVar[2].FailedTriggerCounter_u8 rba_SvbbEtk_ControlVar[3].Control_u8 rba_SvbbEtk_ControlVar[3].ErrCntPost_u8 rba_SvbbEtk_ControlVar[3].ErrCntPre_u8 
        rba_SvbbEtk_ControlVar[3].FailedTriggerCounter_u8 rba_SvbbEtk_DelayedEcuInitialisation rba_SvbbEtk_DummyVar rba_SvbbEtk_stEnable 
    /end LOC_MEASUREMENT

    FUNCTION_VERSION    "1.41.0"

/end FUNCTION

/begin FUNCTION

    rba_SyC_States
    "1.9.0_RC40_ML  McFunction rba_SyC_States Created by MCFunctionUpdater"
    /begin DEF_CHARACTERISTIC
        rba_SyC_States_PostDrive_Begin_Timeout_C rba_SyC_States_PostDrive_ClearTimeoutIndication_C rba_SyC_States_PostDrive_End_Timeout_C rba_SyC_States_PostDrive_MinimumTime_C rba_SyC_States_PostDrive_Network_Timeout_C 
        rba_SyC_States_PrepareShutdown_ClearTimeoutIndication_C rba_SyC_States_PrepareShutdown_MaximumTime_C rba_SyC_States_PrepareShutdown_MinimumTime_C rba_SyC_States_Wait_ClearTimeoutIndication_C rba_SyC_States_Wait_Delay_Timeout_C 
        rba_SyC_States_Wait_MinimumTime_C rba_SyC_States_Wait_Network_Timeout_C rba_SyC_States_Wait_Prolong_Timeout_C 
    /end DEF_CHARACTERISTIC
    /begin LOC_MEASUREMENT
        rba_SyC_States_CurrentState_MP rba_SyC_States_PostDrive_Prolongers_MP rba_SyC_States_PostDrive_TimeoutCounterBegin_MP rba_SyC_States_PostDrive_TimeoutCounterEnd_MP rba_SyC_States_PostDrive_TimeoutCounterNetwork_MP 
        rba_SyC_States_PostDrive_TimeoutHistoryBegin_MP rba_SyC_States_PostDrive_TimeoutHistoryEnd_MP rba_SyC_States_PostDrive_TimeoutHistoryNetwork_MP rba_SyC_States_PostDrive_substate_MP rba_SyC_States_PrepareDrive_substate_MP 
        rba_SyC_States_PrepareShutdown_Prolongers_MP rba_SyC_States_PrepareShutdown_TimeoutCounterComplete_MP rba_SyC_States_PrepareShutdown_TimeoutHistoryComplete_MP rba_SyC_States_PrepareShutdown_substate_MP rba_SyC_States_PreviousState_MP 
        rba_SyC_States_Wait_Prolongers_MP rba_SyC_States_Wait_TimeoutCounterDelay_MP rba_SyC_States_Wait_TimeoutCounterNetwork_MP rba_SyC_States_Wait_TimeoutCounterProlong_MP rba_SyC_States_Wait_TimeoutHistoryDelay_MP 
        rba_SyC_States_Wait_TimeoutHistoryNetwork_MP rba_SyC_States_Wait_TimeoutHistoryProlong_MP rba_SyC_States_Wait_substate_MP rba_SyC_User_GlobalScope_Prolongers_MP rba_SyC_User_PostDriveScope_Delayers_MP 
        rba_SyC_User_PostDriveScope_Prolongers_MP rba_SyC_User_PrepareShutdownScope_Delayers_MP rba_SyC_User_WaitScope_Delayers_MP rba_SyC_User_WaitScope_Prolongers_MP rba_SyC_tiBoot_us_MP 
        rba_SyC_tiDrive_10ms_MP rba_SyC_tiInit_us_MP rba_SyC_tiLastShutdown_us_MP rba_SyC_tiPostDrive_10ms_MP rba_SyC_tiPrepareDrive_10ms_MP 
        rba_SyC_tiPrepareShutdown_10ms_MP rba_SyC_tiWait_10ms_MP 
    /end LOC_MEASUREMENT

    FUNCTION_VERSION    "1.9.0_RC40_ML"

/end FUNCTION

/begin FUNCTION

    rba_T15
    "2.30.0    Terminal15"
    /begin DEF_CHARACTERISTIC
        rba_T15_Diag_ComInVld_tiDebPreFault_C rba_T15_Diag_ComInVld_tiDebPreOk_C rba_T15_Diag_ComOff_HwOn_tiDebPreFault_C rba_T15_Diag_ComOff_HwOn_tiDebPreOk_C rba_T15_Diag_ComOn_HwOff_tiDebPreFault_C 
        rba_T15_Diag_ComOn_HwOff_tiDebPreOk_C rba_T15_Signal_tiDebHiLo_C rba_T15_Signal_tiDebLoHi_C 
    /end DEF_CHARACTERISTIC
    /begin LOC_MEASUREMENT
        rba_T15_Signal_Debounced_MP rba_T15_Signal_Logical_MP rba_T15_Signal_UndebouncedValid_MP rba_T15_Signal_Undebounced_MP 
    /end LOC_MEASUREMENT

    FUNCTION_VERSION    "2.30.0"

/end FUNCTION

/begin FUNCTION

    CanIf
    "15.12.2  McFunction CanIf Created by MCFunctionUpdater"
    /begin LOC_MEASUREMENT
        CanIf_Prv_ControllerState_ast[0].Ctrl_Pdu_mode CanIf_Prv_ControllerState_ast[1].Ctrl_Pdu_mode CanIf_Prv_ControllerState_ast[2].Ctrl_Pdu_mode CanIf_Prv_ControllerState_ast[3].Ctrl_Pdu_mode CanIf_Prv_InitStatus_b 
        CanIf_Prv_TxBufferRam_ast[0].bufferstatus CanIf_Prv_TxBufferRam_ast[0].last_index CanIf_Prv_TxBufferRam_ast[10].bufferstatus CanIf_Prv_TxBufferRam_ast[10].last_index CanIf_Prv_TxBufferRam_ast[11].bufferstatus 
        CanIf_Prv_TxBufferRam_ast[11].last_index CanIf_Prv_TxBufferRam_ast[12].bufferstatus CanIf_Prv_TxBufferRam_ast[12].last_index CanIf_Prv_TxBufferRam_ast[13].bufferstatus CanIf_Prv_TxBufferRam_ast[13].last_index 
        CanIf_Prv_TxBufferRam_ast[1].bufferstatus CanIf_Prv_TxBufferRam_ast[1].last_index CanIf_Prv_TxBufferRam_ast[2].bufferstatus CanIf_Prv_TxBufferRam_ast[2].last_index CanIf_Prv_TxBufferRam_ast[3].bufferstatus 
        CanIf_Prv_TxBufferRam_ast[3].last_index CanIf_Prv_TxBufferRam_ast[4].bufferstatus CanIf_Prv_TxBufferRam_ast[4].last_index CanIf_Prv_TxBufferRam_ast[5].bufferstatus CanIf_Prv_TxBufferRam_ast[5].last_index 
        CanIf_Prv_TxBufferRam_ast[6].bufferstatus CanIf_Prv_TxBufferRam_ast[6].last_index CanIf_Prv_TxBufferRam_ast[7].bufferstatus CanIf_Prv_TxBufferRam_ast[7].last_index CanIf_Prv_TxBufferRam_ast[8].bufferstatus 
        CanIf_Prv_TxBufferRam_ast[8].last_index CanIf_Prv_TxBufferRam_ast[9].bufferstatus CanIf_Prv_TxBufferRam_ast[9].last_index 
    /end LOC_MEASUREMENT

    FUNCTION_VERSION    "15.12.2"

/end FUNCTION

/begin FUNCTION

    CanSM
    "11.12.2   CAN State Manager"
    /begin LOC_MEASUREMENT
        CanSM_BORMode_au8 CanSM_BusOffISRPend_ab CanSM_BusOff_Cntr_au8 CanSM_CurrNw_Mode_en CanSM_MutexMode_au8 
        CanSM_Network_Init_ab CanSM_ReqComM_Mode_en CanSM_TimerConfig_ast[0].cntTick_u16 CanSM_TimerConfig_ast[0].stTimer CanSM_TimerConfig_ast[1].cntTick_u16 
        CanSM_TimerConfig_ast[1].stTimer CanSM_TimerConfig_ast[2].cntTick_u16 CanSM_TimerConfig_ast[2].stTimer CanSM_TimerConfig_ast[3].cntTick_u16 CanSM_TimerConfig_ast[3].stTimer 
        CanSM_currBOR_State_en 
    /end LOC_MEASUREMENT

    FUNCTION_VERSION    "11.12.2"

/end FUNCTION

/begin FUNCTION

    CanTp
    "24.12.2  McFunction CanTp Created by MCFunctionUpdater"
    /begin LOC_MEASUREMENT
        CanTp_MainState 
    /end LOC_MEASUREMENT

    FUNCTION_VERSION    "24.12.2"

/end FUNCTION

/begin FUNCTION

    ComM
    "9.12.0    Communication Manager"
    /begin LOC_MEASUREMENT
        ComM_ChannelStruct[0].BusSmMode_u8 ComM_ChannelStruct[0].ChannelMode_u8 ComM_ChannelStruct[0].ChannelState_e ComM_ChannelStruct[0].CommunicationAllowed_b ComM_ChannelStruct[0].DiagnosticRequestState_b 
        ComM_ChannelStruct[0].InhibitionReqStatus_u8 ComM_ChannelStruct[0].LightTimeoutCtr_u32 ComM_ChannelStruct[0].MinFullComTimeoutCtr_u16 ComM_ChannelStruct[0].NmBusSleepIndicationStatus_b ComM_ChannelStruct[0].NmNetworkModeStatus_b 
        ComM_ChannelStruct[0].NmNetworkRequestStatus_b ComM_ChannelStruct[0].NmPrepareBusSleepIndicationStatus_b ComM_ChannelStruct[0].PassiveRequestState_u8 ComM_ChannelStruct[0].PncRequestCtr_u8 ComM_ChannelStruct[0].UserRequestCtr_u16 
        ComM_ChannelStruct[1].BusSmMode_u8 ComM_ChannelStruct[1].ChannelMode_u8 ComM_ChannelStruct[1].ChannelState_e ComM_ChannelStruct[1].CommunicationAllowed_b ComM_ChannelStruct[1].DiagnosticRequestState_b 
        ComM_ChannelStruct[1].InhibitionReqStatus_u8 ComM_ChannelStruct[1].LightTimeoutCtr_u32 ComM_ChannelStruct[1].MinFullComTimeoutCtr_u16 ComM_ChannelStruct[1].NmBusSleepIndicationStatus_b ComM_ChannelStruct[1].NmNetworkModeStatus_b 
        ComM_ChannelStruct[1].NmNetworkRequestStatus_b ComM_ChannelStruct[1].NmPrepareBusSleepIndicationStatus_b ComM_ChannelStruct[1].PassiveRequestState_u8 ComM_ChannelStruct[1].PncRequestCtr_u8 ComM_ChannelStruct[1].UserRequestCtr_u16 
        ComM_ChannelStruct[2].BusSmMode_u8 ComM_ChannelStruct[2].ChannelMode_u8 ComM_ChannelStruct[2].ChannelState_e ComM_ChannelStruct[2].CommunicationAllowed_b ComM_ChannelStruct[2].DiagnosticRequestState_b 
        ComM_ChannelStruct[2].InhibitionReqStatus_u8 ComM_ChannelStruct[2].LightTimeoutCtr_u32 ComM_ChannelStruct[2].MinFullComTimeoutCtr_u16 ComM_ChannelStruct[2].NmBusSleepIndicationStatus_b ComM_ChannelStruct[2].NmNetworkModeStatus_b 
        ComM_ChannelStruct[2].NmNetworkRequestStatus_b ComM_ChannelStruct[2].NmPrepareBusSleepIndicationStatus_b ComM_ChannelStruct[2].PassiveRequestState_u8 ComM_ChannelStruct[2].PncRequestCtr_u8 ComM_ChannelStruct[2].UserRequestCtr_u16 
        ComM_ChannelStruct[3].BusSmMode_u8 ComM_ChannelStruct[3].ChannelMode_u8 ComM_ChannelStruct[3].ChannelState_e ComM_ChannelStruct[3].CommunicationAllowed_b ComM_ChannelStruct[3].DiagnosticRequestState_b 
        ComM_ChannelStruct[3].InhibitionReqStatus_u8 ComM_ChannelStruct[3].LightTimeoutCtr_u32 ComM_ChannelStruct[3].MinFullComTimeoutCtr_u16 ComM_ChannelStruct[3].NmBusSleepIndicationStatus_b ComM_ChannelStruct[3].NmNetworkModeStatus_b 
        ComM_ChannelStruct[3].NmNetworkRequestStatus_b ComM_ChannelStruct[3].NmPrepareBusSleepIndicationStatus_b ComM_ChannelStruct[3].PassiveRequestState_u8 ComM_ChannelStruct[3].PncRequestCtr_u8 ComM_ChannelStruct[3].UserRequestCtr_u16 
        ComM_ChannelStruct[4].BusSmMode_u8 ComM_ChannelStruct[4].ChannelMode_u8 ComM_ChannelStruct[4].ChannelState_e ComM_ChannelStruct[4].CommunicationAllowed_b ComM_ChannelStruct[4].DiagnosticRequestState_b 
        ComM_ChannelStruct[4].InhibitionReqStatus_u8 ComM_ChannelStruct[4].LightTimeoutCtr_u32 ComM_ChannelStruct[4].MinFullComTimeoutCtr_u16 ComM_ChannelStruct[4].NmBusSleepIndicationStatus_b ComM_ChannelStruct[4].NmNetworkModeStatus_b 
        ComM_ChannelStruct[4].NmNetworkRequestStatus_b ComM_ChannelStruct[4].NmPrepareBusSleepIndicationStatus_b ComM_ChannelStruct[4].PassiveRequestState_u8 ComM_ChannelStruct[4].PncRequestCtr_u8 ComM_ChannelStruct[4].UserRequestCtr_u16 
        ComM_ChannelStruct[5].BusSmMode_u8 ComM_ChannelStruct[5].ChannelMode_u8 ComM_ChannelStruct[5].ChannelState_e ComM_ChannelStruct[5].CommunicationAllowed_b ComM_ChannelStruct[5].DiagnosticRequestState_b 
        ComM_ChannelStruct[5].InhibitionReqStatus_u8 ComM_ChannelStruct[5].LightTimeoutCtr_u32 ComM_ChannelStruct[5].MinFullComTimeoutCtr_u16 ComM_ChannelStruct[5].NmBusSleepIndicationStatus_b ComM_ChannelStruct[5].NmNetworkModeStatus_b 
        ComM_ChannelStruct[5].NmNetworkRequestStatus_b ComM_ChannelStruct[5].NmPrepareBusSleepIndicationStatus_b ComM_ChannelStruct[5].PassiveRequestState_u8 ComM_ChannelStruct[5].PncRequestCtr_u8 ComM_ChannelStruct[5].UserRequestCtr_u16 
        ComM_UserStruct[0].IndicatedUserMode_t ComM_UserStruct[0].LimitToNoComCtr_u16 ComM_UserStruct[0].RequestedUserMode_t ComM_UserStruct[0].WakeUpInhibitionCtr_u16 ComM_UserStruct[0].numChannelsInFullCom_u8 
        ComM_UserStruct[0].numChannelsInNoCom_u8 ComM_UserStruct[0].numChannelsInSilentCom_u8 ComM_UserStruct[1].IndicatedUserMode_t ComM_UserStruct[1].LimitToNoComCtr_u16 ComM_UserStruct[1].RequestedUserMode_t 
        ComM_UserStruct[1].WakeUpInhibitionCtr_u16 ComM_UserStruct[1].numChannelsInFullCom_u8 ComM_UserStruct[1].numChannelsInNoCom_u8 ComM_UserStruct[1].numChannelsInSilentCom_u8 ComM_UserStruct[2].IndicatedUserMode_t 
        ComM_UserStruct[2].LimitToNoComCtr_u16 ComM_UserStruct[2].RequestedUserMode_t ComM_UserStruct[2].WakeUpInhibitionCtr_u16 ComM_UserStruct[2].numChannelsInFullCom_u8 ComM_UserStruct[2].numChannelsInNoCom_u8 
        ComM_UserStruct[2].numChannelsInSilentCom_u8 ComM_UserStruct[3].IndicatedUserMode_t ComM_UserStruct[3].LimitToNoComCtr_u16 ComM_UserStruct[3].RequestedUserMode_t ComM_UserStruct[3].WakeUpInhibitionCtr_u16 
        ComM_UserStruct[3].numChannelsInFullCom_u8 ComM_UserStruct[3].numChannelsInNoCom_u8 ComM_UserStruct[3].numChannelsInSilentCom_u8 ComM_UserStruct[4].IndicatedUserMode_t ComM_UserStruct[4].LimitToNoComCtr_u16 
        ComM_UserStruct[4].RequestedUserMode_t ComM_UserStruct[4].WakeUpInhibitionCtr_u16 ComM_UserStruct[4].numChannelsInFullCom_u8 ComM_UserStruct[4].numChannelsInNoCom_u8 ComM_UserStruct[4].numChannelsInSilentCom_u8 
        ComM_UserStruct[5].IndicatedUserMode_t ComM_UserStruct[5].LimitToNoComCtr_u16 ComM_UserStruct[5].RequestedUserMode_t ComM_UserStruct[5].WakeUpInhibitionCtr_u16 ComM_UserStruct[5].numChannelsInFullCom_u8 
        ComM_UserStruct[5].numChannelsInNoCom_u8 ComM_UserStruct[5].numChannelsInSilentCom_u8 ComM_UserStruct[6].IndicatedUserMode_t ComM_UserStruct[6].LimitToNoComCtr_u16 ComM_UserStruct[6].RequestedUserMode_t 
        ComM_UserStruct[6].WakeUpInhibitionCtr_u16 ComM_UserStruct[6].numChannelsInFullCom_u8 ComM_UserStruct[6].numChannelsInNoCom_u8 ComM_UserStruct[6].numChannelsInSilentCom_u8 
    /end LOC_MEASUREMENT

    FUNCTION_VERSION    "9.12.0"

/end FUNCTION

/begin FUNCTION

    EthSM
    "2.11.0  McFunction EthSM Created by MCFunctionUpdater"
    /begin LOC_MEASUREMENT
        EthSM_NetState_aen 
    /end LOC_MEASUREMENT

    FUNCTION_VERSION    "2.11.0"

/end FUNCTION

/begin FUNCTION

    LinIf
    "9.12.1  McFunction LinIf Created by MCFunctionUpdater"
    /begin LOC_MEASUREMENT
        LinIf_ChnlVar_as[0].ChannelStateFlag_u8 LinIf_ChnlVar_as[0].ChannelStatusFlags_u8 LinIf_ChnlVar_as[0].CurrentIndex_u8 LinIf_ChnlVar_as[0].CurrentScheduleTable_u8 LinIf_ChnlVar_as[0].DelayCount_u8 
        LinIf_ChnlVar_as[0].GotoSleepCtr LinIf_ChnlVar_as[0].NewScheduleTable_u8 LinIf_ChnlVar_as[0].SavedIndex_u8 LinIf_ChnlVar_as[0].SavedScheduleTable_u8 LinIf_ChnlVar_as[0].SlpGetStatus_u8 
        LinIf_ChnlVar_as[0].SpoETIndex_u8 LinIf_ChnlVar_as[0].Temp_SpoFrmCount_u8 LinIf_ChnlVar_as[0].TransmitSRF_u8 LinIf_ChnlVar_as[0].Wakeup_u8 LinIf_Status_u8 
        
    /end LOC_MEASUREMENT

    FUNCTION_VERSION    "9.12.1"

/end FUNCTION

/begin FUNCTION

    LinSM
    "5.10.0  McFunction LinSM Created by MCFunctionUpdater"
    /begin LOC_MEASUREMENT
        LinSM_ModeRepeatReq_Max_u8 LinSM_RamVar_ast[0].ChnlState LinSM_RamVar_ast[0].LinSmModReqRepMax LinSM_RamVar_ast[0].LinSm_Conf_Status LinSM_RamVar_ast[0].LinSm_Request_Status 
        LinSM_RamVar_ast[0].LinSm_SchdReq_E_NOT_OK LinSM_RamVar_ast[0].LinSm_Sleep_Status LinSM_RamVar_ast[0].StoredSchdTab LinSM_RamVar_ast[0].TimeOutCounter LinSM_RamVar_ast[0].TimeoutFlag 
        LinSM_State_en 
    /end LOC_MEASUREMENT

    FUNCTION_VERSION    "5.10.0"

/end FUNCTION

/begin FUNCTION

    PduR
    "15.12.1_TMA1COB_BSW_20.03_ESB1  McFunction PduR Created by MCFunctionUpdater"
    /begin LOC_MEASUREMENT
        PduR_State 
    /end LOC_MEASUREMENT

    FUNCTION_VERSION    "15.12.1_TMA1COB_BSW_20.03_ESB1"

/end FUNCTION

/begin FUNCTION

    TcpIp
    "2.11.1  McFunction TcpIp Created by MCFunctionUpdater"
    /begin LOC_MEASUREMENT
        TcpIp_EthIfCtrlSt_aen 
    /end LOC_MEASUREMENT

    FUNCTION_VERSION    "2.11.1"

/end FUNCTION

/begin FUNCTION

    Can
    "McFunction Can Created by MCFunctionUpdater"
    /begin LOC_MEASUREMENT
        rba_CanMcan_DriverState_MP rba_CanMcan_MsgStatus_MP 
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    rba_IoDiagHlfBr
    "1.17.0  McFunction rba_IoDiagHlfBr Created by MCFunctionUpdater"
    /begin LOC_MEASUREMENT
        rba_IoDiagHlfBr_dataDiagInfo_MP rba_IoDiagHlfBr_idDbgSignal rba_IoDiagHlfBr_stDiagCtrl_MP rba_IoDiagHlfBr_stDiagDi_MP rba_IoDiagHlfBr_stSwtOffDiag_MP 
        rba_IoDiagHlfBr_stTstPlsReq_MP rba_IoDiagHlfBr_xReasSwtOffDiagAbort_MP 
    /end LOC_MEASUREMENT

    FUNCTION_VERSION    "1.17.0"

/end FUNCTION

/begin FUNCTION

    rba_OsShell
    "1.38.0__RC40_FFI  McFunction rba_OsShell Created by MCFunctionUpdater"
    /begin LOC_MEASUREMENT
        rba_MultiStackTrace_CurrentCycleMaxUsage_CSA0 rba_MultiStackTrace_CurrentCycleMaxUsage_CSA1 rba_MultiStackTrace_CurrentCycleMaxUsage_CSA2 rba_MultiStackTrace_CurrentCycleMaxUsage_User0 rba_MultiStackTrace_CurrentCycleMaxUsage_User1 
        rba_MultiStackTrace_CurrentCycleMaxUsage_User2 rba_MultiStackTrace_LifeTimeMaxUsage_CSA0 rba_MultiStackTrace_LifeTimeMaxUsage_CSA1 rba_MultiStackTrace_LifeTimeMaxUsage_CSA2 rba_MultiStackTrace_LifeTimeMaxUsage_User0 
        rba_MultiStackTrace_LifeTimeMaxUsage_User1 rba_MultiStackTrace_LifeTimeMaxUsage_User2 rba_OsShell_Cntr1000msTask rba_OsShell_Cntr100msTask rba_OsShell_Cntr100msTaskUntrusted 
        rba_OsShell_Cntr10msTask rba_OsShell_Cntr10msTaskUntrusted rba_OsShell_Cntr1msTask rba_OsShell_Cntr1msTaskUntrusted rba_OsShell_Cntr200msTask 
        rba_OsShell_Cntr20msTask rba_OsShell_Cntr20msTaskUntrusted rba_OsShell_Cntr2msTask rba_OsShell_Cntr2msTaskUntrusted rba_OsShell_Cntr40msTask 
        rba_OsShell_Cntr40msTaskUntrusted rba_OsShell_Cntr50msTask rba_OsShell_Cntr50msTaskUntrusted rba_OsShell_Cntr5msTask rba_OsShell_Cntr5msTaskUntrusted 
        rba_OsShell_Cntr80msTask rba_OsShell_Cntr80msTaskUntrusted rba_OsShell_CntrAsw1BgTask rba_OsShell_CntrAswBgTaskUntrusted rba_OsShell_CntrAswShutdownTaskUntrusted 
        rba_OsShell_CntrBswBgTask rba_OsShell_CntrCalWup100msTask rba_OsShell_CntrCalWup10msTask rba_OsShell_CntrCalWup20msTask rba_OsShell_CntrCalWup2msTask 
        rba_OsShell_CntrCalWupAsw110msTask rba_OsShell_CntrCalWupAsw210msTask rba_OsShell_CntrCalWupAsw310msTask rba_OsShell_CntrCalWupBgTask rba_OsShell_CntrCalWupIniEndTask 
        rba_OsShell_CntrCalWupIniTask rba_OsShell_CntrDSMClearTask rba_OsShell_CntrDSMReiniTask rba_OsShell_CntrEngReStrtModeMTask rba_OsShell_CntrEngReStrtTask 
        rba_OsShell_CntrEpmNoSyncTask rba_OsShell_CntrErrLimit1000msTask rba_OsShell_CntrErrLimit100msTask rba_OsShell_CntrErrLimit100msTaskUntrusted rba_OsShell_CntrErrLimit10msTask 
        rba_OsShell_CntrErrLimit10msTaskUntrusted rba_OsShell_CntrErrLimit1msTask rba_OsShell_CntrErrLimit1msTaskUntrusted rba_OsShell_CntrErrLimit200msTask rba_OsShell_CntrErrLimit20msTask 
        rba_OsShell_CntrErrLimit20msTaskUntrusted rba_OsShell_CntrErrLimit2msTask rba_OsShell_CntrErrLimit2msTaskUntrusted rba_OsShell_CntrErrLimit40msTask rba_OsShell_CntrErrLimit40msTaskUntrusted 
        rba_OsShell_CntrErrLimit50msTask rba_OsShell_CntrErrLimit50msTaskUntrusted rba_OsShell_CntrErrLimit5msTask rba_OsShell_CntrErrLimit5msTaskUntrusted rba_OsShell_CntrErrLimit80msTask 
        rba_OsShell_CntrErrLimit80msTaskUntrusted rba_OsShell_CntrErrLimitAsw1BgTask rba_OsShell_CntrErrLimitAswBgTaskUntrusted rba_OsShell_CntrErrLimitAswShutdownTaskUntrusted rba_OsShell_CntrErrLimitBswBgTask 
        rba_OsShell_CntrErrLimitCalWup100msTask rba_OsShell_CntrErrLimitCalWup10msTask rba_OsShell_CntrErrLimitCalWup20msTask rba_OsShell_CntrErrLimitCalWup2msTask rba_OsShell_CntrErrLimitCalWupAsw110msTask 
        rba_OsShell_CntrErrLimitCalWupAsw210msTask rba_OsShell_CntrErrLimitCalWupAsw310msTask rba_OsShell_CntrErrLimitCalWupBgTask rba_OsShell_CntrErrLimitCalWupIniEndTask rba_OsShell_CntrErrLimitCalWupIniTask 
        rba_OsShell_CntrErrLimitDSMClearTask rba_OsShell_CntrErrLimitDSMReiniTask rba_OsShell_CntrErrLimitEngReStrtModeMTask rba_OsShell_CntrErrLimitEngReStrtTask rba_OsShell_CntrErrLimitEpmNoSyncTask 
        rba_OsShell_CntrErrLimitInfraAsw1App10msTask rba_OsShell_CntrErrLimitInfraAsw2App10msTask rba_OsShell_CntrErrLimitInfraAsw3App10msTask rba_OsShell_CntrErrLimitInfraBswApp10msTask rba_OsShell_CntrErrLimitIniDrvTask 
        rba_OsShell_CntrErrLimitIniDrvTaskUntrusted rba_OsShell_CntrErrLimitIniEndTask rba_OsShell_CntrErrLimitIniTask rba_OsShell_CntrErrLimitMoTask rba_OsShell_CntrErrLimitPreIniDrvTask 
        rba_OsShell_CntrErrLimitRbrAfterRunTask rba_OsShell_CntrErrLimitReIniModeMTask rba_OsShell_CntrErrLimitReIniTask rba_OsShell_CntrErrLimitShutdown10msTask rba_OsShell_CntrErrLimitShutdownAsw1Task 
        rba_OsShell_CntrErrLimitShutdownAsw2Task rba_OsShell_CntrErrLimitShutdownAsw3Task rba_OsShell_CntrErrLimitShutdownBswTask rba_OsShell_CntrErrLimitShutdownSeqTask rba_OsShell_CntrErrLimitWdgMTask 
        rba_OsShell_CntrErrLimitcore2100msTask rba_OsShell_CntrErrLimitcore210msTask rba_OsShell_CntrErrLimitcore21msTask rba_OsShell_CntrErrLimitcore220msTask rba_OsShell_CntrErrLimitcore22msTask 
        rba_OsShell_CntrErrLimitcore240msTask rba_OsShell_CntrErrLimitcore250msTask rba_OsShell_CntrErrLimitcore25msTask rba_OsShell_CntrErrLimitcore280msTask rba_OsShell_CntrErrLimitcore2AswBgTask 
        rba_OsShell_CntrErrLimitcore2AswShutdownTask rba_OsShell_CntrErrLimitcore2IniDrvTask rba_OsShell_CntrErrLimitcore3100msTask rba_OsShell_CntrErrLimitcore310msTask rba_OsShell_CntrErrLimitcore31msTask 
        rba_OsShell_CntrErrLimitcore320msTask rba_OsShell_CntrErrLimitcore32msTask rba_OsShell_CntrErrLimitcore340msTask rba_OsShell_CntrErrLimitcore350msTask rba_OsShell_CntrErrLimitcore35msTask 
        rba_OsShell_CntrErrLimitcore380msTask rba_OsShell_CntrErrLimitcore3AswBgTask rba_OsShell_CntrErrLimitcore3AswShutdownTask rba_OsShell_CntrErrLimitcore3IniDrvTask rba_OsShell_CntrInfraAsw1App10msTask 
        rba_OsShell_CntrInfraAsw2App10msTask rba_OsShell_CntrInfraAsw3App10msTask rba_OsShell_CntrInfraBswApp10msTask rba_OsShell_CntrIniDrvTask rba_OsShell_CntrIniDrvTaskUntrusted 
        rba_OsShell_CntrIniEndTask rba_OsShell_CntrIniTask rba_OsShell_CntrMoTask rba_OsShell_CntrPreIniDrvTask rba_OsShell_CntrRbrAfterRunTask 
        rba_OsShell_CntrReIniModeMTask rba_OsShell_CntrReIniTask rba_OsShell_CntrShutdown10msTask rba_OsShell_CntrShutdownAsw1Task rba_OsShell_CntrShutdownAsw2Task 
        rba_OsShell_CntrShutdownAsw3Task rba_OsShell_CntrShutdownBswTask rba_OsShell_CntrShutdownSeqTask rba_OsShell_CntrWdgMTask rba_OsShell_Cntrcore2100msTask 
        rba_OsShell_Cntrcore210msTask rba_OsShell_Cntrcore21msTask rba_OsShell_Cntrcore220msTask rba_OsShell_Cntrcore22msTask rba_OsShell_Cntrcore240msTask 
        rba_OsShell_Cntrcore250msTask rba_OsShell_Cntrcore25msTask rba_OsShell_Cntrcore280msTask rba_OsShell_Cntrcore2AswBgTask rba_OsShell_Cntrcore2AswShutdownTask 
        rba_OsShell_Cntrcore2IniDrvTask rba_OsShell_Cntrcore3100msTask rba_OsShell_Cntrcore310msTask rba_OsShell_Cntrcore31msTask rba_OsShell_Cntrcore320msTask 
        rba_OsShell_Cntrcore32msTask rba_OsShell_Cntrcore340msTask rba_OsShell_Cntrcore350msTask rba_OsShell_Cntrcore35msTask rba_OsShell_Cntrcore380msTask 
        rba_OsShell_Cntrcore3AswBgTask rba_OsShell_Cntrcore3AswShutdownTask rba_OsShell_Cntrcore3IniDrvTask rba_OsShell_cntrErrAccess rba_OsShell_cntrErrCallevel 
        rba_OsShell_cntrErrId rba_OsShell_cntrErrLimitSum rba_OsShell_cntrErrNoFunc rba_OsShell_cntrErrResource rba_OsShell_cntrErrState 
        rba_OsShell_cntrErrSum rba_OsShell_cntrErrValue rba_OsShell_tiPowerOnFrst10ms rba_OsShell_tiResetFrst10ms 
    /end LOC_MEASUREMENT

    FUNCTION_VERSION    "1.38.0__RC40_FFI"

/end FUNCTION

/begin FUNCTION

    rba_Runtime
    "3.11.0  McFunction rba_Runtime Created by MCFunctionUpdater"
    /begin LOC_MEASUREMENT
        rba_Runtime_Input_st.configs_ast[0].idElement_u32 rba_Runtime_Input_st.configs_ast[0].idTask_u16 rba_Runtime_Input_st.ctTrigger_u8 rba_Runtime_Input_st.tiSampleTime_u8 rba_Runtime_MonIsr_ast[0].ctCallsTotal_u32 
        rba_Runtime_MonIsr_ast[0].ctCalls_u32 rba_Runtime_MonIsr_ast[0].ctSampleProcessed_u8 rba_Runtime_MonIsr_ast[0].internal_st.ctBeginCalls_u32 rba_Runtime_MonIsr_ast[0].internal_st.tiAccuRT_u32 rba_Runtime_MonIsr_ast[0].internal_st.tiBeginFree_u32 
        rba_Runtime_MonIsr_ast[0].loadPer64k_u16 rba_Runtime_MonIsr_ast[0].tiAvrgRT_u32 rba_Runtime_MonIsr_ast[0].tiCurRT_u32 rba_Runtime_MonIsr_ast[0].tiMaxRT_u32 rba_Runtime_MonIsr_ast[0].tiMinRT_u32 
        rba_Runtime_MonIsr_ast[1].ctCallsTotal_u32 rba_Runtime_MonIsr_ast[1].ctCalls_u32 rba_Runtime_MonIsr_ast[1].ctSampleProcessed_u8 rba_Runtime_MonIsr_ast[1].internal_st.ctBeginCalls_u32 rba_Runtime_MonIsr_ast[1].internal_st.tiAccuRT_u32 
        rba_Runtime_MonIsr_ast[1].internal_st.tiBeginFree_u32 rba_Runtime_MonIsr_ast[1].loadPer64k_u16 rba_Runtime_MonIsr_ast[1].tiAvrgRT_u32 rba_Runtime_MonIsr_ast[1].tiCurRT_u32 rba_Runtime_MonIsr_ast[1].tiMaxRT_u32 
        rba_Runtime_MonIsr_ast[1].tiMinRT_u32 rba_Runtime_MonIsr_ast[2].ctCallsTotal_u32 rba_Runtime_MonIsr_ast[2].ctCalls_u32 rba_Runtime_MonIsr_ast[2].ctSampleProcessed_u8 rba_Runtime_MonIsr_ast[2].internal_st.ctBeginCalls_u32 
        rba_Runtime_MonIsr_ast[2].internal_st.tiAccuRT_u32 rba_Runtime_MonIsr_ast[2].internal_st.tiBeginFree_u32 rba_Runtime_MonIsr_ast[2].loadPer64k_u16 rba_Runtime_MonIsr_ast[2].tiAvrgRT_u32 rba_Runtime_MonIsr_ast[2].tiCurRT_u32 
        rba_Runtime_MonIsr_ast[2].tiMaxRT_u32 rba_Runtime_MonIsr_ast[2].tiMinRT_u32 rba_Runtime_MonSystemLoadPer64k_au16 rba_Runtime_MonTask_ast[0].ctCallsTotal_u32 rba_Runtime_MonTask_ast[0].ctCalls_u32 
        rba_Runtime_MonTask_ast[0].ctSampleProcessed_u8 rba_Runtime_MonTask_ast[0].internal_st.ctBeginCalls_u32 rba_Runtime_MonTask_ast[0].internal_st.tiAccuRT_u32 rba_Runtime_MonTask_ast[0].internal_st.tiBeginFree_u32 rba_Runtime_MonTask_ast[0].loadPer64k_u16 
        rba_Runtime_MonTask_ast[0].tiAvrgRT_u32 rba_Runtime_MonTask_ast[0].tiCurRT_u32 rba_Runtime_MonTask_ast[0].tiCurResponseT_u32 rba_Runtime_MonTask_ast[0].tiMaxRT_u32 rba_Runtime_MonTask_ast[0].tiMaxResponseT_u32 
        rba_Runtime_MonTask_ast[0].tiMinRT_u32 rba_Runtime_MonTask_ast[0].tiMinResponseT_u32 rba_Runtime_MonTask_ast[10].ctCallsTotal_u32 rba_Runtime_MonTask_ast[10].ctCalls_u32 rba_Runtime_MonTask_ast[10].ctSampleProcessed_u8 
        rba_Runtime_MonTask_ast[10].internal_st.ctBeginCalls_u32 rba_Runtime_MonTask_ast[10].internal_st.tiAccuRT_u32 rba_Runtime_MonTask_ast[10].internal_st.tiBeginFree_u32 rba_Runtime_MonTask_ast[10].loadPer64k_u16 rba_Runtime_MonTask_ast[10].tiAvrgRT_u32 
        rba_Runtime_MonTask_ast[10].tiCurRT_u32 rba_Runtime_MonTask_ast[10].tiCurResponseT_u32 rba_Runtime_MonTask_ast[10].tiMaxRT_u32 rba_Runtime_MonTask_ast[10].tiMaxResponseT_u32 rba_Runtime_MonTask_ast[10].tiMinRT_u32 
        rba_Runtime_MonTask_ast[10].tiMinResponseT_u32 rba_Runtime_MonTask_ast[11].ctCallsTotal_u32 rba_Runtime_MonTask_ast[11].ctCalls_u32 rba_Runtime_MonTask_ast[11].ctSampleProcessed_u8 rba_Runtime_MonTask_ast[11].internal_st.ctBeginCalls_u32 
        rba_Runtime_MonTask_ast[11].internal_st.tiAccuRT_u32 rba_Runtime_MonTask_ast[11].internal_st.tiBeginFree_u32 rba_Runtime_MonTask_ast[11].loadPer64k_u16 rba_Runtime_MonTask_ast[11].tiAvrgRT_u32 rba_Runtime_MonTask_ast[11].tiCurRT_u32 
        rba_Runtime_MonTask_ast[11].tiCurResponseT_u32 rba_Runtime_MonTask_ast[11].tiMaxRT_u32 rba_Runtime_MonTask_ast[11].tiMaxResponseT_u32 rba_Runtime_MonTask_ast[11].tiMinRT_u32 rba_Runtime_MonTask_ast[11].tiMinResponseT_u32 
        rba_Runtime_MonTask_ast[12].ctCallsTotal_u32 rba_Runtime_MonTask_ast[12].ctCalls_u32 rba_Runtime_MonTask_ast[12].ctSampleProcessed_u8 rba_Runtime_MonTask_ast[12].internal_st.ctBeginCalls_u32 rba_Runtime_MonTask_ast[12].internal_st.tiAccuRT_u32 
        rba_Runtime_MonTask_ast[12].internal_st.tiBeginFree_u32 rba_Runtime_MonTask_ast[12].loadPer64k_u16 rba_Runtime_MonTask_ast[12].tiAvrgRT_u32 rba_Runtime_MonTask_ast[12].tiCurRT_u32 rba_Runtime_MonTask_ast[12].tiCurResponseT_u32 
        rba_Runtime_MonTask_ast[12].tiMaxRT_u32 rba_Runtime_MonTask_ast[12].tiMaxResponseT_u32 rba_Runtime_MonTask_ast[12].tiMinRT_u32 rba_Runtime_MonTask_ast[12].tiMinResponseT_u32 rba_Runtime_MonTask_ast[13].ctCallsTotal_u32 
        rba_Runtime_MonTask_ast[13].ctCalls_u32 rba_Runtime_MonTask_ast[13].ctSampleProcessed_u8 rba_Runtime_MonTask_ast[13].internal_st.ctBeginCalls_u32 rba_Runtime_MonTask_ast[13].internal_st.tiAccuRT_u32 rba_Runtime_MonTask_ast[13].internal_st.tiBeginFree_u32 
        rba_Runtime_MonTask_ast[13].loadPer64k_u16 rba_Runtime_MonTask_ast[13].tiAvrgRT_u32 rba_Runtime_MonTask_ast[13].tiCurRT_u32 rba_Runtime_MonTask_ast[13].tiCurResponseT_u32 rba_Runtime_MonTask_ast[13].tiMaxRT_u32 
        rba_Runtime_MonTask_ast[13].tiMaxResponseT_u32 rba_Runtime_MonTask_ast[13].tiMinRT_u32 rba_Runtime_MonTask_ast[13].tiMinResponseT_u32 rba_Runtime_MonTask_ast[14].ctCallsTotal_u32 rba_Runtime_MonTask_ast[14].ctCalls_u32 
        rba_Runtime_MonTask_ast[14].ctSampleProcessed_u8 rba_Runtime_MonTask_ast[14].internal_st.ctBeginCalls_u32 rba_Runtime_MonTask_ast[14].internal_st.tiAccuRT_u32 rba_Runtime_MonTask_ast[14].internal_st.tiBeginFree_u32 rba_Runtime_MonTask_ast[14].loadPer64k_u16 
        rba_Runtime_MonTask_ast[14].tiAvrgRT_u32 rba_Runtime_MonTask_ast[14].tiCurRT_u32 rba_Runtime_MonTask_ast[14].tiCurResponseT_u32 rba_Runtime_MonTask_ast[14].tiMaxRT_u32 rba_Runtime_MonTask_ast[14].tiMaxResponseT_u32 
        rba_Runtime_MonTask_ast[14].tiMinRT_u32 rba_Runtime_MonTask_ast[14].tiMinResponseT_u32 rba_Runtime_MonTask_ast[15].ctCallsTotal_u32 rba_Runtime_MonTask_ast[15].ctCalls_u32 rba_Runtime_MonTask_ast[15].ctSampleProcessed_u8 
        rba_Runtime_MonTask_ast[15].internal_st.ctBeginCalls_u32 rba_Runtime_MonTask_ast[15].internal_st.tiAccuRT_u32 rba_Runtime_MonTask_ast[15].internal_st.tiBeginFree_u32 rba_Runtime_MonTask_ast[15].loadPer64k_u16 rba_Runtime_MonTask_ast[15].tiAvrgRT_u32 
        rba_Runtime_MonTask_ast[15].tiCurRT_u32 rba_Runtime_MonTask_ast[15].tiCurResponseT_u32 rba_Runtime_MonTask_ast[15].tiMaxRT_u32 rba_Runtime_MonTask_ast[15].tiMaxResponseT_u32 rba_Runtime_MonTask_ast[15].tiMinRT_u32 
        rba_Runtime_MonTask_ast[15].tiMinResponseT_u32 rba_Runtime_MonTask_ast[16].ctCallsTotal_u32 rba_Runtime_MonTask_ast[16].ctCalls_u32 rba_Runtime_MonTask_ast[16].ctSampleProcessed_u8 rba_Runtime_MonTask_ast[16].internal_st.ctBeginCalls_u32 
        rba_Runtime_MonTask_ast[16].internal_st.tiAccuRT_u32 rba_Runtime_MonTask_ast[16].internal_st.tiBeginFree_u32 rba_Runtime_MonTask_ast[16].loadPer64k_u16 rba_Runtime_MonTask_ast[16].tiAvrgRT_u32 rba_Runtime_MonTask_ast[16].tiCurRT_u32 
        rba_Runtime_MonTask_ast[16].tiCurResponseT_u32 rba_Runtime_MonTask_ast[16].tiMaxRT_u32 rba_Runtime_MonTask_ast[16].tiMaxResponseT_u32 rba_Runtime_MonTask_ast[16].tiMinRT_u32 rba_Runtime_MonTask_ast[16].tiMinResponseT_u32 
        rba_Runtime_MonTask_ast[17].ctCallsTotal_u32 rba_Runtime_MonTask_ast[17].ctCalls_u32 rba_Runtime_MonTask_ast[17].ctSampleProcessed_u8 rba_Runtime_MonTask_ast[17].internal_st.ctBeginCalls_u32 rba_Runtime_MonTask_ast[17].internal_st.tiAccuRT_u32 
        rba_Runtime_MonTask_ast[17].internal_st.tiBeginFree_u32 rba_Runtime_MonTask_ast[17].loadPer64k_u16 rba_Runtime_MonTask_ast[17].tiAvrgRT_u32 rba_Runtime_MonTask_ast[17].tiCurRT_u32 rba_Runtime_MonTask_ast[17].tiCurResponseT_u32 
        rba_Runtime_MonTask_ast[17].tiMaxRT_u32 rba_Runtime_MonTask_ast[17].tiMaxResponseT_u32 rba_Runtime_MonTask_ast[17].tiMinRT_u32 rba_Runtime_MonTask_ast[17].tiMinResponseT_u32 rba_Runtime_MonTask_ast[18].ctCallsTotal_u32 
        rba_Runtime_MonTask_ast[18].ctCalls_u32 rba_Runtime_MonTask_ast[18].ctSampleProcessed_u8 rba_Runtime_MonTask_ast[18].internal_st.ctBeginCalls_u32 rba_Runtime_MonTask_ast[18].internal_st.tiAccuRT_u32 rba_Runtime_MonTask_ast[18].internal_st.tiBeginFree_u32 
        rba_Runtime_MonTask_ast[18].loadPer64k_u16 rba_Runtime_MonTask_ast[18].tiAvrgRT_u32 rba_Runtime_MonTask_ast[18].tiCurRT_u32 rba_Runtime_MonTask_ast[18].tiCurResponseT_u32 rba_Runtime_MonTask_ast[18].tiMaxRT_u32 
        rba_Runtime_MonTask_ast[18].tiMaxResponseT_u32 rba_Runtime_MonTask_ast[18].tiMinRT_u32 rba_Runtime_MonTask_ast[18].tiMinResponseT_u32 rba_Runtime_MonTask_ast[19].ctCallsTotal_u32 rba_Runtime_MonTask_ast[19].ctCalls_u32 
        rba_Runtime_MonTask_ast[19].ctSampleProcessed_u8 rba_Runtime_MonTask_ast[19].internal_st.ctBeginCalls_u32 rba_Runtime_MonTask_ast[19].internal_st.tiAccuRT_u32 rba_Runtime_MonTask_ast[19].internal_st.tiBeginFree_u32 rba_Runtime_MonTask_ast[19].loadPer64k_u16 
        rba_Runtime_MonTask_ast[19].tiAvrgRT_u32 rba_Runtime_MonTask_ast[19].tiCurRT_u32 rba_Runtime_MonTask_ast[19].tiCurResponseT_u32 rba_Runtime_MonTask_ast[19].tiMaxRT_u32 rba_Runtime_MonTask_ast[19].tiMaxResponseT_u32 
        rba_Runtime_MonTask_ast[19].tiMinRT_u32 rba_Runtime_MonTask_ast[19].tiMinResponseT_u32 rba_Runtime_MonTask_ast[1].ctCallsTotal_u32 rba_Runtime_MonTask_ast[1].ctCalls_u32 rba_Runtime_MonTask_ast[1].ctSampleProcessed_u8 
        rba_Runtime_MonTask_ast[1].internal_st.ctBeginCalls_u32 rba_Runtime_MonTask_ast[1].internal_st.tiAccuRT_u32 rba_Runtime_MonTask_ast[1].internal_st.tiBeginFree_u32 rba_Runtime_MonTask_ast[1].loadPer64k_u16 rba_Runtime_MonTask_ast[1].tiAvrgRT_u32 
        rba_Runtime_MonTask_ast[1].tiCurRT_u32 rba_Runtime_MonTask_ast[1].tiCurResponseT_u32 rba_Runtime_MonTask_ast[1].tiMaxRT_u32 rba_Runtime_MonTask_ast[1].tiMaxResponseT_u32 rba_Runtime_MonTask_ast[1].tiMinRT_u32 
        rba_Runtime_MonTask_ast[1].tiMinResponseT_u32 rba_Runtime_MonTask_ast[20].ctCallsTotal_u32 rba_Runtime_MonTask_ast[20].ctCalls_u32 rba_Runtime_MonTask_ast[20].ctSampleProcessed_u8 rba_Runtime_MonTask_ast[20].internal_st.ctBeginCalls_u32 
        rba_Runtime_MonTask_ast[20].internal_st.tiAccuRT_u32 rba_Runtime_MonTask_ast[20].internal_st.tiBeginFree_u32 rba_Runtime_MonTask_ast[20].loadPer64k_u16 rba_Runtime_MonTask_ast[20].tiAvrgRT_u32 rba_Runtime_MonTask_ast[20].tiCurRT_u32 
        rba_Runtime_MonTask_ast[20].tiCurResponseT_u32 rba_Runtime_MonTask_ast[20].tiMaxRT_u32 rba_Runtime_MonTask_ast[20].tiMaxResponseT_u32 rba_Runtime_MonTask_ast[20].tiMinRT_u32 rba_Runtime_MonTask_ast[20].tiMinResponseT_u32 
        rba_Runtime_MonTask_ast[21].ctCallsTotal_u32 rba_Runtime_MonTask_ast[21].ctCalls_u32 rba_Runtime_MonTask_ast[21].ctSampleProcessed_u8 rba_Runtime_MonTask_ast[21].internal_st.ctBeginCalls_u32 rba_Runtime_MonTask_ast[21].internal_st.tiAccuRT_u32 
        rba_Runtime_MonTask_ast[21].internal_st.tiBeginFree_u32 rba_Runtime_MonTask_ast[21].loadPer64k_u16 rba_Runtime_MonTask_ast[21].tiAvrgRT_u32 rba_Runtime_MonTask_ast[21].tiCurRT_u32 rba_Runtime_MonTask_ast[21].tiCurResponseT_u32 
        rba_Runtime_MonTask_ast[21].tiMaxRT_u32 rba_Runtime_MonTask_ast[21].tiMaxResponseT_u32 rba_Runtime_MonTask_ast[21].tiMinRT_u32 rba_Runtime_MonTask_ast[21].tiMinResponseT_u32 rba_Runtime_MonTask_ast[22].ctCallsTotal_u32 
        rba_Runtime_MonTask_ast[22].ctCalls_u32 rba_Runtime_MonTask_ast[22].ctSampleProcessed_u8 rba_Runtime_MonTask_ast[22].internal_st.ctBeginCalls_u32 rba_Runtime_MonTask_ast[22].internal_st.tiAccuRT_u32 rba_Runtime_MonTask_ast[22].internal_st.tiBeginFree_u32 
        rba_Runtime_MonTask_ast[22].loadPer64k_u16 rba_Runtime_MonTask_ast[22].tiAvrgRT_u32 rba_Runtime_MonTask_ast[22].tiCurRT_u32 rba_Runtime_MonTask_ast[22].tiCurResponseT_u32 rba_Runtime_MonTask_ast[22].tiMaxRT_u32 
        rba_Runtime_MonTask_ast[22].tiMaxResponseT_u32 rba_Runtime_MonTask_ast[22].tiMinRT_u32 rba_Runtime_MonTask_ast[22].tiMinResponseT_u32 rba_Runtime_MonTask_ast[23].ctCallsTotal_u32 rba_Runtime_MonTask_ast[23].ctCalls_u32 
        rba_Runtime_MonTask_ast[23].ctSampleProcessed_u8 rba_Runtime_MonTask_ast[23].internal_st.ctBeginCalls_u32 rba_Runtime_MonTask_ast[23].internal_st.tiAccuRT_u32 rba_Runtime_MonTask_ast[23].internal_st.tiBeginFree_u32 rba_Runtime_MonTask_ast[23].loadPer64k_u16 
        rba_Runtime_MonTask_ast[23].tiAvrgRT_u32 rba_Runtime_MonTask_ast[23].tiCurRT_u32 rba_Runtime_MonTask_ast[23].tiCurResponseT_u32 rba_Runtime_MonTask_ast[23].tiMaxRT_u32 rba_Runtime_MonTask_ast[23].tiMaxResponseT_u32 
        rba_Runtime_MonTask_ast[23].tiMinRT_u32 rba_Runtime_MonTask_ast[23].tiMinResponseT_u32 rba_Runtime_MonTask_ast[24].ctCallsTotal_u32 rba_Runtime_MonTask_ast[24].ctCalls_u32 rba_Runtime_MonTask_ast[24].ctSampleProcessed_u8 
        rba_Runtime_MonTask_ast[24].internal_st.ctBeginCalls_u32 rba_Runtime_MonTask_ast[24].internal_st.tiAccuRT_u32 rba_Runtime_MonTask_ast[24].internal_st.tiBeginFree_u32 rba_Runtime_MonTask_ast[24].loadPer64k_u16 rba_Runtime_MonTask_ast[24].tiAvrgRT_u32 
        rba_Runtime_MonTask_ast[24].tiCurRT_u32 rba_Runtime_MonTask_ast[24].tiCurResponseT_u32 rba_Runtime_MonTask_ast[24].tiMaxRT_u32 rba_Runtime_MonTask_ast[24].tiMaxResponseT_u32 rba_Runtime_MonTask_ast[24].tiMinRT_u32 
        rba_Runtime_MonTask_ast[24].tiMinResponseT_u32 rba_Runtime_MonTask_ast[25].ctCallsTotal_u32 rba_Runtime_MonTask_ast[25].ctCalls_u32 rba_Runtime_MonTask_ast[25].ctSampleProcessed_u8 rba_Runtime_MonTask_ast[25].internal_st.ctBeginCalls_u32 
        rba_Runtime_MonTask_ast[25].internal_st.tiAccuRT_u32 rba_Runtime_MonTask_ast[25].internal_st.tiBeginFree_u32 rba_Runtime_MonTask_ast[25].loadPer64k_u16 rba_Runtime_MonTask_ast[25].tiAvrgRT_u32 rba_Runtime_MonTask_ast[25].tiCurRT_u32 
        rba_Runtime_MonTask_ast[25].tiCurResponseT_u32 rba_Runtime_MonTask_ast[25].tiMaxRT_u32 rba_Runtime_MonTask_ast[25].tiMaxResponseT_u32 rba_Runtime_MonTask_ast[25].tiMinRT_u32 rba_Runtime_MonTask_ast[25].tiMinResponseT_u32 
        rba_Runtime_MonTask_ast[26].ctCallsTotal_u32 rba_Runtime_MonTask_ast[26].ctCalls_u32 rba_Runtime_MonTask_ast[26].ctSampleProcessed_u8 rba_Runtime_MonTask_ast[26].internal_st.ctBeginCalls_u32 rba_Runtime_MonTask_ast[26].internal_st.tiAccuRT_u32 
        rba_Runtime_MonTask_ast[26].internal_st.tiBeginFree_u32 rba_Runtime_MonTask_ast[26].loadPer64k_u16 rba_Runtime_MonTask_ast[26].tiAvrgRT_u32 rba_Runtime_MonTask_ast[26].tiCurRT_u32 rba_Runtime_MonTask_ast[26].tiCurResponseT_u32 
        rba_Runtime_MonTask_ast[26].tiMaxRT_u32 rba_Runtime_MonTask_ast[26].tiMaxResponseT_u32 rba_Runtime_MonTask_ast[26].tiMinRT_u32 rba_Runtime_MonTask_ast[26].tiMinResponseT_u32 rba_Runtime_MonTask_ast[27].ctCallsTotal_u32 
        rba_Runtime_MonTask_ast[27].ctCalls_u32 rba_Runtime_MonTask_ast[27].ctSampleProcessed_u8 rba_Runtime_MonTask_ast[27].internal_st.ctBeginCalls_u32 rba_Runtime_MonTask_ast[27].internal_st.tiAccuRT_u32 rba_Runtime_MonTask_ast[27].internal_st.tiBeginFree_u32 
        rba_Runtime_MonTask_ast[27].loadPer64k_u16 rba_Runtime_MonTask_ast[27].tiAvrgRT_u32 rba_Runtime_MonTask_ast[27].tiCurRT_u32 rba_Runtime_MonTask_ast[27].tiCurResponseT_u32 rba_Runtime_MonTask_ast[27].tiMaxRT_u32 
        rba_Runtime_MonTask_ast[27].tiMaxResponseT_u32 rba_Runtime_MonTask_ast[27].tiMinRT_u32 rba_Runtime_MonTask_ast[27].tiMinResponseT_u32 rba_Runtime_MonTask_ast[28].ctCallsTotal_u32 rba_Runtime_MonTask_ast[28].ctCalls_u32 
        rba_Runtime_MonTask_ast[28].ctSampleProcessed_u8 rba_Runtime_MonTask_ast[28].internal_st.ctBeginCalls_u32 rba_Runtime_MonTask_ast[28].internal_st.tiAccuRT_u32 rba_Runtime_MonTask_ast[28].internal_st.tiBeginFree_u32 rba_Runtime_MonTask_ast[28].loadPer64k_u16 
        rba_Runtime_MonTask_ast[28].tiAvrgRT_u32 rba_Runtime_MonTask_ast[28].tiCurRT_u32 rba_Runtime_MonTask_ast[28].tiCurResponseT_u32 rba_Runtime_MonTask_ast[28].tiMaxRT_u32 rba_Runtime_MonTask_ast[28].tiMaxResponseT_u32 
        rba_Runtime_MonTask_ast[28].tiMinRT_u32 rba_Runtime_MonTask_ast[28].tiMinResponseT_u32 rba_Runtime_MonTask_ast[29].ctCallsTotal_u32 rba_Runtime_MonTask_ast[29].ctCalls_u32 rba_Runtime_MonTask_ast[29].ctSampleProcessed_u8 
        rba_Runtime_MonTask_ast[29].internal_st.ctBeginCalls_u32 rba_Runtime_MonTask_ast[29].internal_st.tiAccuRT_u32 rba_Runtime_MonTask_ast[29].internal_st.tiBeginFree_u32 rba_Runtime_MonTask_ast[29].loadPer64k_u16 rba_Runtime_MonTask_ast[29].tiAvrgRT_u32 
        rba_Runtime_MonTask_ast[29].tiCurRT_u32 rba_Runtime_MonTask_ast[29].tiCurResponseT_u32 rba_Runtime_MonTask_ast[29].tiMaxRT_u32 rba_Runtime_MonTask_ast[29].tiMaxResponseT_u32 rba_Runtime_MonTask_ast[29].tiMinRT_u32 
        rba_Runtime_MonTask_ast[29].tiMinResponseT_u32 rba_Runtime_MonTask_ast[2].ctCallsTotal_u32 rba_Runtime_MonTask_ast[2].ctCalls_u32 rba_Runtime_MonTask_ast[2].ctSampleProcessed_u8 rba_Runtime_MonTask_ast[2].internal_st.ctBeginCalls_u32 
        rba_Runtime_MonTask_ast[2].internal_st.tiAccuRT_u32 rba_Runtime_MonTask_ast[2].internal_st.tiBeginFree_u32 rba_Runtime_MonTask_ast[2].loadPer64k_u16 rba_Runtime_MonTask_ast[2].tiAvrgRT_u32 rba_Runtime_MonTask_ast[2].tiCurRT_u32 
        rba_Runtime_MonTask_ast[2].tiCurResponseT_u32 rba_Runtime_MonTask_ast[2].tiMaxRT_u32 rba_Runtime_MonTask_ast[2].tiMaxResponseT_u32 rba_Runtime_MonTask_ast[2].tiMinRT_u32 rba_Runtime_MonTask_ast[2].tiMinResponseT_u32 
        rba_Runtime_MonTask_ast[30].ctCallsTotal_u32 rba_Runtime_MonTask_ast[30].ctCalls_u32 rba_Runtime_MonTask_ast[30].ctSampleProcessed_u8 rba_Runtime_MonTask_ast[30].internal_st.ctBeginCalls_u32 rba_Runtime_MonTask_ast[30].internal_st.tiAccuRT_u32 
        rba_Runtime_MonTask_ast[30].internal_st.tiBeginFree_u32 rba_Runtime_MonTask_ast[30].loadPer64k_u16 rba_Runtime_MonTask_ast[30].tiAvrgRT_u32 rba_Runtime_MonTask_ast[30].tiCurRT_u32 rba_Runtime_MonTask_ast[30].tiCurResponseT_u32 
        rba_Runtime_MonTask_ast[30].tiMaxRT_u32 rba_Runtime_MonTask_ast[30].tiMaxResponseT_u32 rba_Runtime_MonTask_ast[30].tiMinRT_u32 rba_Runtime_MonTask_ast[30].tiMinResponseT_u32 rba_Runtime_MonTask_ast[31].ctCallsTotal_u32 
        rba_Runtime_MonTask_ast[31].ctCalls_u32 rba_Runtime_MonTask_ast[31].ctSampleProcessed_u8 rba_Runtime_MonTask_ast[31].internal_st.ctBeginCalls_u32 rba_Runtime_MonTask_ast[31].internal_st.tiAccuRT_u32 rba_Runtime_MonTask_ast[31].internal_st.tiBeginFree_u32 
        rba_Runtime_MonTask_ast[31].loadPer64k_u16 rba_Runtime_MonTask_ast[31].tiAvrgRT_u32 rba_Runtime_MonTask_ast[31].tiCurRT_u32 rba_Runtime_MonTask_ast[31].tiCurResponseT_u32 rba_Runtime_MonTask_ast[31].tiMaxRT_u32 
        rba_Runtime_MonTask_ast[31].tiMaxResponseT_u32 rba_Runtime_MonTask_ast[31].tiMinRT_u32 rba_Runtime_MonTask_ast[31].tiMinResponseT_u32 rba_Runtime_MonTask_ast[32].ctCallsTotal_u32 rba_Runtime_MonTask_ast[32].ctCalls_u32 
        rba_Runtime_MonTask_ast[32].ctSampleProcessed_u8 rba_Runtime_MonTask_ast[32].internal_st.ctBeginCalls_u32 rba_Runtime_MonTask_ast[32].internal_st.tiAccuRT_u32 rba_Runtime_MonTask_ast[32].internal_st.tiBeginFree_u32 rba_Runtime_MonTask_ast[32].loadPer64k_u16 
        rba_Runtime_MonTask_ast[32].tiAvrgRT_u32 rba_Runtime_MonTask_ast[32].tiCurRT_u32 rba_Runtime_MonTask_ast[32].tiCurResponseT_u32 rba_Runtime_MonTask_ast[32].tiMaxRT_u32 rba_Runtime_MonTask_ast[32].tiMaxResponseT_u32 
        rba_Runtime_MonTask_ast[32].tiMinRT_u32 rba_Runtime_MonTask_ast[32].tiMinResponseT_u32 rba_Runtime_MonTask_ast[33].ctCallsTotal_u32 rba_Runtime_MonTask_ast[33].ctCalls_u32 rba_Runtime_MonTask_ast[33].ctSampleProcessed_u8 
        rba_Runtime_MonTask_ast[33].internal_st.ctBeginCalls_u32 rba_Runtime_MonTask_ast[33].internal_st.tiAccuRT_u32 rba_Runtime_MonTask_ast[33].internal_st.tiBeginFree_u32 rba_Runtime_MonTask_ast[33].loadPer64k_u16 rba_Runtime_MonTask_ast[33].tiAvrgRT_u32 
        rba_Runtime_MonTask_ast[33].tiCurRT_u32 rba_Runtime_MonTask_ast[33].tiCurResponseT_u32 rba_Runtime_MonTask_ast[33].tiMaxRT_u32 rba_Runtime_MonTask_ast[33].tiMaxResponseT_u32 rba_Runtime_MonTask_ast[33].tiMinRT_u32 
        rba_Runtime_MonTask_ast[33].tiMinResponseT_u32 rba_Runtime_MonTask_ast[34].ctCallsTotal_u32 rba_Runtime_MonTask_ast[34].ctCalls_u32 rba_Runtime_MonTask_ast[34].ctSampleProcessed_u8 rba_Runtime_MonTask_ast[34].internal_st.ctBeginCalls_u32 
        rba_Runtime_MonTask_ast[34].internal_st.tiAccuRT_u32 rba_Runtime_MonTask_ast[34].internal_st.tiBeginFree_u32 rba_Runtime_MonTask_ast[34].loadPer64k_u16 rba_Runtime_MonTask_ast[34].tiAvrgRT_u32 rba_Runtime_MonTask_ast[34].tiCurRT_u32 
        rba_Runtime_MonTask_ast[34].tiCurResponseT_u32 rba_Runtime_MonTask_ast[34].tiMaxRT_u32 rba_Runtime_MonTask_ast[34].tiMaxResponseT_u32 rba_Runtime_MonTask_ast[34].tiMinRT_u32 rba_Runtime_MonTask_ast[34].tiMinResponseT_u32 
        rba_Runtime_MonTask_ast[35].ctCallsTotal_u32 rba_Runtime_MonTask_ast[35].ctCalls_u32 rba_Runtime_MonTask_ast[35].ctSampleProcessed_u8 rba_Runtime_MonTask_ast[35].internal_st.ctBeginCalls_u32 rba_Runtime_MonTask_ast[35].internal_st.tiAccuRT_u32 
        rba_Runtime_MonTask_ast[35].internal_st.tiBeginFree_u32 rba_Runtime_MonTask_ast[35].loadPer64k_u16 rba_Runtime_MonTask_ast[35].tiAvrgRT_u32 rba_Runtime_MonTask_ast[35].tiCurRT_u32 rba_Runtime_MonTask_ast[35].tiCurResponseT_u32 
        rba_Runtime_MonTask_ast[35].tiMaxRT_u32 rba_Runtime_MonTask_ast[35].tiMaxResponseT_u32 rba_Runtime_MonTask_ast[35].tiMinRT_u32 rba_Runtime_MonTask_ast[35].tiMinResponseT_u32 rba_Runtime_MonTask_ast[36].ctCallsTotal_u32 
        rba_Runtime_MonTask_ast[36].ctCalls_u32 rba_Runtime_MonTask_ast[36].ctSampleProcessed_u8 rba_Runtime_MonTask_ast[36].internal_st.ctBeginCalls_u32 rba_Runtime_MonTask_ast[36].internal_st.tiAccuRT_u32 rba_Runtime_MonTask_ast[36].internal_st.tiBeginFree_u32 
        rba_Runtime_MonTask_ast[36].loadPer64k_u16 rba_Runtime_MonTask_ast[36].tiAvrgRT_u32 rba_Runtime_MonTask_ast[36].tiCurRT_u32 rba_Runtime_MonTask_ast[36].tiCurResponseT_u32 rba_Runtime_MonTask_ast[36].tiMaxRT_u32 
        rba_Runtime_MonTask_ast[36].tiMaxResponseT_u32 rba_Runtime_MonTask_ast[36].tiMinRT_u32 rba_Runtime_MonTask_ast[36].tiMinResponseT_u32 rba_Runtime_MonTask_ast[37].ctCallsTotal_u32 rba_Runtime_MonTask_ast[37].ctCalls_u32 
        rba_Runtime_MonTask_ast[37].ctSampleProcessed_u8 rba_Runtime_MonTask_ast[37].internal_st.ctBeginCalls_u32 rba_Runtime_MonTask_ast[37].internal_st.tiAccuRT_u32 rba_Runtime_MonTask_ast[37].internal_st.tiBeginFree_u32 rba_Runtime_MonTask_ast[37].loadPer64k_u16 
        rba_Runtime_MonTask_ast[37].tiAvrgRT_u32 rba_Runtime_MonTask_ast[37].tiCurRT_u32 rba_Runtime_MonTask_ast[37].tiCurResponseT_u32 rba_Runtime_MonTask_ast[37].tiMaxRT_u32 rba_Runtime_MonTask_ast[37].tiMaxResponseT_u32 
        rba_Runtime_MonTask_ast[37].tiMinRT_u32 rba_Runtime_MonTask_ast[37].tiMinResponseT_u32 rba_Runtime_MonTask_ast[38].ctCallsTotal_u32 rba_Runtime_MonTask_ast[38].ctCalls_u32 rba_Runtime_MonTask_ast[38].ctSampleProcessed_u8 
        rba_Runtime_MonTask_ast[38].internal_st.ctBeginCalls_u32 rba_Runtime_MonTask_ast[38].internal_st.tiAccuRT_u32 rba_Runtime_MonTask_ast[38].internal_st.tiBeginFree_u32 rba_Runtime_MonTask_ast[38].loadPer64k_u16 rba_Runtime_MonTask_ast[38].tiAvrgRT_u32 
        rba_Runtime_MonTask_ast[38].tiCurRT_u32 rba_Runtime_MonTask_ast[38].tiCurResponseT_u32 rba_Runtime_MonTask_ast[38].tiMaxRT_u32 rba_Runtime_MonTask_ast[38].tiMaxResponseT_u32 rba_Runtime_MonTask_ast[38].tiMinRT_u32 
        rba_Runtime_MonTask_ast[38].tiMinResponseT_u32 rba_Runtime_MonTask_ast[39].ctCallsTotal_u32 rba_Runtime_MonTask_ast[39].ctCalls_u32 rba_Runtime_MonTask_ast[39].ctSampleProcessed_u8 rba_Runtime_MonTask_ast[39].internal_st.ctBeginCalls_u32 
        rba_Runtime_MonTask_ast[39].internal_st.tiAccuRT_u32 rba_Runtime_MonTask_ast[39].internal_st.tiBeginFree_u32 rba_Runtime_MonTask_ast[39].loadPer64k_u16 rba_Runtime_MonTask_ast[39].tiAvrgRT_u32 rba_Runtime_MonTask_ast[39].tiCurRT_u32 
        rba_Runtime_MonTask_ast[39].tiCurResponseT_u32 rba_Runtime_MonTask_ast[39].tiMaxRT_u32 rba_Runtime_MonTask_ast[39].tiMaxResponseT_u32 rba_Runtime_MonTask_ast[39].tiMinRT_u32 rba_Runtime_MonTask_ast[39].tiMinResponseT_u32 
        rba_Runtime_MonTask_ast[3].ctCallsTotal_u32 rba_Runtime_MonTask_ast[3].ctCalls_u32 rba_Runtime_MonTask_ast[3].ctSampleProcessed_u8 rba_Runtime_MonTask_ast[3].internal_st.ctBeginCalls_u32 rba_Runtime_MonTask_ast[3].internal_st.tiAccuRT_u32 
        rba_Runtime_MonTask_ast[3].internal_st.tiBeginFree_u32 rba_Runtime_MonTask_ast[3].loadPer64k_u16 rba_Runtime_MonTask_ast[3].tiAvrgRT_u32 rba_Runtime_MonTask_ast[3].tiCurRT_u32 rba_Runtime_MonTask_ast[3].tiCurResponseT_u32 
        rba_Runtime_MonTask_ast[3].tiMaxRT_u32 rba_Runtime_MonTask_ast[3].tiMaxResponseT_u32 rba_Runtime_MonTask_ast[3].tiMinRT_u32 rba_Runtime_MonTask_ast[3].tiMinResponseT_u32 rba_Runtime_MonTask_ast[40].ctCallsTotal_u32 
        rba_Runtime_MonTask_ast[40].ctCalls_u32 rba_Runtime_MonTask_ast[40].ctSampleProcessed_u8 rba_Runtime_MonTask_ast[40].internal_st.ctBeginCalls_u32 rba_Runtime_MonTask_ast[40].internal_st.tiAccuRT_u32 rba_Runtime_MonTask_ast[40].internal_st.tiBeginFree_u32 
        rba_Runtime_MonTask_ast[40].loadPer64k_u16 rba_Runtime_MonTask_ast[40].tiAvrgRT_u32 rba_Runtime_MonTask_ast[40].tiCurRT_u32 rba_Runtime_MonTask_ast[40].tiCurResponseT_u32 rba_Runtime_MonTask_ast[40].tiMaxRT_u32 
        rba_Runtime_MonTask_ast[40].tiMaxResponseT_u32 rba_Runtime_MonTask_ast[40].tiMinRT_u32 rba_Runtime_MonTask_ast[40].tiMinResponseT_u32 rba_Runtime_MonTask_ast[41].ctCallsTotal_u32 rba_Runtime_MonTask_ast[41].ctCalls_u32 
        rba_Runtime_MonTask_ast[41].ctSampleProcessed_u8 rba_Runtime_MonTask_ast[41].internal_st.ctBeginCalls_u32 rba_Runtime_MonTask_ast[41].internal_st.tiAccuRT_u32 rba_Runtime_MonTask_ast[41].internal_st.tiBeginFree_u32 rba_Runtime_MonTask_ast[41].loadPer64k_u16 
        rba_Runtime_MonTask_ast[41].tiAvrgRT_u32 rba_Runtime_MonTask_ast[41].tiCurRT_u32 rba_Runtime_MonTask_ast[41].tiCurResponseT_u32 rba_Runtime_MonTask_ast[41].tiMaxRT_u32 rba_Runtime_MonTask_ast[41].tiMaxResponseT_u32 
        rba_Runtime_MonTask_ast[41].tiMinRT_u32 rba_Runtime_MonTask_ast[41].tiMinResponseT_u32 rba_Runtime_MonTask_ast[42].ctCallsTotal_u32 rba_Runtime_MonTask_ast[42].ctCalls_u32 rba_Runtime_MonTask_ast[42].ctSampleProcessed_u8 
        rba_Runtime_MonTask_ast[42].internal_st.ctBeginCalls_u32 rba_Runtime_MonTask_ast[42].internal_st.tiAccuRT_u32 rba_Runtime_MonTask_ast[42].internal_st.tiBeginFree_u32 rba_Runtime_MonTask_ast[42].loadPer64k_u16 rba_Runtime_MonTask_ast[42].tiAvrgRT_u32 
        rba_Runtime_MonTask_ast[42].tiCurRT_u32 rba_Runtime_MonTask_ast[42].tiCurResponseT_u32 rba_Runtime_MonTask_ast[42].tiMaxRT_u32 rba_Runtime_MonTask_ast[42].tiMaxResponseT_u32 rba_Runtime_MonTask_ast[42].tiMinRT_u32 
        rba_Runtime_MonTask_ast[42].tiMinResponseT_u32 rba_Runtime_MonTask_ast[43].ctCallsTotal_u32 rba_Runtime_MonTask_ast[43].ctCalls_u32 rba_Runtime_MonTask_ast[43].ctSampleProcessed_u8 rba_Runtime_MonTask_ast[43].internal_st.ctBeginCalls_u32 
        rba_Runtime_MonTask_ast[43].internal_st.tiAccuRT_u32 rba_Runtime_MonTask_ast[43].internal_st.tiBeginFree_u32 rba_Runtime_MonTask_ast[43].loadPer64k_u16 rba_Runtime_MonTask_ast[43].tiAvrgRT_u32 rba_Runtime_MonTask_ast[43].tiCurRT_u32 
        rba_Runtime_MonTask_ast[43].tiCurResponseT_u32 rba_Runtime_MonTask_ast[43].tiMaxRT_u32 rba_Runtime_MonTask_ast[43].tiMaxResponseT_u32 rba_Runtime_MonTask_ast[43].tiMinRT_u32 rba_Runtime_MonTask_ast[43].tiMinResponseT_u32 
        rba_Runtime_MonTask_ast[44].ctCallsTotal_u32 rba_Runtime_MonTask_ast[44].ctCalls_u32 rba_Runtime_MonTask_ast[44].ctSampleProcessed_u8 rba_Runtime_MonTask_ast[44].internal_st.ctBeginCalls_u32 rba_Runtime_MonTask_ast[44].internal_st.tiAccuRT_u32 
        rba_Runtime_MonTask_ast[44].internal_st.tiBeginFree_u32 rba_Runtime_MonTask_ast[44].loadPer64k_u16 rba_Runtime_MonTask_ast[44].tiAvrgRT_u32 rba_Runtime_MonTask_ast[44].tiCurRT_u32 rba_Runtime_MonTask_ast[44].tiCurResponseT_u32 
        rba_Runtime_MonTask_ast[44].tiMaxRT_u32 rba_Runtime_MonTask_ast[44].tiMaxResponseT_u32 rba_Runtime_MonTask_ast[44].tiMinRT_u32 rba_Runtime_MonTask_ast[44].tiMinResponseT_u32 rba_Runtime_MonTask_ast[45].ctCallsTotal_u32 
        rba_Runtime_MonTask_ast[45].ctCalls_u32 rba_Runtime_MonTask_ast[45].ctSampleProcessed_u8 rba_Runtime_MonTask_ast[45].internal_st.ctBeginCalls_u32 rba_Runtime_MonTask_ast[45].internal_st.tiAccuRT_u32 rba_Runtime_MonTask_ast[45].internal_st.tiBeginFree_u32 
        rba_Runtime_MonTask_ast[45].loadPer64k_u16 rba_Runtime_MonTask_ast[45].tiAvrgRT_u32 rba_Runtime_MonTask_ast[45].tiCurRT_u32 rba_Runtime_MonTask_ast[45].tiCurResponseT_u32 rba_Runtime_MonTask_ast[45].tiMaxRT_u32 
        rba_Runtime_MonTask_ast[45].tiMaxResponseT_u32 rba_Runtime_MonTask_ast[45].tiMinRT_u32 rba_Runtime_MonTask_ast[45].tiMinResponseT_u32 rba_Runtime_MonTask_ast[46].ctCallsTotal_u32 rba_Runtime_MonTask_ast[46].ctCalls_u32 
        rba_Runtime_MonTask_ast[46].ctSampleProcessed_u8 rba_Runtime_MonTask_ast[46].internal_st.ctBeginCalls_u32 rba_Runtime_MonTask_ast[46].internal_st.tiAccuRT_u32 rba_Runtime_MonTask_ast[46].internal_st.tiBeginFree_u32 rba_Runtime_MonTask_ast[46].loadPer64k_u16 
        rba_Runtime_MonTask_ast[46].tiAvrgRT_u32 rba_Runtime_MonTask_ast[46].tiCurRT_u32 rba_Runtime_MonTask_ast[46].tiCurResponseT_u32 rba_Runtime_MonTask_ast[46].tiMaxRT_u32 rba_Runtime_MonTask_ast[46].tiMaxResponseT_u32 
        rba_Runtime_MonTask_ast[46].tiMinRT_u32 rba_Runtime_MonTask_ast[46].tiMinResponseT_u32 rba_Runtime_MonTask_ast[47].ctCallsTotal_u32 rba_Runtime_MonTask_ast[47].ctCalls_u32 rba_Runtime_MonTask_ast[47].ctSampleProcessed_u8 
        rba_Runtime_MonTask_ast[47].internal_st.ctBeginCalls_u32 rba_Runtime_MonTask_ast[47].internal_st.tiAccuRT_u32 rba_Runtime_MonTask_ast[47].internal_st.tiBeginFree_u32 rba_Runtime_MonTask_ast[47].loadPer64k_u16 rba_Runtime_MonTask_ast[47].tiAvrgRT_u32 
        rba_Runtime_MonTask_ast[47].tiCurRT_u32 rba_Runtime_MonTask_ast[47].tiCurResponseT_u32 rba_Runtime_MonTask_ast[47].tiMaxRT_u32 rba_Runtime_MonTask_ast[47].tiMaxResponseT_u32 rba_Runtime_MonTask_ast[47].tiMinRT_u32 
        rba_Runtime_MonTask_ast[47].tiMinResponseT_u32 rba_Runtime_MonTask_ast[48].ctCallsTotal_u32 rba_Runtime_MonTask_ast[48].ctCalls_u32 rba_Runtime_MonTask_ast[48].ctSampleProcessed_u8 rba_Runtime_MonTask_ast[48].internal_st.ctBeginCalls_u32 
        rba_Runtime_MonTask_ast[48].internal_st.tiAccuRT_u32 rba_Runtime_MonTask_ast[48].internal_st.tiBeginFree_u32 rba_Runtime_MonTask_ast[48].loadPer64k_u16 rba_Runtime_MonTask_ast[48].tiAvrgRT_u32 rba_Runtime_MonTask_ast[48].tiCurRT_u32 
        rba_Runtime_MonTask_ast[48].tiCurResponseT_u32 rba_Runtime_MonTask_ast[48].tiMaxRT_u32 rba_Runtime_MonTask_ast[48].tiMaxResponseT_u32 rba_Runtime_MonTask_ast[48].tiMinRT_u32 rba_Runtime_MonTask_ast[48].tiMinResponseT_u32 
        rba_Runtime_MonTask_ast[49].ctCallsTotal_u32 rba_Runtime_MonTask_ast[49].ctCalls_u32 rba_Runtime_MonTask_ast[49].ctSampleProcessed_u8 rba_Runtime_MonTask_ast[49].internal_st.ctBeginCalls_u32 rba_Runtime_MonTask_ast[49].internal_st.tiAccuRT_u32 
        rba_Runtime_MonTask_ast[49].internal_st.tiBeginFree_u32 rba_Runtime_MonTask_ast[49].loadPer64k_u16 rba_Runtime_MonTask_ast[49].tiAvrgRT_u32 rba_Runtime_MonTask_ast[49].tiCurRT_u32 rba_Runtime_MonTask_ast[49].tiCurResponseT_u32 
        rba_Runtime_MonTask_ast[49].tiMaxRT_u32 rba_Runtime_MonTask_ast[49].tiMaxResponseT_u32 rba_Runtime_MonTask_ast[49].tiMinRT_u32 rba_Runtime_MonTask_ast[49].tiMinResponseT_u32 rba_Runtime_MonTask_ast[4].ctCallsTotal_u32 
        rba_Runtime_MonTask_ast[4].ctCalls_u32 rba_Runtime_MonTask_ast[4].ctSampleProcessed_u8 rba_Runtime_MonTask_ast[4].internal_st.ctBeginCalls_u32 rba_Runtime_MonTask_ast[4].internal_st.tiAccuRT_u32 rba_Runtime_MonTask_ast[4].internal_st.tiBeginFree_u32 
        rba_Runtime_MonTask_ast[4].loadPer64k_u16 rba_Runtime_MonTask_ast[4].tiAvrgRT_u32 rba_Runtime_MonTask_ast[4].tiCurRT_u32 rba_Runtime_MonTask_ast[4].tiCurResponseT_u32 rba_Runtime_MonTask_ast[4].tiMaxRT_u32 
        rba_Runtime_MonTask_ast[4].tiMaxResponseT_u32 rba_Runtime_MonTask_ast[4].tiMinRT_u32 rba_Runtime_MonTask_ast[4].tiMinResponseT_u32 rba_Runtime_MonTask_ast[50].ctCallsTotal_u32 rba_Runtime_MonTask_ast[50].ctCalls_u32 
        rba_Runtime_MonTask_ast[50].ctSampleProcessed_u8 rba_Runtime_MonTask_ast[50].internal_st.ctBeginCalls_u32 rba_Runtime_MonTask_ast[50].internal_st.tiAccuRT_u32 rba_Runtime_MonTask_ast[50].internal_st.tiBeginFree_u32 rba_Runtime_MonTask_ast[50].loadPer64k_u16 
        rba_Runtime_MonTask_ast[50].tiAvrgRT_u32 rba_Runtime_MonTask_ast[50].tiCurRT_u32 rba_Runtime_MonTask_ast[50].tiCurResponseT_u32 rba_Runtime_MonTask_ast[50].tiMaxRT_u32 rba_Runtime_MonTask_ast[50].tiMaxResponseT_u32 
        rba_Runtime_MonTask_ast[50].tiMinRT_u32 rba_Runtime_MonTask_ast[50].tiMinResponseT_u32 rba_Runtime_MonTask_ast[51].ctCallsTotal_u32 rba_Runtime_MonTask_ast[51].ctCalls_u32 rba_Runtime_MonTask_ast[51].ctSampleProcessed_u8 
        rba_Runtime_MonTask_ast[51].internal_st.ctBeginCalls_u32 rba_Runtime_MonTask_ast[51].internal_st.tiAccuRT_u32 rba_Runtime_MonTask_ast[51].internal_st.tiBeginFree_u32 rba_Runtime_MonTask_ast[51].loadPer64k_u16 rba_Runtime_MonTask_ast[51].tiAvrgRT_u32 
        rba_Runtime_MonTask_ast[51].tiCurRT_u32 rba_Runtime_MonTask_ast[51].tiCurResponseT_u32 rba_Runtime_MonTask_ast[51].tiMaxRT_u32 rba_Runtime_MonTask_ast[51].tiMaxResponseT_u32 rba_Runtime_MonTask_ast[51].tiMinRT_u32 
        rba_Runtime_MonTask_ast[51].tiMinResponseT_u32 rba_Runtime_MonTask_ast[52].ctCallsTotal_u32 rba_Runtime_MonTask_ast[52].ctCalls_u32 rba_Runtime_MonTask_ast[52].ctSampleProcessed_u8 rba_Runtime_MonTask_ast[52].internal_st.ctBeginCalls_u32 
        rba_Runtime_MonTask_ast[52].internal_st.tiAccuRT_u32 rba_Runtime_MonTask_ast[52].internal_st.tiBeginFree_u32 rba_Runtime_MonTask_ast[52].loadPer64k_u16 rba_Runtime_MonTask_ast[52].tiAvrgRT_u32 rba_Runtime_MonTask_ast[52].tiCurRT_u32 
        rba_Runtime_MonTask_ast[52].tiCurResponseT_u32 rba_Runtime_MonTask_ast[52].tiMaxRT_u32 rba_Runtime_MonTask_ast[52].tiMaxResponseT_u32 rba_Runtime_MonTask_ast[52].tiMinRT_u32 rba_Runtime_MonTask_ast[52].tiMinResponseT_u32 
        rba_Runtime_MonTask_ast[53].ctCallsTotal_u32 rba_Runtime_MonTask_ast[53].ctCalls_u32 rba_Runtime_MonTask_ast[53].ctSampleProcessed_u8 rba_Runtime_MonTask_ast[53].internal_st.ctBeginCalls_u32 rba_Runtime_MonTask_ast[53].internal_st.tiAccuRT_u32 
        rba_Runtime_MonTask_ast[53].internal_st.tiBeginFree_u32 rba_Runtime_MonTask_ast[53].loadPer64k_u16 rba_Runtime_MonTask_ast[53].tiAvrgRT_u32 rba_Runtime_MonTask_ast[53].tiCurRT_u32 rba_Runtime_MonTask_ast[53].tiCurResponseT_u32 
        rba_Runtime_MonTask_ast[53].tiMaxRT_u32 rba_Runtime_MonTask_ast[53].tiMaxResponseT_u32 rba_Runtime_MonTask_ast[53].tiMinRT_u32 rba_Runtime_MonTask_ast[53].tiMinResponseT_u32 rba_Runtime_MonTask_ast[54].ctCallsTotal_u32 
        rba_Runtime_MonTask_ast[54].ctCalls_u32 rba_Runtime_MonTask_ast[54].ctSampleProcessed_u8 rba_Runtime_MonTask_ast[54].internal_st.ctBeginCalls_u32 rba_Runtime_MonTask_ast[54].internal_st.tiAccuRT_u32 rba_Runtime_MonTask_ast[54].internal_st.tiBeginFree_u32 
        rba_Runtime_MonTask_ast[54].loadPer64k_u16 rba_Runtime_MonTask_ast[54].tiAvrgRT_u32 rba_Runtime_MonTask_ast[54].tiCurRT_u32 rba_Runtime_MonTask_ast[54].tiCurResponseT_u32 rba_Runtime_MonTask_ast[54].tiMaxRT_u32 
        rba_Runtime_MonTask_ast[54].tiMaxResponseT_u32 rba_Runtime_MonTask_ast[54].tiMinRT_u32 rba_Runtime_MonTask_ast[54].tiMinResponseT_u32 rba_Runtime_MonTask_ast[55].ctCallsTotal_u32 rba_Runtime_MonTask_ast[55].ctCalls_u32 
        rba_Runtime_MonTask_ast[55].ctSampleProcessed_u8 rba_Runtime_MonTask_ast[55].internal_st.ctBeginCalls_u32 rba_Runtime_MonTask_ast[55].internal_st.tiAccuRT_u32 rba_Runtime_MonTask_ast[55].internal_st.tiBeginFree_u32 rba_Runtime_MonTask_ast[55].loadPer64k_u16 
        rba_Runtime_MonTask_ast[55].tiAvrgRT_u32 rba_Runtime_MonTask_ast[55].tiCurRT_u32 rba_Runtime_MonTask_ast[55].tiCurResponseT_u32 rba_Runtime_MonTask_ast[55].tiMaxRT_u32 rba_Runtime_MonTask_ast[55].tiMaxResponseT_u32 
        rba_Runtime_MonTask_ast[55].tiMinRT_u32 rba_Runtime_MonTask_ast[55].tiMinResponseT_u32 rba_Runtime_MonTask_ast[56].ctCallsTotal_u32 rba_Runtime_MonTask_ast[56].ctCalls_u32 rba_Runtime_MonTask_ast[56].ctSampleProcessed_u8 
        rba_Runtime_MonTask_ast[56].internal_st.ctBeginCalls_u32 rba_Runtime_MonTask_ast[56].internal_st.tiAccuRT_u32 rba_Runtime_MonTask_ast[56].internal_st.tiBeginFree_u32 rba_Runtime_MonTask_ast[56].loadPer64k_u16 rba_Runtime_MonTask_ast[56].tiAvrgRT_u32 
        rba_Runtime_MonTask_ast[56].tiCurRT_u32 rba_Runtime_MonTask_ast[56].tiCurResponseT_u32 rba_Runtime_MonTask_ast[56].tiMaxRT_u32 rba_Runtime_MonTask_ast[56].tiMaxResponseT_u32 rba_Runtime_MonTask_ast[56].tiMinRT_u32 
        rba_Runtime_MonTask_ast[56].tiMinResponseT_u32 rba_Runtime_MonTask_ast[57].ctCallsTotal_u32 rba_Runtime_MonTask_ast[57].ctCalls_u32 rba_Runtime_MonTask_ast[57].ctSampleProcessed_u8 rba_Runtime_MonTask_ast[57].internal_st.ctBeginCalls_u32 
        rba_Runtime_MonTask_ast[57].internal_st.tiAccuRT_u32 rba_Runtime_MonTask_ast[57].internal_st.tiBeginFree_u32 rba_Runtime_MonTask_ast[57].loadPer64k_u16 rba_Runtime_MonTask_ast[57].tiAvrgRT_u32 rba_Runtime_MonTask_ast[57].tiCurRT_u32 
        rba_Runtime_MonTask_ast[57].tiCurResponseT_u32 rba_Runtime_MonTask_ast[57].tiMaxRT_u32 rba_Runtime_MonTask_ast[57].tiMaxResponseT_u32 rba_Runtime_MonTask_ast[57].tiMinRT_u32 rba_Runtime_MonTask_ast[57].tiMinResponseT_u32 
        rba_Runtime_MonTask_ast[58].ctCallsTotal_u32 rba_Runtime_MonTask_ast[58].ctCalls_u32 rba_Runtime_MonTask_ast[58].ctSampleProcessed_u8 rba_Runtime_MonTask_ast[58].internal_st.ctBeginCalls_u32 rba_Runtime_MonTask_ast[58].internal_st.tiAccuRT_u32 
        rba_Runtime_MonTask_ast[58].internal_st.tiBeginFree_u32 rba_Runtime_MonTask_ast[58].loadPer64k_u16 rba_Runtime_MonTask_ast[58].tiAvrgRT_u32 rba_Runtime_MonTask_ast[58].tiCurRT_u32 rba_Runtime_MonTask_ast[58].tiCurResponseT_u32 
        rba_Runtime_MonTask_ast[58].tiMaxRT_u32 rba_Runtime_MonTask_ast[58].tiMaxResponseT_u32 rba_Runtime_MonTask_ast[58].tiMinRT_u32 rba_Runtime_MonTask_ast[58].tiMinResponseT_u32 rba_Runtime_MonTask_ast[59].ctCallsTotal_u32 
        rba_Runtime_MonTask_ast[59].ctCalls_u32 rba_Runtime_MonTask_ast[59].ctSampleProcessed_u8 rba_Runtime_MonTask_ast[59].internal_st.ctBeginCalls_u32 rba_Runtime_MonTask_ast[59].internal_st.tiAccuRT_u32 rba_Runtime_MonTask_ast[59].internal_st.tiBeginFree_u32 
        rba_Runtime_MonTask_ast[59].loadPer64k_u16 rba_Runtime_MonTask_ast[59].tiAvrgRT_u32 rba_Runtime_MonTask_ast[59].tiCurRT_u32 rba_Runtime_MonTask_ast[59].tiCurResponseT_u32 rba_Runtime_MonTask_ast[59].tiMaxRT_u32 
        rba_Runtime_MonTask_ast[59].tiMaxResponseT_u32 rba_Runtime_MonTask_ast[59].tiMinRT_u32 rba_Runtime_MonTask_ast[59].tiMinResponseT_u32 rba_Runtime_MonTask_ast[5].ctCallsTotal_u32 rba_Runtime_MonTask_ast[5].ctCalls_u32 
        rba_Runtime_MonTask_ast[5].ctSampleProcessed_u8 rba_Runtime_MonTask_ast[5].internal_st.ctBeginCalls_u32 rba_Runtime_MonTask_ast[5].internal_st.tiAccuRT_u32 rba_Runtime_MonTask_ast[5].internal_st.tiBeginFree_u32 rba_Runtime_MonTask_ast[5].loadPer64k_u16 
        rba_Runtime_MonTask_ast[5].tiAvrgRT_u32 rba_Runtime_MonTask_ast[5].tiCurRT_u32 rba_Runtime_MonTask_ast[5].tiCurResponseT_u32 rba_Runtime_MonTask_ast[5].tiMaxRT_u32 rba_Runtime_MonTask_ast[5].tiMaxResponseT_u32 
        rba_Runtime_MonTask_ast[5].tiMinRT_u32 rba_Runtime_MonTask_ast[5].tiMinResponseT_u32 rba_Runtime_MonTask_ast[60].ctCallsTotal_u32 rba_Runtime_MonTask_ast[60].ctCalls_u32 rba_Runtime_MonTask_ast[60].ctSampleProcessed_u8 
        rba_Runtime_MonTask_ast[60].internal_st.ctBeginCalls_u32 rba_Runtime_MonTask_ast[60].internal_st.tiAccuRT_u32 rba_Runtime_MonTask_ast[60].internal_st.tiBeginFree_u32 rba_Runtime_MonTask_ast[60].loadPer64k_u16 rba_Runtime_MonTask_ast[60].tiAvrgRT_u32 
        rba_Runtime_MonTask_ast[60].tiCurRT_u32 rba_Runtime_MonTask_ast[60].tiCurResponseT_u32 rba_Runtime_MonTask_ast[60].tiMaxRT_u32 rba_Runtime_MonTask_ast[60].tiMaxResponseT_u32 rba_Runtime_MonTask_ast[60].tiMinRT_u32 
        rba_Runtime_MonTask_ast[60].tiMinResponseT_u32 rba_Runtime_MonTask_ast[61].ctCallsTotal_u32 rba_Runtime_MonTask_ast[61].ctCalls_u32 rba_Runtime_MonTask_ast[61].ctSampleProcessed_u8 rba_Runtime_MonTask_ast[61].internal_st.ctBeginCalls_u32 
        rba_Runtime_MonTask_ast[61].internal_st.tiAccuRT_u32 rba_Runtime_MonTask_ast[61].internal_st.tiBeginFree_u32 rba_Runtime_MonTask_ast[61].loadPer64k_u16 rba_Runtime_MonTask_ast[61].tiAvrgRT_u32 rba_Runtime_MonTask_ast[61].tiCurRT_u32 
        rba_Runtime_MonTask_ast[61].tiCurResponseT_u32 rba_Runtime_MonTask_ast[61].tiMaxRT_u32 rba_Runtime_MonTask_ast[61].tiMaxResponseT_u32 rba_Runtime_MonTask_ast[61].tiMinRT_u32 rba_Runtime_MonTask_ast[61].tiMinResponseT_u32 
        rba_Runtime_MonTask_ast[62].ctCallsTotal_u32 rba_Runtime_MonTask_ast[62].ctCalls_u32 rba_Runtime_MonTask_ast[62].ctSampleProcessed_u8 rba_Runtime_MonTask_ast[62].internal_st.ctBeginCalls_u32 rba_Runtime_MonTask_ast[62].internal_st.tiAccuRT_u32 
        rba_Runtime_MonTask_ast[62].internal_st.tiBeginFree_u32 rba_Runtime_MonTask_ast[62].loadPer64k_u16 rba_Runtime_MonTask_ast[62].tiAvrgRT_u32 rba_Runtime_MonTask_ast[62].tiCurRT_u32 rba_Runtime_MonTask_ast[62].tiCurResponseT_u32 
        rba_Runtime_MonTask_ast[62].tiMaxRT_u32 rba_Runtime_MonTask_ast[62].tiMaxResponseT_u32 rba_Runtime_MonTask_ast[62].tiMinRT_u32 rba_Runtime_MonTask_ast[62].tiMinResponseT_u32 rba_Runtime_MonTask_ast[63].ctCallsTotal_u32 
        rba_Runtime_MonTask_ast[63].ctCalls_u32 rba_Runtime_MonTask_ast[63].ctSampleProcessed_u8 rba_Runtime_MonTask_ast[63].internal_st.ctBeginCalls_u32 rba_Runtime_MonTask_ast[63].internal_st.tiAccuRT_u32 rba_Runtime_MonTask_ast[63].internal_st.tiBeginFree_u32 
        rba_Runtime_MonTask_ast[63].loadPer64k_u16 rba_Runtime_MonTask_ast[63].tiAvrgRT_u32 rba_Runtime_MonTask_ast[63].tiCurRT_u32 rba_Runtime_MonTask_ast[63].tiCurResponseT_u32 rba_Runtime_MonTask_ast[63].tiMaxRT_u32 
        rba_Runtime_MonTask_ast[63].tiMaxResponseT_u32 rba_Runtime_MonTask_ast[63].tiMinRT_u32 rba_Runtime_MonTask_ast[63].tiMinResponseT_u32 rba_Runtime_MonTask_ast[64].ctCallsTotal_u32 rba_Runtime_MonTask_ast[64].ctCalls_u32 
        rba_Runtime_MonTask_ast[64].ctSampleProcessed_u8 rba_Runtime_MonTask_ast[64].internal_st.ctBeginCalls_u32 rba_Runtime_MonTask_ast[64].internal_st.tiAccuRT_u32 rba_Runtime_MonTask_ast[64].internal_st.tiBeginFree_u32 rba_Runtime_MonTask_ast[64].loadPer64k_u16 
        rba_Runtime_MonTask_ast[64].tiAvrgRT_u32 rba_Runtime_MonTask_ast[64].tiCurRT_u32 rba_Runtime_MonTask_ast[64].tiCurResponseT_u32 rba_Runtime_MonTask_ast[64].tiMaxRT_u32 rba_Runtime_MonTask_ast[64].tiMaxResponseT_u32 
        rba_Runtime_MonTask_ast[64].tiMinRT_u32 rba_Runtime_MonTask_ast[64].tiMinResponseT_u32 rba_Runtime_MonTask_ast[6].ctCallsTotal_u32 rba_Runtime_MonTask_ast[6].ctCalls_u32 rba_Runtime_MonTask_ast[6].ctSampleProcessed_u8 
        rba_Runtime_MonTask_ast[6].internal_st.ctBeginCalls_u32 rba_Runtime_MonTask_ast[6].internal_st.tiAccuRT_u32 rba_Runtime_MonTask_ast[6].internal_st.tiBeginFree_u32 rba_Runtime_MonTask_ast[6].loadPer64k_u16 rba_Runtime_MonTask_ast[6].tiAvrgRT_u32 
        rba_Runtime_MonTask_ast[6].tiCurRT_u32 rba_Runtime_MonTask_ast[6].tiCurResponseT_u32 rba_Runtime_MonTask_ast[6].tiMaxRT_u32 rba_Runtime_MonTask_ast[6].tiMaxResponseT_u32 rba_Runtime_MonTask_ast[6].tiMinRT_u32 
        rba_Runtime_MonTask_ast[6].tiMinResponseT_u32 rba_Runtime_MonTask_ast[7].ctCallsTotal_u32 rba_Runtime_MonTask_ast[7].ctCalls_u32 rba_Runtime_MonTask_ast[7].ctSampleProcessed_u8 rba_Runtime_MonTask_ast[7].internal_st.ctBeginCalls_u32 
        rba_Runtime_MonTask_ast[7].internal_st.tiAccuRT_u32 rba_Runtime_MonTask_ast[7].internal_st.tiBeginFree_u32 rba_Runtime_MonTask_ast[7].loadPer64k_u16 rba_Runtime_MonTask_ast[7].tiAvrgRT_u32 rba_Runtime_MonTask_ast[7].tiCurRT_u32 
        rba_Runtime_MonTask_ast[7].tiCurResponseT_u32 rba_Runtime_MonTask_ast[7].tiMaxRT_u32 rba_Runtime_MonTask_ast[7].tiMaxResponseT_u32 rba_Runtime_MonTask_ast[7].tiMinRT_u32 rba_Runtime_MonTask_ast[7].tiMinResponseT_u32 
        rba_Runtime_MonTask_ast[8].ctCallsTotal_u32 rba_Runtime_MonTask_ast[8].ctCalls_u32 rba_Runtime_MonTask_ast[8].ctSampleProcessed_u8 rba_Runtime_MonTask_ast[8].internal_st.ctBeginCalls_u32 rba_Runtime_MonTask_ast[8].internal_st.tiAccuRT_u32 
        rba_Runtime_MonTask_ast[8].internal_st.tiBeginFree_u32 rba_Runtime_MonTask_ast[8].loadPer64k_u16 rba_Runtime_MonTask_ast[8].tiAvrgRT_u32 rba_Runtime_MonTask_ast[8].tiCurRT_u32 rba_Runtime_MonTask_ast[8].tiCurResponseT_u32 
        rba_Runtime_MonTask_ast[8].tiMaxRT_u32 rba_Runtime_MonTask_ast[8].tiMaxResponseT_u32 rba_Runtime_MonTask_ast[8].tiMinRT_u32 rba_Runtime_MonTask_ast[8].tiMinResponseT_u32 rba_Runtime_MonTask_ast[9].ctCallsTotal_u32 
        rba_Runtime_MonTask_ast[9].ctCalls_u32 rba_Runtime_MonTask_ast[9].ctSampleProcessed_u8 rba_Runtime_MonTask_ast[9].internal_st.ctBeginCalls_u32 rba_Runtime_MonTask_ast[9].internal_st.tiAccuRT_u32 rba_Runtime_MonTask_ast[9].internal_st.tiBeginFree_u32 
        rba_Runtime_MonTask_ast[9].loadPer64k_u16 rba_Runtime_MonTask_ast[9].tiAvrgRT_u32 rba_Runtime_MonTask_ast[9].tiCurRT_u32 rba_Runtime_MonTask_ast[9].tiCurResponseT_u32 rba_Runtime_MonTask_ast[9].tiMaxRT_u32 
        rba_Runtime_MonTask_ast[9].tiMaxResponseT_u32 rba_Runtime_MonTask_ast[9].tiMinRT_u32 rba_Runtime_MonTask_ast[9].tiMinResponseT_u32 rba_Runtime_Output_st.cores_ast[0].results_ast[0].ctCalls_u32 rba_Runtime_Output_st.cores_ast[0].results_ast[0].ctReentCalls_u32 
        rba_Runtime_Output_st.cores_ast[0].results_ast[0].tiAvrgCD_u32 rba_Runtime_Output_st.cores_ast[0].results_ast[0].tiAvrgRT_u32 rba_Runtime_Output_st.cores_ast[0].results_ast[0].tiMaxCD_u32 rba_Runtime_Output_st.cores_ast[0].results_ast[0].tiMaxRT_u32 rba_Runtime_Output_st.cores_ast[0].results_ast[0].tiMinCD_u32 
        rba_Runtime_Output_st.cores_ast[0].results_ast[0].tiMinRT_u32 rba_Runtime_Output_st.cores_ast[0].tiSampleDuration_u32 rba_Runtime_Output_st.cores_ast[1].results_ast[0].ctCalls_u32 rba_Runtime_Output_st.cores_ast[1].results_ast[0].ctReentCalls_u32 rba_Runtime_Output_st.cores_ast[1].results_ast[0].tiAvrgCD_u32 
        rba_Runtime_Output_st.cores_ast[1].results_ast[0].tiAvrgRT_u32 rba_Runtime_Output_st.cores_ast[1].results_ast[0].tiMaxCD_u32 rba_Runtime_Output_st.cores_ast[1].results_ast[0].tiMaxRT_u32 rba_Runtime_Output_st.cores_ast[1].results_ast[0].tiMinCD_u32 rba_Runtime_Output_st.cores_ast[1].results_ast[0].tiMinRT_u32 
        rba_Runtime_Output_st.cores_ast[1].tiSampleDuration_u32 rba_Runtime_Output_st.cores_ast[2].results_ast[0].ctCalls_u32 rba_Runtime_Output_st.cores_ast[2].results_ast[0].ctReentCalls_u32 rba_Runtime_Output_st.cores_ast[2].results_ast[0].tiAvrgCD_u32 rba_Runtime_Output_st.cores_ast[2].results_ast[0].tiAvrgRT_u32 
        rba_Runtime_Output_st.cores_ast[2].results_ast[0].tiMaxCD_u32 rba_Runtime_Output_st.cores_ast[2].results_ast[0].tiMaxRT_u32 rba_Runtime_Output_st.cores_ast[2].results_ast[0].tiMinCD_u32 rba_Runtime_Output_st.cores_ast[2].results_ast[0].tiMinRT_u32 rba_Runtime_Output_st.cores_ast[2].tiSampleDuration_u32 
        rba_Runtime_Output_st.cores_ast[3].results_ast[0].ctCalls_u32 rba_Runtime_Output_st.cores_ast[3].results_ast[0].ctReentCalls_u32 rba_Runtime_Output_st.cores_ast[3].results_ast[0].tiAvrgCD_u32 rba_Runtime_Output_st.cores_ast[3].results_ast[0].tiAvrgRT_u32 rba_Runtime_Output_st.cores_ast[3].results_ast[0].tiMaxCD_u32 
        rba_Runtime_Output_st.cores_ast[3].results_ast[0].tiMaxRT_u32 rba_Runtime_Output_st.cores_ast[3].results_ast[0].tiMinCD_u32 rba_Runtime_Output_st.cores_ast[3].results_ast[0].tiMinRT_u32 rba_Runtime_Output_st.cores_ast[3].tiSampleDuration_u32 rba_Runtime_Output_st.ctSample_u8 
        
    /end LOC_MEASUREMENT

    FUNCTION_VERSION    "3.11.0"

/end FUNCTION

/begin FUNCTION

    rba_SyC_ObservationCounter
    "1.5.1     System Control Observation Counter"
    /begin LOC_MEASUREMENT
        rba_SyC_ObservationCounters_IrrSwOffTrigEngRun_Value_MP rba_SyC_ObservationCounters_IrrSwOff_Value_MP 
    /end LOC_MEASUREMENT

    FUNCTION_VERSION    "1.5.1"

/end FUNCTION

/begin FUNCTION

    CPT_ComDia_Dcm_Rte_Adapter
    "McFunction CPT_ComDia_Dcm_Rte_Adapter Created by MCFunctionUpdater"
    /begin LOC_MEASUREMENT
        Unconnected_DcmTest_EngineSpeed Unconnected_DcmTest_Timer 
    /end LOC_MEASUREMENT

/end FUNCTION

/***********   End of merged FUNCTION blocks    ***********/
/begin FUNCTION

    AccPr
    "91.0.0    Access Protection"

    FUNCTION_VERSION "91.0.0"

/end FUNCTION

/begin FUNCTION

    AccPrAppl
    "67.1.0    Access Protection Application"

    FUNCTION_VERSION "67.1.0"

/end FUNCTION

/begin FUNCTION

    ApplDatSet
    "2.0.0     project specific data set for basic application"

    /begin LOC_MEASUREMENT
      rba_MRly_Ctrl_State_en rba_MRly_Diag_StkState_en
    /end LOC_MEASUREMENT
    FUNCTION_VERSION "2.0.0"

/end FUNCTION

/begin FUNCTION

    ATSExtd_Std
    "30000.0.0 Handling of actuator test demands with diagnostics extended"

    FUNCTION_VERSION "30000.0.0"

/end FUNCTION

/begin FUNCTION

    ATS_Std
    "30000.33.0Handling of actuator test demands with diagnostics"

    /begin DEF_CHARACTERISTIC
      ATS_Standby_Disabled_C ATS_tiTstDemHeal_C ATS_tiTstDemMax_C ATS_TmrBehaviour_C ATS_TstDemMaxEngN_C ATS_TstDemMaxVSSCDV_C
    /end DEF_CHARACTERISTIC
    /begin REF_CHARACTERISTIC
      ErrLmpMIL_ATS.LimitTypeMsk_C ErrLmpMIL_ATS.CnvNorm_C ErrLmpMIL_ATS.LowLim_C ErrLmpMIL_ATS.UpLim_C ErrLmpMIL_ATS.CnvFac_C ErrLmpMIL_ATS.CnvOfs_C
      ErrLmpMIL_ATS.DfltVal_C ErrLmpSVS_ATS.LimitTypeMsk_C ErrLmpSVS_ATS.CnvNorm_C ErrLmpSVS_ATS.LowLim_C ErrLmpSVS_ATS.UpLim_C ErrLmpSVS_ATS.CnvFac_C
      ErrLmpSVS_ATS.CnvOfs_C ErrLmpSVS_ATS.DfltVal_C StopLmp_ATS.LimitTypeMsk_C StopLmp_ATS.CnvNorm_C StopLmp_ATS.LowLim_C StopLmp_ATS.UpLim_C
      StopLmp_ATS.CnvFac_C StopLmp_ATS.CnvOfs_C StopLmp_ATS.DfltVal_C WrnLmp_ATS.LimitTypeMsk_C WrnLmp_ATS.CnvNorm_C WrnLmp_ATS.LowLim_C
      WrnLmp_ATS.UpLim_C WrnLmp_ATS.CnvFac_C WrnLmp_ATS.CnvOfs_C WrnLmp_ATS.DfltVal_C
    /end REF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Epm_nEngLRes T15_st VehV_v
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      ATS_ctCurRunTst ATS_stMon ATS_stMonTimeLimit
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      ATS_IntvVal_mp ATS_TstStatus_mp
    /end LOC_MEASUREMENT
    FUNCTION_VERSION "30000.33.0"

/end FUNCTION

/begin FUNCTION

    Avs
    "30000.15.0"

    FUNCTION_VERSION "30000.15.0"

/end FUNCTION

/begin FUNCTION

    AVSExtd_Std
    "30000.0.0 Adjustment Value Service extended"

    FUNCTION_VERSION "30000.0.0"

/end FUNCTION

/begin FUNCTION

    AVS_Std
    "30000.16.0Adjustment Value Service"

    FUNCTION_VERSION "30000.16.0"

/end FUNCTION



/begin FUNCTION

    CanTrcv
    "6.12.1_RC40_MLCAN Tranceiver Driver"

    FUNCTION_VERSION "6.12.1_RC40_ML"

/end FUNCTION

/begin FUNCTION

    CEL_Compu
    "1.258.0   DGS Computation Methods"

    FUNCTION_VERSION "1.258.0"

/end FUNCTION

/begin FUNCTION

    CEL_CompuLcy
    "1.0.0     Computation methods and SW Units with old DGS naming convention"

    FUNCTION_VERSION "1.0.0"

/end FUNCTION

/begin FUNCTION

    CEL_Const
    "1.17.0    DGS central System Constants of the category FIXED"

    /begin DEF_CHARACTERISTIC
      medc_datasetid
    /end DEF_CHARACTERISTIC
    FUNCTION_VERSION "1.17.0"

/end FUNCTION

/begin FUNCTION

    CodeGen
    "1.30.0    ASCET Automotive System Library Interface"

    FUNCTION_VERSION "1.30.0"

/end FUNCTION

/begin FUNCTION

    CodeGen_Simulink
    "1.18.0    Code generator component for Simulink Coder"

    FUNCTION_VERSION "1.18.0"

/end FUNCTION

/begin FUNCTION

    CoDsplCtl_CoErrLmp
    "30017.2.0"

    /begin IN_MEASUREMENT
      CoDsplCtl_stDiaBlnIntv ErrLmp_stSVSReq Sia_stErrLmpReq
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      CoDsplCtl_stCoErrLmp
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      CoDsplCtl_stSVSReq_mp
    /end LOC_MEASUREMENT
    FUNCTION_VERSION "30017.2.0"

/end FUNCTION

/begin FUNCTION

    ComCIL_Co
    "234.7.0   coordinator of the frame manager"

    /begin DEF_CHARACTERISTIC
      Com_flgSwvar_C
    /end DEF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      Com_flgComNEngNeut Com_flgSwvar
    /end OUT_MEASUREMENT
    FUNCTION_VERSION "234.7.0"

/end FUNCTION

/begin FUNCTION

    ComCo_Lyr
    "4200.3.0_RC40_LARGEComCo Layer"

    FUNCTION_VERSION "4200.3.0_RC40_LARGE"

/end FUNCTION



/begin FUNCTION

    Common
    "3.2.0     central header file"

    FUNCTION_VERSION "3.2.0"

/end FUNCTION

/begin FUNCTION

    CommonCELPrj
    "30059.0.0 header file for CELPrj package"

    FUNCTION_VERSION "30059.0.0"

/end FUNCTION

/begin FUNCTION

    ComScl_Appl
    "4200.11.0_RC40_LARGEApplication of ComScl Layer"

    FUNCTION_VERSION "4200.11.0_RC40_LARGE"

/end FUNCTION

/begin FUNCTION

    ConversionSpecial_CELPrj
    "30059.0.0 Conversion Formulas Special, which are migrated from GS"

    FUNCTION_VERSION "30059.0.0"

/end FUNCTION

/begin FUNCTION

    Conversion_CELPrj
    "30059.0.0 Conversion Formulas, which are migrated from GS classic"

    FUNCTION_VERSION "30059.0.0"

/end FUNCTION

/begin FUNCTION

    DcmCore_DslDsd_Appl
    "314.11.0_RC40_MLAdaptions of DcmCore Dsl and Dsd"

    /begin DEF_CHARACTERISTIC
      ComDia_nMaxServCDI_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Epm_nEng
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      BasSvr_bFuncTstReq
    /end OUT_MEASUREMENT
    FUNCTION_VERSION "314.11.0_RC40_ML"

/end FUNCTION

/begin FUNCTION

    DcmDspUDS_DID
    "101.10.0_RC40_LARGConfiguration and Implementation of the DIDs for the DCM UDS Services (RDBI, WDBI, IOCBI)"

    /begin DEF_CHARACTERISTIC
      CALIBID COMDIA_TGEFN_CA EROTAN
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      APP1_uRaw BattU_uRaw BrkP_uRaw EngDa_tEng EnvT_uRaw EpmCrS_tiIncPer
      Epm_nEng Epm_tiSpd2Zero OilP_p SyC_tiDrv T15_flgOn T15_st
      TECU_t
    /end IN_MEASUREMENT
    /begin LOC_MEASUREMENT
      DcmDspUds_DID_requestIBChk Dcm_stCallWr Dcm_stEepOrder
    /end LOC_MEASUREMENT
    FUNCTION_VERSION "101.10.0_RC40_LARG"

/end FUNCTION

/begin FUNCTION

    DDRC
    "30017.7.0 Diagnostic Debounce and Report of Check"

    /begin DEF_CHARACTERISTIC
      DDRC_DurDeb.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3DebOk_C DDRC_DurDeb.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3DebDef_C DDRC_DurDeb.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3DebOk_C DDRC_DurDeb.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3DebDef_C DDRC_DurDeb.DFC_rbr_outA01OL_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA01OL_tiDebDef_C
      DDRC_DurDeb.DFC_rbr_outA01OT_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA01OT_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA01SCB_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA01SCB_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA01SCG_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA01SCG_tiDebDef_C
      DDRC_DurDeb.DFC_rbr_outA02OL_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA02OL_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA02OR_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA02OR_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA02OT_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA02OT_tiDebDef_C
      DDRC_DurDeb.DFC_rbr_outA02SCB_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA02SCB_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA02SCG_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA02SCG_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA03OL_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA03OL_tiDebDef_C
      DDRC_DurDeb.DFC_rbr_outA03OT_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA03OT_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA03SCB_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA03SCB_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA03SCG_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA03SCG_tiDebDef_C
      DDRC_DurDeb.DFC_rbr_outA04OL_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA04OL_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA04OT_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA04OT_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA04SCB_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA04SCB_tiDebDef_C
      DDRC_DurDeb.DFC_rbr_outA04SCG_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA04SCG_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA05OL_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA05OL_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA05OR_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA05OR_tiDebDef_C
      DDRC_DurDeb.DFC_rbr_outA05OT_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA05OT_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA05SCB_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA05SCB_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA05SCG_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA05SCG_tiDebDef_C
      DDRC_DurDeb.DFC_rbr_outA06OL_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA06OL_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA06OR_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA06OR_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA06OT_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA06OT_tiDebDef_C
      DDRC_DurDeb.DFC_rbr_outA06SCB_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA06SCB_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA06SCG_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA06SCG_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA07OL_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA07OL_tiDebDef_C
      DDRC_DurDeb.DFC_rbr_outA07OT_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA07OT_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA07SCB_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA07SCB_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA07SCG_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA07SCG_tiDebDef_C
      DDRC_DurDeb.DFC_rbr_outA08OL_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA08OL_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA08OT_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA08OT_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA08SCB_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA08SCB_tiDebDef_C
      DDRC_DurDeb.DFC_rbr_outA08SCG_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA08SCG_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA09OL_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA09OL_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA09OR_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA09OR_tiDebDef_C
      DDRC_DurDeb.DFC_rbr_outA09OT_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA09OT_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA09SCB_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA09SCB_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA09SCG_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA09SCG_tiDebDef_C
      DDRC_DurDeb.DFC_rbr_outA10OL_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA10OL_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA10OT_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA10OT_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA10SCB_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA10SCB_tiDebDef_C
      DDRC_DurDeb.DFC_rbr_outA10SCG_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA10SCG_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA11OL_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA11OL_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA11OT_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA11OT_tiDebDef_C
      DDRC_DurDeb.DFC_rbr_outA11SCB_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA11SCB_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA11SCG_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA11SCG_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA12OR_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA12OR_tiDebDef_C
      DDRC_DurDeb.DFC_rbr_outA12SCB_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA12SCB_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA12SCG_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA12SCG_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA16OL_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA16OL_tiDebDef_C
      DDRC_DurDeb.DFC_rbr_outA16OT_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA16OT_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA16SCB_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA16SCB_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA16SCG_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA16SCG_tiDebDef_C
      DDRC_DurDeb.DFC_rbr_outA17OL_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA17OL_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA17OR_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA17OR_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA17OT_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA17OT_tiDebDef_C
      DDRC_DurDeb.DFC_rbr_outA17SCB_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA17SCB_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA17SCG_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA17SCG_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA18OL_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA18OL_tiDebDef_C
      DDRC_DurDeb.DFC_rbr_outA18OT_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA18OT_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA18SCB_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA18SCB_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA18SCG_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA18SCG_tiDebDef_C
      DDRC_DurDeb.DFC_rbr_outA19OL_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA19OL_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA19OR_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA19OR_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA19OT_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA19OT_tiDebDef_C
      DDRC_DurDeb.DFC_rbr_outA19SCB_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA19SCB_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA19SCG_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA19SCG_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA20OL_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA20OL_tiDebDef_C
      DDRC_DurDeb.DFC_rbr_outA20OR_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA20OR_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA20OT_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA20OT_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA20SCB_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA20SCB_tiDebDef_C
      DDRC_DurDeb.DFC_rbr_outA20SCG_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA20SCG_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA31OL_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA31OL_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA31OR_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA31OR_tiDebDef_C
      DDRC_DurDeb.DFC_rbr_outA31OT_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA31OT_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA31SCB_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA31SCB_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA31SCG_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA31SCG_tiDebDef_C
      DDRC_DurDeb.DFC_rbr_outA32OL_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA32OL_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA32OR_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA32OR_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA32OT_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA32OT_tiDebDef_C
      DDRC_DurDeb.DFC_rbr_outA32SCB_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA32SCB_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA32SCG_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA32SCG_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA33OL_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA33OL_tiDebDef_C
      DDRC_DurDeb.DFC_rbr_outA33OR_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA33OR_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA33OT_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA33OT_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA33SCB_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA33SCB_tiDebDef_C
      DDRC_DurDeb.DFC_rbr_outA33SCG_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA33SCG_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA34OL_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA34OL_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA34OR_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA34OR_tiDebDef_C
      DDRC_DurDeb.DFC_rbr_outA34OT_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA34OT_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA34SCB_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA34SCB_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA34SCG_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA34SCG_tiDebDef_C
      DDRC_DurDeb.DFC_rbr_outA35OL_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA35OL_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA35OR_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA35OR_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA35OT_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA35OT_tiDebDef_C
      DDRC_DurDeb.DFC_rbr_outA35SCB_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA35SCB_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA35SCG_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA35SCG_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA46OL_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA46OL_tiDebDef_C
      DDRC_DurDeb.DFC_rbr_outA46OR_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA46OR_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA46OT_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA46OT_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA46SCB_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA46SCB_tiDebDef_C
      DDRC_DurDeb.DFC_rbr_outA46SCG_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA46SCG_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA47OL_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA47OL_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA47OR_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA47OR_tiDebDef_C
      DDRC_DurDeb.DFC_rbr_outA47OT_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA47OT_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA47SCB_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA47SCB_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA47SCG_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA47SCG_tiDebDef_C
      DDRC_DurDeb.DFC_rbr_outA48OL_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA48OL_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA48OR_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA48OR_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA48OT_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA48OT_tiDebDef_C
      DDRC_DurDeb.DFC_rbr_outA48SCB_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA48SCB_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA48SCG_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA48SCG_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA49OL_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA49OL_tiDebDef_C
      DDRC_DurDeb.DFC_rbr_outA49OT_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA49OT_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA49SCB_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA49SCB_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA49SCG_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA49SCG_tiDebDef_C
      DDRC_DurDeb.DFC_rbr_outA50OL_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA50OL_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA50OT_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA50OT_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA50SCB_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA50SCB_tiDebDef_C
      DDRC_DurDeb.DFC_rbr_outA50SCG_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA50SCG_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA51OL_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA51OL_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA51OR_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA51OR_tiDebDef_C
      DDRC_DurDeb.DFC_rbr_outA51OT_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA51OT_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA51SCB_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA51SCB_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA51SCG_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA51SCG_tiDebDef_C
      DDRC_DurDeb.DFC_rbr_outA52OL_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA52OL_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA52OR_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA52OR_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA52OT_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA52OT_tiDebDef_C
      DDRC_DurDeb.DFC_rbr_outA52SCB_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA52SCB_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA52SCG_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA52SCG_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA53OL_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA53OL_tiDebDef_C
      DDRC_DurDeb.DFC_rbr_outA53OR_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA53OR_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA53OT_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA53OT_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA53SCB_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA53SCB_tiDebDef_C
      DDRC_DurDeb.DFC_rbr_outA53SCG_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA53SCG_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA54OL_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA54OL_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA54OR_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA54OR_tiDebDef_C
      DDRC_DurDeb.DFC_rbr_outA54OT_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA54OT_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA54SCB_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA54SCB_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA54SCG_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA54SCG_tiDebDef_C
      DDRC_DurDeb.DFC_rbr_outA55OL_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA55OL_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA55OT_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA55OT_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA55SCB_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA55SCB_tiDebDef_C
      DDRC_DurDeb.DFC_rbr_outA55SCG_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA55SCG_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA56OL_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA56OL_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA56OT_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA56OT_tiDebDef_C
      DDRC_DurDeb.DFC_rbr_outA56SCB_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA56SCB_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA56SCG_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA56SCG_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA58OL_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA58OL_tiDebDef_C
      DDRC_DurDeb.DFC_rbr_outA58OT_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA58OT_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA58SCB_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA58SCB_tiDebDef_C DDRC_DurDeb.DFC_rbr_outA58SCG_tiDebOk_C DDRC_DurDeb.DFC_rbr_outA58SCG_tiDebDef_C
      DDRC_DurDeb.DFC_rbr_outK14OR_tiDebOk_C DDRC_DurDeb.DFC_rbr_outK14OR_tiDebDef_C DDRC_DurDeb.DFC_rbr_outK15OR_tiDebOk_C DDRC_DurDeb.DFC_rbr_outK15OR_tiDebDef_C DDRC_DurDeb.DFC_rbr_outK16OR_tiDebOk_C DDRC_DurDeb.DFC_rbr_outK16OR_tiDebDef_C
      DDRC_DurDeb.DFC_rbr_outK17OL_tiDebOk_C DDRC_DurDeb.DFC_rbr_outK17OL_tiDebDef_C DDRC_DurDeb.DFC_rbr_outK17OR_tiDebOk_C DDRC_DurDeb.DFC_rbr_outK17OR_tiDebDef_C DDRC_DurDeb.DFC_rbr_outK17OT_tiDebOk_C DDRC_DurDeb.DFC_rbr_outK17OT_tiDebDef_C
      DDRC_DurDeb.DFC_rbr_outK17SCB_tiDebOk_C DDRC_DurDeb.DFC_rbr_outK17SCB_tiDebDef_C DDRC_DurDeb.DFC_rbr_outK17SCG_tiDebOk_C DDRC_DurDeb.DFC_rbr_outK17SCG_tiDebDef_C DDRC_DurDeb.DevLib_tiBattUHiDebOk_C DDRC_DurDeb.DevLib_tiBattUHiDebDef_C
      DDRC_DurDeb.DevLib_tiBattULoDebOk_C DDRC_DurDeb.DevLib_tiBattULoDebDef_C DDRC_DurDeb.bds_dsm_TimeUpDownDebOk_C DDRC_DurDeb.bds_dsm_TimeUpDownDebDef_C DDRC_DurDeb.rbrIn_tK44SCBDebOk_C DDRC_DurDeb.rbrIn_tK44SCBDebDef_C
      DDRC_DurDeb.rbrIn_tiA13ORDebOk_C DDRC_DurDeb.rbrIn_tiA13ORDebDef_C DDRC_DurDeb.rbrIn_tiA13SCBDebOk_C DDRC_DurDeb.rbrIn_tiA13SCBDebDef_C DDRC_DurDeb.rbrIn_tiA13SCGDebOk_C DDRC_DurDeb.rbrIn_tiA13SCGDebDef_C
      DDRC_DurDeb.rbrIn_tiA14ORDebOk_C DDRC_DurDeb.rbrIn_tiA14ORDebDef_C DDRC_DurDeb.rbrIn_tiA14SCBDebOk_C DDRC_DurDeb.rbrIn_tiA14SCBDebDef_C DDRC_DurDeb.rbrIn_tiA14SCGDebOk_C DDRC_DurDeb.rbrIn_tiA14SCGDebDef_C
      DDRC_DurDeb.rbrIn_tiA21ORDebOk_C DDRC_DurDeb.rbrIn_tiA21ORDebDef_C DDRC_DurDeb.rbrIn_tiA21SCBDebOk_C DDRC_DurDeb.rbrIn_tiA21SCBDebDef_C DDRC_DurDeb.rbrIn_tiA21SCGDebOk_C DDRC_DurDeb.rbrIn_tiA21SCGDebDef_C
      DDRC_DurDeb.rbrIn_tiA22ORDebOk_C DDRC_DurDeb.rbrIn_tiA22ORDebDef_C DDRC_DurDeb.rbrIn_tiA22SCBDebOk_C DDRC_DurDeb.rbrIn_tiA22SCBDebDef_C DDRC_DurDeb.rbrIn_tiA22SCGDebOk_C DDRC_DurDeb.rbrIn_tiA22SCGDebDef_C
      DDRC_DurDeb.rbrIn_tiA23ORDebOk_C DDRC_DurDeb.rbrIn_tiA23ORDebDef_C DDRC_DurDeb.rbrIn_tiA23SCBDebOk_C DDRC_DurDeb.rbrIn_tiA23SCBDebDef_C DDRC_DurDeb.rbrIn_tiA23SCGDebOk_C DDRC_DurDeb.rbrIn_tiA23SCGDebDef_C
      DDRC_DurDeb.rbrIn_tiA24ORDebOk_C DDRC_DurDeb.rbrIn_tiA24ORDebDef_C DDRC_DurDeb.rbrIn_tiA24SCBDebOk_C DDRC_DurDeb.rbrIn_tiA24SCBDebDef_C DDRC_DurDeb.rbrIn_tiA24SCGDebOk_C DDRC_DurDeb.rbrIn_tiA24SCGDebDef_C
      DDRC_DurDeb.rbrIn_tiA25ORDebOk_C DDRC_DurDeb.rbrIn_tiA25ORDebDef_C DDRC_DurDeb.rbrIn_tiA25SCBDebOk_C DDRC_DurDeb.rbrIn_tiA25SCBDebDef_C DDRC_DurDeb.rbrIn_tiA25SCGDebOk_C DDRC_DurDeb.rbrIn_tiA25SCGDebDef_C
      DDRC_DurDeb.rbrIn_tiA26ORDebOk_C DDRC_DurDeb.rbrIn_tiA26ORDebDef_C DDRC_DurDeb.rbrIn_tiA26SCBDebOk_C DDRC_DurDeb.rbrIn_tiA26SCBDebDef_C DDRC_DurDeb.rbrIn_tiA26SCGDebOk_C DDRC_DurDeb.rbrIn_tiA26SCGDebDef_C
      DDRC_DurDeb.rbrIn_tiA27ORDebOk_C DDRC_DurDeb.rbrIn_tiA27ORDebDef_C DDRC_DurDeb.rbrIn_tiA27SCBDebOk_C DDRC_DurDeb.rbrIn_tiA27SCBDebDef_C DDRC_DurDeb.rbrIn_tiA27SCGDebOk_C DDRC_DurDeb.rbrIn_tiA27SCGDebDef_C
      DDRC_DurDeb.rbrIn_tiA28ORDebOk_C DDRC_DurDeb.rbrIn_tiA28ORDebDef_C DDRC_DurDeb.rbrIn_tiA28SCBDebOk_C DDRC_DurDeb.rbrIn_tiA28SCBDebDef_C DDRC_DurDeb.rbrIn_tiA28SCGDebOk_C DDRC_DurDeb.rbrIn_tiA28SCGDebDef_C
      DDRC_DurDeb.rbrIn_tiA29ORDebOk_C DDRC_DurDeb.rbrIn_tiA29ORDebDef_C DDRC_DurDeb.rbrIn_tiA29SCBDebOk_C DDRC_DurDeb.rbrIn_tiA29SCBDebDef_C DDRC_DurDeb.rbrIn_tiA29SCGDebOk_C DDRC_DurDeb.rbrIn_tiA29SCGDebDef_C
      DDRC_DurDeb.rbrIn_tiA36AicSCBDebOk_C DDRC_DurDeb.rbrIn_tiA36AicSCBDebDef_C DDRC_DurDeb.rbrIn_tiA36AicSCGDebOk_C DDRC_DurDeb.rbrIn_tiA36AicSCGDebDef_C DDRC_DurDeb.rbrIn_tiA36ORDebOk_C DDRC_DurDeb.rbrIn_tiA36ORDebDef_C
      DDRC_DurDeb.rbrIn_tiA36SCBDebOk_C DDRC_DurDeb.rbrIn_tiA36SCBDebDef_C DDRC_DurDeb.rbrIn_tiA36SCGDebOk_C DDRC_DurDeb.rbrIn_tiA36SCGDebDef_C DDRC_DurDeb.rbrIn_tiA36ShuntSCBDebOk_C DDRC_DurDeb.rbrIn_tiA36ShuntSCBDebDef_C
      DDRC_DurDeb.rbrIn_tiA37AicSCBDebOk_C DDRC_DurDeb.rbrIn_tiA37AicSCBDebDef_C DDRC_DurDeb.rbrIn_tiA37AicSCGDebOk_C DDRC_DurDeb.rbrIn_tiA37AicSCGDebDef_C DDRC_DurDeb.rbrIn_tiA37ORDebOk_C DDRC_DurDeb.rbrIn_tiA37ORDebDef_C
      DDRC_DurDeb.rbrIn_tiA37SCBDebOk_C DDRC_DurDeb.rbrIn_tiA37SCBDebDef_C DDRC_DurDeb.rbrIn_tiA37SCGDebOk_C DDRC_DurDeb.rbrIn_tiA37SCGDebDef_C DDRC_DurDeb.rbrIn_tiA37ShuntSCBDebOk_C DDRC_DurDeb.rbrIn_tiA37ShuntSCBDebDef_C
      DDRC_DurDeb.rbrIn_tiA38AicSCBDebOk_C DDRC_DurDeb.rbrIn_tiA38AicSCBDebDef_C DDRC_DurDeb.rbrIn_tiA38AicSCGDebOk_C DDRC_DurDeb.rbrIn_tiA38AicSCGDebDef_C DDRC_DurDeb.rbrIn_tiA38ORDebOk_C DDRC_DurDeb.rbrIn_tiA38ORDebDef_C
      DDRC_DurDeb.rbrIn_tiA38SCBDebOk_C DDRC_DurDeb.rbrIn_tiA38SCBDebDef_C DDRC_DurDeb.rbrIn_tiA38SCGDebOk_C DDRC_DurDeb.rbrIn_tiA38SCGDebDef_C DDRC_DurDeb.rbrIn_tiA38ShuntSCBDebOk_C DDRC_DurDeb.rbrIn_tiA38ShuntSCBDebDef_C
      DDRC_DurDeb.rbrIn_tiA39AicSCBDebOk_C DDRC_DurDeb.rbrIn_tiA39AicSCBDebDef_C DDRC_DurDeb.rbrIn_tiA39AicSCGDebOk_C DDRC_DurDeb.rbrIn_tiA39AicSCGDebDef_C DDRC_DurDeb.rbrIn_tiA39ORDebOk_C DDRC_DurDeb.rbrIn_tiA39ORDebDef_C
      DDRC_DurDeb.rbrIn_tiA39SCBDebOk_C DDRC_DurDeb.rbrIn_tiA39SCBDebDef_C DDRC_DurDeb.rbrIn_tiA39SCGDebOk_C DDRC_DurDeb.rbrIn_tiA39SCGDebDef_C DDRC_DurDeb.rbrIn_tiA39ShuntSCBDebOk_C DDRC_DurDeb.rbrIn_tiA39ShuntSCBDebDef_C
      DDRC_DurDeb.rbrIn_tiA40ORDebOk_C DDRC_DurDeb.rbrIn_tiA40ORDebDef_C DDRC_DurDeb.rbrIn_tiA40SCBDebOk_C DDRC_DurDeb.rbrIn_tiA40SCBDebDef_C DDRC_DurDeb.rbrIn_tiA40SCGDebOk_C DDRC_DurDeb.rbrIn_tiA40SCGDebDef_C
      DDRC_DurDeb.rbrIn_tiA41ORDebOk_C DDRC_DurDeb.rbrIn_tiA41ORDebDef_C DDRC_DurDeb.rbrIn_tiA41SCBDebOk_C DDRC_DurDeb.rbrIn_tiA41SCBDebDef_C DDRC_DurDeb.rbrIn_tiA41SCGDebOk_C DDRC_DurDeb.rbrIn_tiA41SCGDebDef_C
      DDRC_DurDeb.rbrIn_tiA42ORDebOk_C DDRC_DurDeb.rbrIn_tiA42ORDebDef_C DDRC_DurDeb.rbrIn_tiA42SCBDebOk_C DDRC_DurDeb.rbrIn_tiA42SCBDebDef_C DDRC_DurDeb.rbrIn_tiA42SCGDebOk_C DDRC_DurDeb.rbrIn_tiA42SCGDebDef_C
      DDRC_DurDeb.rbrIn_tiA43AicSCBDebOk_C DDRC_DurDeb.rbrIn_tiA43AicSCBDebDef_C DDRC_DurDeb.rbrIn_tiA43AicSCGDebOk_C DDRC_DurDeb.rbrIn_tiA43AicSCGDebDef_C DDRC_DurDeb.rbrIn_tiA43ORDebOk_C DDRC_DurDeb.rbrIn_tiA43ORDebDef_C
      DDRC_DurDeb.rbrIn_tiA43SCBDebOk_C DDRC_DurDeb.rbrIn_tiA43SCBDebDef_C DDRC_DurDeb.rbrIn_tiA43SCGDebOk_C DDRC_DurDeb.rbrIn_tiA43SCGDebDef_C DDRC_DurDeb.rbrIn_tiA43ShuntSCBDebOk_C DDRC_DurDeb.rbrIn_tiA43ShuntSCBDebDef_C
      DDRC_DurDeb.rbrIn_tiA44OLDebOk_C DDRC_DurDeb.rbrIn_tiA44OLDebDef_C DDRC_DurDeb.rbrIn_tiA44SCBDebOk_C DDRC_DurDeb.rbrIn_tiA44SCBDebDef_C DDRC_DurDeb.rbrIn_tiA44SCGDebOk_C DDRC_DurDeb.rbrIn_tiA44SCGDebDef_C
      DDRC_DurDeb.rbrIn_tiA57ORDebOk_C DDRC_DurDeb.rbrIn_tiA57ORDebDef_C DDRC_DurDeb.rbrIn_tiA57SCBDebOk_C DDRC_DurDeb.rbrIn_tiA57SCBDebDef_C DDRC_DurDeb.rbrIn_tiA57SCGDebOk_C DDRC_DurDeb.rbrIn_tiA57SCGDebDef_C
      DDRC_DurDeb.rbrIn_tiA59OLDebOk_C DDRC_DurDeb.rbrIn_tiA59OLDebDef_C DDRC_DurDeb.rbrIn_tiA59SCBDebOk_C DDRC_DurDeb.rbrIn_tiA59SCBDebDef_C DDRC_DurDeb.rbrIn_tiA59SCGDebOk_C DDRC_DurDeb.rbrIn_tiA59SCGDebDef_C
      DDRC_DurDeb.rbrIn_tiK10ORDebOk_C DDRC_DurDeb.rbrIn_tiK10ORDebDef_C DDRC_DurDeb.rbrIn_tiK10SCBDebOk_C DDRC_DurDeb.rbrIn_tiK10SCBDebDef_C DDRC_DurDeb.rbrIn_tiK10SCGDebOk_C DDRC_DurDeb.rbrIn_tiK10SCGDebDef_C
      DDRC_DurDeb.rbrIn_tiK11ORDebOk_C DDRC_DurDeb.rbrIn_tiK11ORDebDef_C DDRC_DurDeb.rbrIn_tiK11SCBDebOk_C DDRC_DurDeb.rbrIn_tiK11SCBDebDef_C DDRC_DurDeb.rbrIn_tiK11SCGDebOk_C DDRC_DurDeb.rbrIn_tiK11SCGDebDef_C
      DDRC_DurDeb.rbrIn_tiK30AicSCBDebOk_C DDRC_DurDeb.rbrIn_tiK30AicSCBDebDef_C DDRC_DurDeb.rbrIn_tiK30AicSCGDebOk_C DDRC_DurDeb.rbrIn_tiK30AicSCGDebDef_C DDRC_DurDeb.rbrIn_tiK30ORDebOk_C DDRC_DurDeb.rbrIn_tiK30ORDebDef_C
      DDRC_DurDeb.rbrIn_tiK30SCBDebOk_C DDRC_DurDeb.rbrIn_tiK30SCBDebDef_C DDRC_DurDeb.rbrIn_tiK30SCGDebOk_C DDRC_DurDeb.rbrIn_tiK30SCGDebDef_C DDRC_DurDeb.rbrIn_tiK30ShuntSCBDebOk_C DDRC_DurDeb.rbrIn_tiK30ShuntSCBDebDef_C
      DDRC_DurDeb.rbrIn_tiK31ORDebOk_C DDRC_DurDeb.rbrIn_tiK31ORDebDef_C DDRC_DurDeb.rbrIn_tiK31SCBDebOk_C DDRC_DurDeb.rbrIn_tiK31SCBDebDef_C DDRC_DurDeb.rbrIn_tiK31SCGDebOk_C DDRC_DurDeb.rbrIn_tiK31SCGDebDef_C
      DDRC_DurDeb.rbrIn_tiK32ORDebOk_C DDRC_DurDeb.rbrIn_tiK32ORDebDef_C DDRC_DurDeb.rbrIn_tiK32SCBDebOk_C DDRC_DurDeb.rbrIn_tiK32SCBDebDef_C DDRC_DurDeb.rbrIn_tiK32SCGDebOk_C DDRC_DurDeb.rbrIn_tiK32SCGDebDef_C
      DDRC_DurDeb.rbrIn_tiK33ORDebOk_C DDRC_DurDeb.rbrIn_tiK33ORDebDef_C DDRC_DurDeb.rbrIn_tiK33SCBDebOk_C DDRC_DurDeb.rbrIn_tiK33SCBDebDef_C DDRC_DurDeb.rbrIn_tiK33SCGDebOk_C DDRC_DurDeb.rbrIn_tiK33SCGDebDef_C
      DDRC_DurDeb.rbrIn_tiK34ORDebOk_C DDRC_DurDeb.rbrIn_tiK34ORDebDef_C DDRC_DurDeb.rbrIn_tiK34SCBDebOk_C DDRC_DurDeb.rbrIn_tiK34SCBDebDef_C DDRC_DurDeb.rbrIn_tiK34SCGDebOk_C DDRC_DurDeb.rbrIn_tiK34SCGDebDef_C
      DDRC_DurDeb.rbrIn_tiK35ORDebOk_C DDRC_DurDeb.rbrIn_tiK35ORDebDef_C DDRC_DurDeb.rbrIn_tiK35SCBDebOk_C DDRC_DurDeb.rbrIn_tiK35SCBDebDef_C DDRC_DurDeb.rbrIn_tiK35SCGDebOk_C DDRC_DurDeb.rbrIn_tiK35SCGDebDef_C
      DDRC_DurDeb.rbrIn_tiK36ORDebOk_C DDRC_DurDeb.rbrIn_tiK36ORDebDef_C DDRC_DurDeb.rbrIn_tiK36SCBDebOk_C DDRC_DurDeb.rbrIn_tiK36SCBDebDef_C DDRC_DurDeb.rbrIn_tiK36SCGDebOk_C DDRC_DurDeb.rbrIn_tiK36SCGDebDef_C
      DDRC_DurDeb.rbrIn_tiK37AicSCBDebOk_C DDRC_DurDeb.rbrIn_tiK37AicSCBDebDef_C DDRC_DurDeb.rbrIn_tiK37AicSCGDebOk_C DDRC_DurDeb.rbrIn_tiK37AicSCGDebDef_C DDRC_DurDeb.rbrIn_tiK37ORDebOk_C DDRC_DurDeb.rbrIn_tiK37ORDebDef_C
      DDRC_DurDeb.rbrIn_tiK37SCBDebOk_C DDRC_DurDeb.rbrIn_tiK37SCBDebDef_C DDRC_DurDeb.rbrIn_tiK37SCGDebOk_C DDRC_DurDeb.rbrIn_tiK37SCGDebDef_C DDRC_DurDeb.rbrIn_tiK37ShuntSCBDebOk_C DDRC_DurDeb.rbrIn_tiK37ShuntSCBDebDef_C
      DDRC_DurDeb.rbrIn_tiK38AicSCBDebOk_C DDRC_DurDeb.rbrIn_tiK38AicSCBDebDef_C DDRC_DurDeb.rbrIn_tiK38AicSCGDebOk_C DDRC_DurDeb.rbrIn_tiK38AicSCGDebDef_C DDRC_DurDeb.rbrIn_tiK38ORDebOk_C DDRC_DurDeb.rbrIn_tiK38ORDebDef_C
      DDRC_DurDeb.rbrIn_tiK38SCBDebOk_C DDRC_DurDeb.rbrIn_tiK38SCBDebDef_C DDRC_DurDeb.rbrIn_tiK38SCGDebOk_C DDRC_DurDeb.rbrIn_tiK38SCGDebDef_C DDRC_DurDeb.rbrIn_tiK38ShuntSCBDebOk_C DDRC_DurDeb.rbrIn_tiK38ShuntSCBDebDef_C
      DDRC_DurDeb.rbrIn_tiK39AicSCBDebOk_C DDRC_DurDeb.rbrIn_tiK39AicSCBDebDef_C DDRC_DurDeb.rbrIn_tiK39AicSCGDebOk_C DDRC_DurDeb.rbrIn_tiK39AicSCGDebDef_C DDRC_DurDeb.rbrIn_tiK39ORDebOk_C DDRC_DurDeb.rbrIn_tiK39ORDebDef_C
      DDRC_DurDeb.rbrIn_tiK39SCBDebOk_C DDRC_DurDeb.rbrIn_tiK39SCBDebDef_C DDRC_DurDeb.rbrIn_tiK39SCGDebOk_C DDRC_DurDeb.rbrIn_tiK39SCGDebDef_C DDRC_DurDeb.rbrIn_tiK39ShuntSCBDebOk_C DDRC_DurDeb.rbrIn_tiK39ShuntSCBDebDef_C
      DDRC_DurDeb.rbrIn_tiK40AicSCBDebOk_C DDRC_DurDeb.rbrIn_tiK40AicSCBDebDef_C DDRC_DurDeb.rbrIn_tiK40AicSCGDebOk_C DDRC_DurDeb.rbrIn_tiK40AicSCGDebDef_C DDRC_DurDeb.rbrIn_tiK40ORDebOk_C DDRC_DurDeb.rbrIn_tiK40ORDebDef_C
      DDRC_DurDeb.rbrIn_tiK40SCBDebOk_C DDRC_DurDeb.rbrIn_tiK40SCBDebDef_C DDRC_DurDeb.rbrIn_tiK40SCGDebOk_C DDRC_DurDeb.rbrIn_tiK40SCGDebDef_C DDRC_DurDeb.rbrIn_tiK40ShuntSCBDebOk_C DDRC_DurDeb.rbrIn_tiK40ShuntSCBDebDef_C
      DDRC_DurDeb.rbrIn_tiK41AicSCBDebOk_C DDRC_DurDeb.rbrIn_tiK41AicSCBDebDef_C DDRC_DurDeb.rbrIn_tiK41AicSCGDebOk_C DDRC_DurDeb.rbrIn_tiK41AicSCGDebDef_C DDRC_DurDeb.rbrIn_tiK41ORDebOk_C DDRC_DurDeb.rbrIn_tiK41ORDebDef_C
      DDRC_DurDeb.rbrIn_tiK41SCBDebOk_C DDRC_DurDeb.rbrIn_tiK41SCBDebDef_C DDRC_DurDeb.rbrIn_tiK41SCGDebOk_C DDRC_DurDeb.rbrIn_tiK41SCGDebDef_C DDRC_DurDeb.rbrIn_tiK41ShuntSCBDebOk_C DDRC_DurDeb.rbrIn_tiK41ShuntSCBDebDef_C
      DDRC_DurDeb.rbrIn_tiK42AicSCBDebOk_C DDRC_DurDeb.rbrIn_tiK42AicSCBDebDef_C DDRC_DurDeb.rbrIn_tiK42AicSCGDebOk_C DDRC_DurDeb.rbrIn_tiK42AicSCGDebDef_C DDRC_DurDeb.rbrIn_tiK42ORDebOk_C DDRC_DurDeb.rbrIn_tiK42ORDebDef_C
      DDRC_DurDeb.rbrIn_tiK42SCBDebOk_C DDRC_DurDeb.rbrIn_tiK42SCBDebDef_C DDRC_DurDeb.rbrIn_tiK42SCGDebOk_C DDRC_DurDeb.rbrIn_tiK42SCGDebDef_C DDRC_DurDeb.rbrIn_tiK42ShuntSCBDebOk_C DDRC_DurDeb.rbrIn_tiK42ShuntSCBDebDef_C
      DDRC_DurDeb.rbrIn_tiK43ORDebOk_C DDRC_DurDeb.rbrIn_tiK43ORDebDef_C DDRC_DurDeb.rbrIn_tiK43SCBDebOk_C DDRC_DurDeb.rbrIn_tiK43SCBDebDef_C DDRC_DurDeb.rbrIn_tiK43SCGDebOk_C DDRC_DurDeb.rbrIn_tiK43SCGDebDef_C
      DDRC_DurDeb.rbrIn_tiK44AicSCBDebOk_C DDRC_DurDeb.rbrIn_tiK44AicSCBDebDef_C DDRC_DurDeb.rbrIn_tiK44AicSCGDebOk_C DDRC_DurDeb.rbrIn_tiK44AicSCGDebDef_C DDRC_DurDeb.rbrIn_tiK44ORDebOk_C DDRC_DurDeb.rbrIn_tiK44ORDebDef_C
      DDRC_DurDeb.rbrIn_tiK44SCGDebOk_C DDRC_DurDeb.rbrIn_tiK44SCGDebDef_C DDRC_DurDeb.rbrIn_tiK44ShuntSCBDebOk_C DDRC_DurDeb.rbrIn_tiK44ShuntSCBDebDef_C DDRC_DurDeb.rbrIn_tiK45AicSCBDebOk_C DDRC_DurDeb.rbrIn_tiK45AicSCBDebDef_C
      DDRC_DurDeb.rbrIn_tiK45AicSCGDebOk_C DDRC_DurDeb.rbrIn_tiK45AicSCGDebDef_C DDRC_DurDeb.rbrIn_tiK45ORDebOk_C DDRC_DurDeb.rbrIn_tiK45ORDebDef_C DDRC_DurDeb.rbrIn_tiK45SCBDebOk_C DDRC_DurDeb.rbrIn_tiK45SCBDebDef_C
      DDRC_DurDeb.rbrIn_tiK45SCGDebOk_C DDRC_DurDeb.rbrIn_tiK45SCGDebDef_C DDRC_DurDeb.rbrIn_tiK45ShuntSCBDebOk_C DDRC_DurDeb.rbrIn_tiK45ShuntSCBDebDef_C DDRC_DurDeb.rbrIn_tiK52ORDebOk_C DDRC_DurDeb.rbrIn_tiK52ORDebDef_C
      DDRC_DurDeb.rbrIn_tiK52SCBDebOk_C DDRC_DurDeb.rbrIn_tiK52SCBDebDef_C DDRC_DurDeb.rbrIn_tiK52SCGDebOk_C DDRC_DurDeb.rbrIn_tiK52SCGDebDef_C DDRC_DurDeb.rbrIn_tiK53ORDebOk_C DDRC_DurDeb.rbrIn_tiK53ORDebDef_C
      DDRC_DurDeb.rbrIn_tiK53SCBDebOk_C DDRC_DurDeb.rbrIn_tiK53SCBDebDef_C DDRC_DurDeb.rbrIn_tiK53SCGDebOk_C DDRC_DurDeb.rbrIn_tiK53SCGDebDef_C DDRC_DurDeb.rbrIn_tiK54AicSCBDebOk_C DDRC_DurDeb.rbrIn_tiK54AicSCBDebDef_C
      DDRC_DurDeb.rbrIn_tiK54AicSCGDebOk_C DDRC_DurDeb.rbrIn_tiK54AicSCGDebDef_C DDRC_DurDeb.rbrIn_tiK54ORDebOk_C DDRC_DurDeb.rbrIn_tiK54ORDebDef_C DDRC_DurDeb.rbrIn_tiK54SCBDebOk_C DDRC_DurDeb.rbrIn_tiK54SCBDebDef_C
      DDRC_DurDeb.rbrIn_tiK54SCGDebOk_C DDRC_DurDeb.rbrIn_tiK54SCGDebDef_C DDRC_DurDeb.rbrIn_tiK54ShuntSCBDebOk_C DDRC_DurDeb.rbrIn_tiK54ShuntSCBDebDef_C DDRC_DurDeb.rbrIn_tiK55AicSCBDebOk_C DDRC_DurDeb.rbrIn_tiK55AicSCBDebDef_C
      DDRC_DurDeb.rbrIn_tiK55AicSCGDebOk_C DDRC_DurDeb.rbrIn_tiK55AicSCGDebDef_C DDRC_DurDeb.rbrIn_tiK55ORDebOk_C DDRC_DurDeb.rbrIn_tiK55ORDebDef_C DDRC_DurDeb.rbrIn_tiK55SCBDebOk_C DDRC_DurDeb.rbrIn_tiK55SCBDebDef_C
      DDRC_DurDeb.rbrIn_tiK55SCGDebOk_C DDRC_DurDeb.rbrIn_tiK55SCGDebDef_C DDRC_DurDeb.rbrIn_tiK55ShuntSCBDebOk_C DDRC_DurDeb.rbrIn_tiK55ShuntSCBDebDef_C DDRC_DurDeb.rbrIn_tiK56ORDebOk_C DDRC_DurDeb.rbrIn_tiK56ORDebDef_C
      DDRC_DurDeb.rbrIn_tiK56SCBDebOk_C DDRC_DurDeb.rbrIn_tiK56SCBDebDef_C DDRC_DurDeb.rbrIn_tiK56SCGDebOk_C DDRC_DurDeb.rbrIn_tiK56SCGDebDef_C DDRC_DurDeb.rbrIn_tiK57ORDebOk_C DDRC_DurDeb.rbrIn_tiK57ORDebDef_C
      DDRC_DurDeb.rbrIn_tiK57SCBDebOk_C DDRC_DurDeb.rbrIn_tiK57SCBDebDef_C DDRC_DurDeb.rbrIn_tiK57SCGDebOk_C DDRC_DurDeb.rbrIn_tiK57SCGDebDef_C DDRC_DurDeb.rbrIn_tiK58ORDebOk_C DDRC_DurDeb.rbrIn_tiK58ORDebDef_C
      DDRC_DurDeb.rbrIn_tiK58SCBDebOk_C DDRC_DurDeb.rbrIn_tiK58SCBDebDef_C DDRC_DurDeb.rbrIn_tiK58SCGDebOk_C DDRC_DurDeb.rbrIn_tiK58SCGDebDef_C DDRC_DurDeb.rbrIn_tiK59ORDebOk_C DDRC_DurDeb.rbrIn_tiK59ORDebDef_C
      DDRC_DurDeb.rbrIn_tiK59SCBDebOk_C DDRC_DurDeb.rbrIn_tiK59SCBDebDef_C DDRC_DurDeb.rbrIn_tiK59SCGDebOk_C DDRC_DurDeb.rbrIn_tiK59SCGDebDef_C DDRC_DurDeb.rbrIn_tiK60ORDebOk_C DDRC_DurDeb.rbrIn_tiK60ORDebDef_C
      DDRC_DurDeb.rbrIn_tiK60SCBDebOk_C DDRC_DurDeb.rbrIn_tiK60SCBDebDef_C DDRC_DurDeb.rbrIn_tiK60SCGDebOk_C DDRC_DurDeb.rbrIn_tiK60SCGDebDef_C DDRC_DurDeb.rbrIn_tiK61AicSCBDebOk_C DDRC_DurDeb.rbrIn_tiK61AicSCBDebDef_C
      DDRC_DurDeb.rbrIn_tiK61AicSCGDebOk_C DDRC_DurDeb.rbrIn_tiK61AicSCGDebDef_C DDRC_DurDeb.rbrIn_tiK61ORDebOk_C DDRC_DurDeb.rbrIn_tiK61ORDebDef_C DDRC_DurDeb.rbrIn_tiK61SCBDebOk_C DDRC_DurDeb.rbrIn_tiK61SCBDebDef_C
      DDRC_DurDeb.rbrIn_tiK61SCGDebOk_C DDRC_DurDeb.rbrIn_tiK61SCGDebDef_C DDRC_DurDeb.rbrIn_tiK61ShuntSCBDebOk_C DDRC_DurDeb.rbrIn_tiK61ShuntSCBDebDef_C DDRC_DurDeb.rbrIn_tiK62ORDebOk_C DDRC_DurDeb.rbrIn_tiK62ORDebDef_C
      DDRC_DurDeb.rbrIn_tiK62SCBDebOk_C DDRC_DurDeb.rbrIn_tiK62SCBDebDef_C DDRC_DurDeb.rbrIn_tiK62SCGDebOk_C DDRC_DurDeb.rbrIn_tiK62SCGDebDef_C DDRC_DurDeb.rbrIn_tiK63AicSCBDebOk_C DDRC_DurDeb.rbrIn_tiK63AicSCBDebDef_C
      DDRC_DurDeb.rbrIn_tiK63AicSCGDebOk_C DDRC_DurDeb.rbrIn_tiK63AicSCGDebDef_C DDRC_DurDeb.rbrIn_tiK63ORDebOk_C DDRC_DurDeb.rbrIn_tiK63ORDebDef_C DDRC_DurDeb.rbrIn_tiK63SCBDebOk_C DDRC_DurDeb.rbrIn_tiK63SCBDebDef_C
      DDRC_DurDeb.rbrIn_tiK63SCGDebOk_C DDRC_DurDeb.rbrIn_tiK63SCGDebDef_C DDRC_DurDeb.rbrIn_tiK63ShuntSCBDebOk_C DDRC_DurDeb.rbrIn_tiK63ShuntSCBDebDef_C DDRC_DurDeb.rbrIn_tiK64AicSCBDebOk_C DDRC_DurDeb.rbrIn_tiK64AicSCBDebDef_C
      DDRC_DurDeb.rbrIn_tiK64AicSCGDebOk_C DDRC_DurDeb.rbrIn_tiK64AicSCGDebDef_C DDRC_DurDeb.rbrIn_tiK64ORDebOk_C DDRC_DurDeb.rbrIn_tiK64ORDebDef_C DDRC_DurDeb.rbrIn_tiK64SCBDebOk_C DDRC_DurDeb.rbrIn_tiK64SCBDebDef_C
      DDRC_DurDeb.rbrIn_tiK64SCGDebOk_C DDRC_DurDeb.rbrIn_tiK64SCGDebDef_C DDRC_DurDeb.rbrIn_tiK64ShuntSCBDebOk_C DDRC_DurDeb.rbrIn_tiK64ShuntSCBDebDef_C DDRC_DurDeb.rbrIn_tiK65AicSCBDebOk_C DDRC_DurDeb.rbrIn_tiK65AicSCBDebDef_C
      DDRC_DurDeb.rbrIn_tiK65AicSCGDebOk_C DDRC_DurDeb.rbrIn_tiK65AicSCGDebDef_C DDRC_DurDeb.rbrIn_tiK65ORDebOk_C DDRC_DurDeb.rbrIn_tiK65ORDebDef_C DDRC_DurDeb.rbrIn_tiK65SCBDebOk_C DDRC_DurDeb.rbrIn_tiK65SCBDebDef_C
      DDRC_DurDeb.rbrIn_tiK65SCGDebOk_C DDRC_DurDeb.rbrIn_tiK65SCGDebDef_C DDRC_DurDeb.rbrIn_tiK65ShuntSCBDebOk_C DDRC_DurDeb.rbrIn_tiK65ShuntSCBDebDef_C DDRC_DurDeb.rbrIn_tiK74ORDebOk_C DDRC_DurDeb.rbrIn_tiK74ORDebDef_C
      DDRC_DurDeb.rbrIn_tiK74SCBDebOk_C DDRC_DurDeb.rbrIn_tiK74SCBDebDef_C DDRC_DurDeb.rbrIn_tiK74SCGDebOk_C DDRC_DurDeb.rbrIn_tiK74SCGDebDef_C DDRC_DurDeb.rbrIn_tiK75ORDebOk_C DDRC_DurDeb.rbrIn_tiK75ORDebDef_C
      DDRC_DurDeb.rbrIn_tiK75SCBDebOk_C DDRC_DurDeb.rbrIn_tiK75SCBDebDef_C DDRC_DurDeb.rbrIn_tiK75SCGDebOk_C DDRC_DurDeb.rbrIn_tiK75SCGDebDef_C DDRC_DurDeb.rbrIn_tiK76ORDebOk_C DDRC_DurDeb.rbrIn_tiK76ORDebDef_C
      DDRC_DurDeb.rbrIn_tiK76SCBDebOk_C DDRC_DurDeb.rbrIn_tiK76SCBDebDef_C DDRC_DurDeb.rbrIn_tiK76SCGDebOk_C DDRC_DurDeb.rbrIn_tiK76SCGDebDef_C DDRC_DurDeb.rbrIn_tiK77ORDebOk_C DDRC_DurDeb.rbrIn_tiK77ORDebDef_C
      DDRC_DurDeb.rbrIn_tiK77SCBDebOk_C DDRC_DurDeb.rbrIn_tiK77SCBDebDef_C DDRC_DurDeb.rbrIn_tiK77SCGDebOk_C DDRC_DurDeb.rbrIn_tiK77SCGDebDef_C DDRC_DurDeb.rbrIn_tiK78ORDebOk_C DDRC_DurDeb.rbrIn_tiK78ORDebDef_C
      DDRC_DurDeb.rbrIn_tiK78SCBDebOk_C DDRC_DurDeb.rbrIn_tiK78SCBDebDef_C DDRC_DurDeb.rbrIn_tiK78SCGDebOk_C DDRC_DurDeb.rbrIn_tiK78SCGDebDef_C DDRC_DurDeb.rbrOut_tiK07OLDebOk_C DDRC_DurDeb.rbrOut_tiK07OLDebDef_C
      DDRC_DurDeb.rbrOut_tiK07ORDebOk_C DDRC_DurDeb.rbrOut_tiK07ORDebDef_C DDRC_DurDeb.rbrOut_tiK07OTDebOk_C DDRC_DurDeb.rbrOut_tiK07OTDebDef_C DDRC_DurDeb.rbrOut_tiK07SCBDebOk_C DDRC_DurDeb.rbrOut_tiK07SCBDebDef_C
      DDRC_DurDeb.rbrOut_tiK07SCGDebOk_C DDRC_DurDeb.rbrOut_tiK07SCGDebDef_C DDRC_DurDeb.rbrOut_tiK08OLDebOk_C DDRC_DurDeb.rbrOut_tiK08OLDebDef_C DDRC_DurDeb.rbrOut_tiK08ORDebOk_C DDRC_DurDeb.rbrOut_tiK08ORDebDef_C
      DDRC_DurDeb.rbrOut_tiK08OTDebOk_C DDRC_DurDeb.rbrOut_tiK08OTDebDef_C DDRC_DurDeb.rbrOut_tiK08SCBDebOk_C DDRC_DurDeb.rbrOut_tiK08SCBDebDef_C DDRC_DurDeb.rbrOut_tiK08SCGDebOk_C DDRC_DurDeb.rbrOut_tiK08SCGDebDef_C
      DDRC_DurDeb.rbrOut_tiK09OLDebOk_C DDRC_DurDeb.rbrOut_tiK09OLDebDef_C DDRC_DurDeb.rbrOut_tiK09ORDebOk_C DDRC_DurDeb.rbrOut_tiK09ORDebDef_C DDRC_DurDeb.rbrOut_tiK09OTDebOk_C DDRC_DurDeb.rbrOut_tiK09OTDebDef_C
      DDRC_DurDeb.rbrOut_tiK09SCBDebOk_C DDRC_DurDeb.rbrOut_tiK09SCBDebDef_C DDRC_DurDeb.rbrOut_tiK09SCGDebOk_C DDRC_DurDeb.rbrOut_tiK09SCGDebDef_C DDRC_DurDeb.rbrOut_tiK12OLDebOk_C DDRC_DurDeb.rbrOut_tiK12OLDebDef_C
      DDRC_DurDeb.rbrOut_tiK12OTDebOk_C DDRC_DurDeb.rbrOut_tiK12OTDebDef_C DDRC_DurDeb.rbrOut_tiK12SCBDebOk_C DDRC_DurDeb.rbrOut_tiK12SCBDebDef_C DDRC_DurDeb.rbrOut_tiK12SCGDebOk_C DDRC_DurDeb.rbrOut_tiK12SCGDebDef_C
      DDRC_DurDeb.rbrOut_tiK13OLDebOk_C DDRC_DurDeb.rbrOut_tiK13OLDebDef_C DDRC_DurDeb.rbrOut_tiK13OTDebOk_C DDRC_DurDeb.rbrOut_tiK13OTDebDef_C DDRC_DurDeb.rbrOut_tiK13SCBDebOk_C DDRC_DurDeb.rbrOut_tiK13SCBDebDef_C
      DDRC_DurDeb.rbrOut_tiK13SCGDebOk_C DDRC_DurDeb.rbrOut_tiK13SCGDebDef_C DDRC_DurDeb.rbrOut_tiK14OLDebOk_C DDRC_DurDeb.rbrOut_tiK14OLDebDef_C DDRC_DurDeb.rbrOut_tiK14OTDebOk_C DDRC_DurDeb.rbrOut_tiK14OTDebDef_C
      DDRC_DurDeb.rbrOut_tiK14SCBDebOk_C DDRC_DurDeb.rbrOut_tiK14SCBDebDef_C DDRC_DurDeb.rbrOut_tiK14SCGDebOk_C DDRC_DurDeb.rbrOut_tiK14SCGDebDef_C DDRC_DurDeb.rbrOut_tiK15OLDebOk_C DDRC_DurDeb.rbrOut_tiK15OLDebDef_C
      DDRC_DurDeb.rbrOut_tiK15OTDebOk_C DDRC_DurDeb.rbrOut_tiK15OTDebDef_C DDRC_DurDeb.rbrOut_tiK15SCBDebOk_C DDRC_DurDeb.rbrOut_tiK15SCBDebDef_C DDRC_DurDeb.rbrOut_tiK15SCGDebOk_C DDRC_DurDeb.rbrOut_tiK15SCGDebDef_C
      DDRC_DurDeb.rbrOut_tiK16OLDebOk_C DDRC_DurDeb.rbrOut_tiK16OLDebDef_C DDRC_DurDeb.rbrOut_tiK16OTDebOk_C DDRC_DurDeb.rbrOut_tiK16OTDebDef_C DDRC_DurDeb.rbrOut_tiK16SCBDebOk_C DDRC_DurDeb.rbrOut_tiK16SCBDebDef_C
      DDRC_DurDeb.rbrOut_tiK16SCGDebOk_C DDRC_DurDeb.rbrOut_tiK16SCGDebDef_C DDRC_DurDeb.rbrOut_tiK25ORDebOk_C DDRC_DurDeb.rbrOut_tiK25ORDebDef_C DDRC_DurDeb.rbrOut_tiK25SCBDebOk_C DDRC_DurDeb.rbrOut_tiK25SCBDebDef_C
      DDRC_DurDeb.rbrOut_tiK25SCGDebOk_C DDRC_DurDeb.rbrOut_tiK25SCGDebDef_C DDRC_DurDeb.rbrOut_tiK29OLDebOk_C DDRC_DurDeb.rbrOut_tiK29OLDebDef_C DDRC_DurDeb.rbrOut_tiK29ORDebOk_C DDRC_DurDeb.rbrOut_tiK29ORDebDef_C
      DDRC_DurDeb.rbrOut_tiK29OTDebOk_C DDRC_DurDeb.rbrOut_tiK29OTDebDef_C DDRC_DurDeb.rbrOut_tiK29SCBDebOk_C DDRC_DurDeb.rbrOut_tiK29SCBDebDef_C DDRC_DurDeb.rbrOut_tiK29SCGDebOk_C DDRC_DurDeb.rbrOut_tiK29SCGDebDef_C
      DDRC_DurDeb.rbrOut_tiK51OLDebOk_C DDRC_DurDeb.rbrOut_tiK51OLDebDef_C DDRC_DurDeb.rbrOut_tiK51OTDebOk_C DDRC_DurDeb.rbrOut_tiK51OTDebDef_C DDRC_DurDeb.rbrOut_tiK51SCBDebOk_C DDRC_DurDeb.rbrOut_tiK51SCBDebDef_C
      DDRC_DurDeb.rbrOut_tiK51SCGDebOk_C DDRC_DurDeb.rbrOut_tiK51SCGDebDef_C DDRC_DurDeb.rbrOut_tiK62ORDebOk_C DDRC_DurDeb.rbrOut_tiK62ORDebDef_C DDRC_DurDeb.rbrOut_tiK62SCBDebOk_C DDRC_DurDeb.rbrOut_tiK62SCBDebDef_C
      DDRC_DurDeb.rbrOut_tiK62SCGDebOk_C DDRC_DurDeb.rbrOut_tiK62SCGDebDef_C DDRC_DurDeb.rbrOut_tiK73OLDebOk_C DDRC_DurDeb.rbrOut_tiK73OLDebDef_C DDRC_DurDeb.rbrOut_tiK73ORDebOk_C DDRC_DurDeb.rbrOut_tiK73ORDebDef_C
      DDRC_DurDeb.rbrOut_tiK73OTDebOk_C DDRC_DurDeb.rbrOut_tiK73OTDebDef_C DDRC_DurDeb.rbrOut_tiK73SCBDebOk_C DDRC_DurDeb.rbrOut_tiK73SCBDebDef_C DDRC_DurDeb.rbrOut_tiK73SCGDebOk_C DDRC_DurDeb.rbrOut_tiK73SCGDebDef_C
      DDRC_DurDeb.rbrOut_tiK80OLDebOk_C DDRC_DurDeb.rbrOut_tiK80OLDebDef_C DDRC_DurDeb.rbrOut_tiK80OTDebOk_C DDRC_DurDeb.rbrOut_tiK80OTDebDef_C DDRC_DurDeb.rbrOut_tiK80SCBDebOk_C DDRC_DurDeb.rbrOut_tiK80SCBDebDef_C
      DDRC_DurDeb.rbrOut_tiK80SCGDebOk_C DDRC_DurDeb.rbrOut_tiK80SCGDebDef_C DDRC_DurDeb.rbrOut_tiK81OLDebOk_C DDRC_DurDeb.rbrOut_tiK81OLDebDef_C DDRC_DurDeb.rbrOut_tiK81OTDebOk_C DDRC_DurDeb.rbrOut_tiK81OTDebDef_C
      DDRC_DurDeb.rbrOut_tiK81SCBDebOk_C DDRC_DurDeb.rbrOut_tiK81SCBDebDef_C DDRC_DurDeb.rbrOut_tiK81SCGDebOk_C DDRC_DurDeb.rbrOut_tiK81SCGDebDef_C DDRC_DurDeb.rbrOut_tiK82OLDebOk_C DDRC_DurDeb.rbrOut_tiK82OLDebDef_C
      DDRC_DurDeb.rbrOut_tiK82OTDebOk_C DDRC_DurDeb.rbrOut_tiK82OTDebDef_C DDRC_DurDeb.rbrOut_tiK82SCBDebOk_C DDRC_DurDeb.rbrOut_tiK82SCBDebDef_C DDRC_DurDeb.rbrOut_tiK82SCGDebOk_C DDRC_DurDeb.rbrOut_tiK82SCGDebDef_C
      DDRC_DurDeb.rbrOut_tiK83OLDebOk_C DDRC_DurDeb.rbrOut_tiK83OLDebDef_C DDRC_DurDeb.rbrOut_tiK83OTDebOk_C DDRC_DurDeb.rbrOut_tiK83OTDebDef_C DDRC_DurDeb.rbrOut_tiK83SCBDebOk_C DDRC_DurDeb.rbrOut_tiK83SCBDebDef_C
      DDRC_DurDeb.rbrOut_tiK83SCGDebOk_C DDRC_DurDeb.rbrOut_tiK83SCGDebDef_C DDRC_DurDeb.rbrOut_tiK84OLDebOk_C DDRC_DurDeb.rbrOut_tiK84OLDebDef_C DDRC_DurDeb.rbrOut_tiK84OTDebOk_C DDRC_DurDeb.rbrOut_tiK84OTDebDef_C
      DDRC_DurDeb.rbrOut_tiK84SCBDebOk_C DDRC_DurDeb.rbrOut_tiK84SCBDebDef_C DDRC_DurDeb.rbrOut_tiK84SCGDebOk_C DDRC_DurDeb.rbrOut_tiK84SCGDebDef_C DDRC_DurDeb.rbrOut_tiK85OLDebOk_C DDRC_DurDeb.rbrOut_tiK85OLDebDef_C
      DDRC_DurDeb.rbrOut_tiK85OTDebOk_C DDRC_DurDeb.rbrOut_tiK85OTDebDef_C DDRC_DurDeb.rbrOut_tiK85SCBDebOk_C DDRC_DurDeb.rbrOut_tiK85SCBDebDef_C DDRC_DurDeb.rbrOut_tiK85SCGDebOk_C DDRC_DurDeb.rbrOut_tiK85SCGDebDef_C
      DDRC_DurDeb.rbrOut_tiK86OLDebOk_C DDRC_DurDeb.rbrOut_tiK86OLDebDef_C DDRC_DurDeb.rbrOut_tiK86OTDebOk_C DDRC_DurDeb.rbrOut_tiK86OTDebDef_C DDRC_DurDeb.rbrOut_tiK86SCBDebOk_C DDRC_DurDeb.rbrOut_tiK86SCBDebDef_C
      DDRC_DurDeb.rbrOut_tiK86SCGDebOk_C DDRC_DurDeb.rbrOut_tiK86SCGDebDef_C DDRC_DurDeb.rbrOut_tiK87OLDebOk_C DDRC_DurDeb.rbrOut_tiK87OLDebDef_C DDRC_DurDeb.rbrOut_tiK87OTDebOk_C DDRC_DurDeb.rbrOut_tiK87OTDebDef_C
      DDRC_DurDeb.rbrOut_tiK87SCBDebOk_C DDRC_DurDeb.rbrOut_tiK87SCBDebDef_C DDRC_DurDeb.rbrOut_tiK87SCGDebOk_C DDRC_DurDeb.rbrOut_tiK87SCGDebDef_C DDRC_DurDeb.rbr_mo_DvUBAT_FWsDebOk_C DDRC_DurDeb.rbr_mo_DvUBAT_FWsDebDef_C
      DDRC_DurDeb.rbr_mo_OVErr_VPR6DebOk_C DDRC_DurDeb.rbr_mo_OVErr_VPR6DebDef_C DDRC_DurDeb.rbr_mo_OVWarn_VPR6DebOk_C DDRC_DurDeb.rbr_mo_OVWarn_VPR6DebDef_C DDRC_DurDeb.rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2DebOk_C DDRC_DurDeb.rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2DebDef_C
      DDRC_DurDeb.rbr_mo_OV_UBAT_MONDebOk_C DDRC_DurDeb.rbr_mo_OV_UBAT_MONDebDef_C DDRC_DurDeb.rbr_mo_OV_UBRM24_FLEXINDebOk_C DDRC_DurDeb.rbr_mo_OV_UBRM24_FLEXINDebDef_C DDRC_DurDeb.rbr_mo_OV_UBRM24_LOADSDebOk_C DDRC_DurDeb.rbr_mo_OV_UBRM24_LOADSDebDef_C
      DDRC_DurDeb.rbr_mo_OV_UBRM24_MONDebOk_C DDRC_DurDeb.rbr_mo_OV_UBRM24_MONDebDef_C DDRC_DurDeb.rbr_mo_OV_VDD5DebOk_C DDRC_DurDeb.rbr_mo_OV_VDD5DebDef_C DDRC_DurDeb.rbr_mo_OV_VDD5_INDebOk_C DDRC_DurDeb.rbr_mo_OV_VDD5_INDebDef_C
      DDRC_DurDeb.rbr_mo_OV_VPR6DebOk_C DDRC_DurDeb.rbr_mo_OV_VPR6DebDef_C DDRC_DurDeb.rbr_mo_OV_VSS3DebOk_C DDRC_DurDeb.rbr_mo_OV_VSS3DebDef_C DDRC_DurDeb.rbr_mo_OV_VSS4DebOk_C DDRC_DurDeb.rbr_mo_OV_VSS4DebDef_C
      DDRC_DurDeb.rbr_mo_Temp1_HTErrDebOk_C DDRC_DurDeb.rbr_mo_Temp1_HTErrDebDef_C DDRC_DurDeb.rbr_mo_Temp1_HTWarnDebOk_C DDRC_DurDeb.rbr_mo_Temp1_HTWarnDebDef_C DDRC_DurDeb.rbr_mo_Temp2_HTErrDebOk_C DDRC_DurDeb.rbr_mo_Temp2_HTErrDebDef_C
      DDRC_DurDeb.rbr_mo_Temp2_HTWarnDebOk_C DDRC_DurDeb.rbr_mo_Temp2_HTWarnDebDef_C DDRC_DurDeb.rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2DebOk_C DDRC_DurDeb.rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2DebDef_C DDRC_DurDeb.rbr_mo_UV_VDD5DebOk_C DDRC_DurDeb.rbr_mo_UV_VDD5DebDef_C
      DDRC_DurDeb.rbr_mo_UV_VDD5_INDebOk_C DDRC_DurDeb.rbr_mo_UV_VDD5_INDebDef_C DDRC_DurDeb.rbr_mo_UV_VPR6DebOk_C DDRC_DurDeb.rbr_mo_UV_VPR6DebDef_C DDRC_DurDeb.rbr_mo_UV_VSS3DebOk_C DDRC_DurDeb.rbr_mo_UV_VSS3DebDef_C
      DDRC_DurDeb.rbr_mo_UV_VSS4DebOk_C DDRC_DurDeb.rbr_mo_UV_VSS4DebDef_C DDRC_DurDeb.bds_dsm_EventUpDownDebOk_C DDRC_DurDeb.bds_dsm_EventUpDownDebDef_C DDRC_DurDeb.bds_dsm_TimeInRowDebOk_C DDRC_DurDeb.bds_dsm_TimeInRowDebDef_C
      DDRC_DurDeb.bds_dsm_EventInRowDebOk_C DDRC_DurDeb.bds_dsm_EventInRowDebDef_C DDRC_RatDeb.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3UDRat_C DDRC_RatDeb.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3UDRat_C DDRC_RatDeb.DFC_rbr_outA01OL_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA01OT_tiUDRat_C
      DDRC_RatDeb.DFC_rbr_outA01SCB_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA01SCG_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA02OL_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA02OR_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA02OT_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA02SCB_tiUDRat_C
      DDRC_RatDeb.DFC_rbr_outA02SCG_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA03OL_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA03OT_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA03SCB_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA03SCG_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA04OL_tiUDRat_C
      DDRC_RatDeb.DFC_rbr_outA04OT_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA04SCB_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA04SCG_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA05OL_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA05OR_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA05OT_tiUDRat_C
      DDRC_RatDeb.DFC_rbr_outA05SCB_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA05SCG_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA06OL_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA06OR_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA06OT_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA06SCB_tiUDRat_C
      DDRC_RatDeb.DFC_rbr_outA06SCG_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA07OL_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA07OT_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA07SCB_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA07SCG_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA08OL_tiUDRat_C
      DDRC_RatDeb.DFC_rbr_outA08OT_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA08SCB_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA08SCG_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA09OL_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA09OR_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA09OT_tiUDRat_C
      DDRC_RatDeb.DFC_rbr_outA09SCB_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA09SCG_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA10OL_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA10OT_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA10SCB_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA10SCG_tiUDRat_C
      DDRC_RatDeb.DFC_rbr_outA11OL_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA11OT_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA11SCB_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA11SCG_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA12OR_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA12SCB_tiUDRat_C
      DDRC_RatDeb.DFC_rbr_outA12SCG_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA16OL_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA16OT_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA16SCB_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA16SCG_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA17OL_tiUDRat_C
      DDRC_RatDeb.DFC_rbr_outA17OR_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA17OT_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA17SCB_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA17SCG_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA18OL_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA18OT_tiUDRat_C
      DDRC_RatDeb.DFC_rbr_outA18SCB_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA18SCG_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA19OL_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA19OR_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA19OT_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA19SCB_tiUDRat_C
      DDRC_RatDeb.DFC_rbr_outA19SCG_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA20OL_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA20OR_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA20OT_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA20SCB_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA20SCG_tiUDRat_C
      DDRC_RatDeb.DFC_rbr_outA31OL_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA31OR_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA31OT_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA31SCB_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA31SCG_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA32OL_tiUDRat_C
      DDRC_RatDeb.DFC_rbr_outA32OR_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA32OT_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA32SCB_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA32SCG_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA33OL_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA33OR_tiUDRat_C
      DDRC_RatDeb.DFC_rbr_outA33OT_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA33SCB_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA33SCG_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA34OL_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA34OR_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA34OT_tiUDRat_C
      DDRC_RatDeb.DFC_rbr_outA34SCB_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA34SCG_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA35OL_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA35OR_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA35OT_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA35SCB_tiUDRat_C
      DDRC_RatDeb.DFC_rbr_outA35SCG_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA46OL_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA46OR_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA46OT_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA46SCB_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA46SCG_tiUDRat_C
      DDRC_RatDeb.DFC_rbr_outA47OL_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA47OR_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA47OT_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA47SCB_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA47SCG_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA48OL_tiUDRat_C
      DDRC_RatDeb.DFC_rbr_outA48OR_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA48OT_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA48SCB_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA48SCG_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA49OL_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA49OT_tiUDRat_C
      DDRC_RatDeb.DFC_rbr_outA49SCB_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA49SCG_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA50OL_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA50OT_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA50SCB_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA50SCG_tiUDRat_C
      DDRC_RatDeb.DFC_rbr_outA51OL_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA51OR_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA51OT_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA51SCB_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA51SCG_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA52OL_tiUDRat_C
      DDRC_RatDeb.DFC_rbr_outA52OR_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA52OT_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA52SCB_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA52SCG_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA53OL_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA53OR_tiUDRat_C
      DDRC_RatDeb.DFC_rbr_outA53OT_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA53SCB_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA53SCG_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA54OL_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA54OR_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA54OT_tiUDRat_C
      DDRC_RatDeb.DFC_rbr_outA54SCB_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA54SCG_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA55OL_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA55OT_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA55SCB_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA55SCG_tiUDRat_C
      DDRC_RatDeb.DFC_rbr_outA56OL_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA56OT_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA56SCB_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA56SCG_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA58OL_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA58OT_tiUDRat_C
      DDRC_RatDeb.DFC_rbr_outA58SCB_tiUDRat_C DDRC_RatDeb.DFC_rbr_outA58SCG_tiUDRat_C DDRC_RatDeb.DFC_rbr_outK14OR_tiUDRat_C DDRC_RatDeb.DFC_rbr_outK15OR_tiUDRat_C DDRC_RatDeb.DFC_rbr_outK16OR_tiUDRat_C DDRC_RatDeb.DFC_rbr_outK17OL_tiUDRat_C
      DDRC_RatDeb.DFC_rbr_outK17OR_tiUDRat_C DDRC_RatDeb.DFC_rbr_outK17OT_tiUDRat_C DDRC_RatDeb.DFC_rbr_outK17SCB_tiUDRat_C DDRC_RatDeb.DFC_rbr_outK17SCG_tiUDRat_C DDRC_RatDeb.DevLib_tiBattUHiUDRat_C DDRC_RatDeb.DevLib_tiBattULoUDRat_C
      DDRC_RatDeb.bds_dsm_TimeUpDownUDRat_C DDRC_RatDeb.rbrIn_tK44SCBUDRat_C DDRC_RatDeb.rbrIn_tiA13ORUDRat_C DDRC_RatDeb.rbrIn_tiA13SCBUDRat_C DDRC_RatDeb.rbrIn_tiA13SCGUDRat_C DDRC_RatDeb.rbrIn_tiA14ORUDRat_C
      DDRC_RatDeb.rbrIn_tiA14SCBUDRat_C DDRC_RatDeb.rbrIn_tiA14SCGUDRat_C DDRC_RatDeb.rbrIn_tiA21ORUDRat_C DDRC_RatDeb.rbrIn_tiA21SCBUDRat_C DDRC_RatDeb.rbrIn_tiA21SCGUDRat_C DDRC_RatDeb.rbrIn_tiA22ORUDRat_C
      DDRC_RatDeb.rbrIn_tiA22SCBUDRat_C DDRC_RatDeb.rbrIn_tiA22SCGUDRat_C DDRC_RatDeb.rbrIn_tiA23ORUDRat_C DDRC_RatDeb.rbrIn_tiA23SCBUDRat_C DDRC_RatDeb.rbrIn_tiA23SCGUDRat_C DDRC_RatDeb.rbrIn_tiA24ORUDRat_C
      DDRC_RatDeb.rbrIn_tiA24SCBUDRat_C DDRC_RatDeb.rbrIn_tiA24SCGUDRat_C DDRC_RatDeb.rbrIn_tiA25ORUDRat_C DDRC_RatDeb.rbrIn_tiA25SCBUDRat_C DDRC_RatDeb.rbrIn_tiA25SCGUDRat_C DDRC_RatDeb.rbrIn_tiA26ORUDRat_C
      DDRC_RatDeb.rbrIn_tiA26SCBUDRat_C DDRC_RatDeb.rbrIn_tiA26SCGUDRat_C DDRC_RatDeb.rbrIn_tiA27ORUDRat_C DDRC_RatDeb.rbrIn_tiA27SCBUDRat_C DDRC_RatDeb.rbrIn_tiA27SCGUDRat_C DDRC_RatDeb.rbrIn_tiA28ORUDRat_C
      DDRC_RatDeb.rbrIn_tiA28SCBUDRat_C DDRC_RatDeb.rbrIn_tiA28SCGUDRat_C DDRC_RatDeb.rbrIn_tiA29ORUDRat_C DDRC_RatDeb.rbrIn_tiA29SCBUDRat_C DDRC_RatDeb.rbrIn_tiA29SCGUDRat_C DDRC_RatDeb.rbrIn_tiA36AicSCBUDRat_C
      DDRC_RatDeb.rbrIn_tiA36AicSCGUDRat_C DDRC_RatDeb.rbrIn_tiA36ORUDRat_C DDRC_RatDeb.rbrIn_tiA36SCBUDRat_C DDRC_RatDeb.rbrIn_tiA36SCGUDRat_C DDRC_RatDeb.rbrIn_tiA36ShuntSCBUDRat_C DDRC_RatDeb.rbrIn_tiA37AicSCBUDRat_C
      DDRC_RatDeb.rbrIn_tiA37AicSCGUDRat_C DDRC_RatDeb.rbrIn_tiA37ORUDRat_C DDRC_RatDeb.rbrIn_tiA37SCBUDRat_C DDRC_RatDeb.rbrIn_tiA37SCGUDRat_C DDRC_RatDeb.rbrIn_tiA37ShuntSCBUDRat_C DDRC_RatDeb.rbrIn_tiA38AicSCBUDRat_C
      DDRC_RatDeb.rbrIn_tiA38AicSCGUDRat_C DDRC_RatDeb.rbrIn_tiA38ORUDRat_C DDRC_RatDeb.rbrIn_tiA38SCBUDRat_C DDRC_RatDeb.rbrIn_tiA38SCGUDRat_C DDRC_RatDeb.rbrIn_tiA38ShuntSCBUDRat_C DDRC_RatDeb.rbrIn_tiA39AicSCBUDRat_C
      DDRC_RatDeb.rbrIn_tiA39AicSCGUDRat_C DDRC_RatDeb.rbrIn_tiA39ORUDRat_C DDRC_RatDeb.rbrIn_tiA39SCBUDRat_C DDRC_RatDeb.rbrIn_tiA39SCGUDRat_C DDRC_RatDeb.rbrIn_tiA39ShuntSCBUDRat_C DDRC_RatDeb.rbrIn_tiA40ORUDRat_C
      DDRC_RatDeb.rbrIn_tiA40SCBUDRat_C DDRC_RatDeb.rbrIn_tiA40SCGUDRat_C DDRC_RatDeb.rbrIn_tiA41ORUDRat_C DDRC_RatDeb.rbrIn_tiA41SCBUDRat_C DDRC_RatDeb.rbrIn_tiA41SCGUDRat_C DDRC_RatDeb.rbrIn_tiA42ORUDRat_C
      DDRC_RatDeb.rbrIn_tiA42SCBUDRat_C DDRC_RatDeb.rbrIn_tiA42SCGUDRat_C DDRC_RatDeb.rbrIn_tiA43AicSCBUDRat_C DDRC_RatDeb.rbrIn_tiA43AicSCGUDRat_C DDRC_RatDeb.rbrIn_tiA43ORUDRat_C DDRC_RatDeb.rbrIn_tiA43SCBUDRat_C
      DDRC_RatDeb.rbrIn_tiA43SCGUDRat_C DDRC_RatDeb.rbrIn_tiA43ShuntSCBUDRat_C DDRC_RatDeb.rbrIn_tiA44OLUDRat_C DDRC_RatDeb.rbrIn_tiA44SCBUDRat_C DDRC_RatDeb.rbrIn_tiA44SCGUDRat_C DDRC_RatDeb.rbrIn_tiA57ORUDRat_C
      DDRC_RatDeb.rbrIn_tiA57SCBUDRat_C DDRC_RatDeb.rbrIn_tiA57SCGUDRat_C DDRC_RatDeb.rbrIn_tiA59OLUDRat_C DDRC_RatDeb.rbrIn_tiA59SCBUDRat_C DDRC_RatDeb.rbrIn_tiA59SCGUDRat_C DDRC_RatDeb.rbrIn_tiK10ORUDRat_C
      DDRC_RatDeb.rbrIn_tiK10SCBUDRat_C DDRC_RatDeb.rbrIn_tiK10SCGUDRat_C DDRC_RatDeb.rbrIn_tiK11ORUDRat_C DDRC_RatDeb.rbrIn_tiK11SCBUDRat_C DDRC_RatDeb.rbrIn_tiK11SCGUDRat_C DDRC_RatDeb.rbrIn_tiK30AicSCBUDRat_C
      DDRC_RatDeb.rbrIn_tiK30AicSCGUDRat_C DDRC_RatDeb.rbrIn_tiK30ORUDRat_C DDRC_RatDeb.rbrIn_tiK30SCBUDRat_C DDRC_RatDeb.rbrIn_tiK30SCGUDRat_C DDRC_RatDeb.rbrIn_tiK30ShuntSCBUDRat_C DDRC_RatDeb.rbrIn_tiK31ORUDRat_C
      DDRC_RatDeb.rbrIn_tiK31SCBUDRat_C DDRC_RatDeb.rbrIn_tiK31SCGUDRat_C DDRC_RatDeb.rbrIn_tiK32ORUDRat_C DDRC_RatDeb.rbrIn_tiK32SCBUDRat_C DDRC_RatDeb.rbrIn_tiK32SCGUDRat_C DDRC_RatDeb.rbrIn_tiK33ORUDRat_C
      DDRC_RatDeb.rbrIn_tiK33SCBUDRat_C DDRC_RatDeb.rbrIn_tiK33SCGUDRat_C DDRC_RatDeb.rbrIn_tiK34ORUDRat_C DDRC_RatDeb.rbrIn_tiK34SCBUDRat_C DDRC_RatDeb.rbrIn_tiK34SCGUDRat_C DDRC_RatDeb.rbrIn_tiK35ORUDRat_C
      DDRC_RatDeb.rbrIn_tiK35SCBUDRat_C DDRC_RatDeb.rbrIn_tiK35SCGUDRat_C DDRC_RatDeb.rbrIn_tiK36ORUDRat_C DDRC_RatDeb.rbrIn_tiK36SCBUDRat_C DDRC_RatDeb.rbrIn_tiK36SCGUDRat_C DDRC_RatDeb.rbrIn_tiK37AicSCBUDRat_C
      DDRC_RatDeb.rbrIn_tiK37AicSCGUDRat_C DDRC_RatDeb.rbrIn_tiK37ORUDRat_C DDRC_RatDeb.rbrIn_tiK37SCBUDRat_C DDRC_RatDeb.rbrIn_tiK37SCGUDRat_C DDRC_RatDeb.rbrIn_tiK37ShuntSCBUDRat_C DDRC_RatDeb.rbrIn_tiK38AicSCBUDRat_C
      DDRC_RatDeb.rbrIn_tiK38AicSCGUDRat_C DDRC_RatDeb.rbrIn_tiK38ORUDRat_C DDRC_RatDeb.rbrIn_tiK38SCBUDRat_C DDRC_RatDeb.rbrIn_tiK38SCGUDRat_C DDRC_RatDeb.rbrIn_tiK38ShuntSCBUDRat_C DDRC_RatDeb.rbrIn_tiK39AicSCBUDRat_C
      DDRC_RatDeb.rbrIn_tiK39AicSCGUDRat_C DDRC_RatDeb.rbrIn_tiK39ORUDRat_C DDRC_RatDeb.rbrIn_tiK39SCBUDRat_C DDRC_RatDeb.rbrIn_tiK39SCGUDRat_C DDRC_RatDeb.rbrIn_tiK39ShuntSCBUDRat_C DDRC_RatDeb.rbrIn_tiK40AicSCBUDRat_C
      DDRC_RatDeb.rbrIn_tiK40AicSCGUDRat_C DDRC_RatDeb.rbrIn_tiK40ORUDRat_C DDRC_RatDeb.rbrIn_tiK40SCBUDRat_C DDRC_RatDeb.rbrIn_tiK40SCGUDRat_C DDRC_RatDeb.rbrIn_tiK40ShuntSCBUDRat_C DDRC_RatDeb.rbrIn_tiK41AicSCBUDRat_C
      DDRC_RatDeb.rbrIn_tiK41AicSCGUDRat_C DDRC_RatDeb.rbrIn_tiK41ORUDRat_C DDRC_RatDeb.rbrIn_tiK41SCBUDRat_C DDRC_RatDeb.rbrIn_tiK41SCGUDRat_C DDRC_RatDeb.rbrIn_tiK41ShuntSCBUDRat_C DDRC_RatDeb.rbrIn_tiK42AicSCBUDRat_C
      DDRC_RatDeb.rbrIn_tiK42AicSCGUDRat_C DDRC_RatDeb.rbrIn_tiK42ORUDRat_C DDRC_RatDeb.rbrIn_tiK42SCBUDRat_C DDRC_RatDeb.rbrIn_tiK42SCGUDRat_C DDRC_RatDeb.rbrIn_tiK42ShuntSCBUDRat_C DDRC_RatDeb.rbrIn_tiK43ORUDRat_C
      DDRC_RatDeb.rbrIn_tiK43SCBUDRat_C DDRC_RatDeb.rbrIn_tiK43SCGUDRat_C DDRC_RatDeb.rbrIn_tiK44AicSCBUDRat_C DDRC_RatDeb.rbrIn_tiK44AicSCGUDRat_C DDRC_RatDeb.rbrIn_tiK44ORUDRat_C DDRC_RatDeb.rbrIn_tiK44SCGUDRat_C
      DDRC_RatDeb.rbrIn_tiK44ShuntSCBUDRat_C DDRC_RatDeb.rbrIn_tiK45AicSCBUDRat_C DDRC_RatDeb.rbrIn_tiK45AicSCGUDRat_C DDRC_RatDeb.rbrIn_tiK45ORUDRat_C DDRC_RatDeb.rbrIn_tiK45SCBUDRat_C DDRC_RatDeb.rbrIn_tiK45SCGUDRat_C
      DDRC_RatDeb.rbrIn_tiK45ShuntSCBUDRat_C DDRC_RatDeb.rbrIn_tiK52ORUDRat_C DDRC_RatDeb.rbrIn_tiK52SCBUDRat_C DDRC_RatDeb.rbrIn_tiK52SCGUDRat_C DDRC_RatDeb.rbrIn_tiK53ORUDRat_C DDRC_RatDeb.rbrIn_tiK53SCBUDRat_C
      DDRC_RatDeb.rbrIn_tiK53SCGUDRat_C DDRC_RatDeb.rbrIn_tiK54AicSCBUDRat_C DDRC_RatDeb.rbrIn_tiK54AicSCGUDRat_C DDRC_RatDeb.rbrIn_tiK54ORUDRat_C DDRC_RatDeb.rbrIn_tiK54SCBUDRat_C DDRC_RatDeb.rbrIn_tiK54SCGUDRat_C
      DDRC_RatDeb.rbrIn_tiK54ShuntSCBUDRat_C DDRC_RatDeb.rbrIn_tiK55AicSCBUDRat_C DDRC_RatDeb.rbrIn_tiK55AicSCGUDRat_C DDRC_RatDeb.rbrIn_tiK55ORUDRat_C DDRC_RatDeb.rbrIn_tiK55SCBUDRat_C DDRC_RatDeb.rbrIn_tiK55SCGUDRat_C
      DDRC_RatDeb.rbrIn_tiK55ShuntSCBUDRat_C DDRC_RatDeb.rbrIn_tiK56ORUDRat_C DDRC_RatDeb.rbrIn_tiK56SCBUDRat_C DDRC_RatDeb.rbrIn_tiK56SCGUDRat_C DDRC_RatDeb.rbrIn_tiK57ORUDRat_C DDRC_RatDeb.rbrIn_tiK57SCBUDRat_C
      DDRC_RatDeb.rbrIn_tiK57SCGUDRat_C DDRC_RatDeb.rbrIn_tiK58ORUDRat_C DDRC_RatDeb.rbrIn_tiK58SCBUDRat_C DDRC_RatDeb.rbrIn_tiK58SCGUDRat_C DDRC_RatDeb.rbrIn_tiK59ORUDRat_C DDRC_RatDeb.rbrIn_tiK59SCBUDRat_C
      DDRC_RatDeb.rbrIn_tiK59SCGUDRat_C DDRC_RatDeb.rbrIn_tiK60ORUDRat_C DDRC_RatDeb.rbrIn_tiK60SCBUDRat_C DDRC_RatDeb.rbrIn_tiK60SCGUDRat_C DDRC_RatDeb.rbrIn_tiK61AicSCBUDRat_C DDRC_RatDeb.rbrIn_tiK61AicSCGUDRat_C
      DDRC_RatDeb.rbrIn_tiK61ORUDRat_C DDRC_RatDeb.rbrIn_tiK61SCBUDRat_C DDRC_RatDeb.rbrIn_tiK61SCGUDRat_C DDRC_RatDeb.rbrIn_tiK61ShuntSCBUDRat_C DDRC_RatDeb.rbrIn_tiK62ORUDRat_C DDRC_RatDeb.rbrIn_tiK62SCBUDRat_C
      DDRC_RatDeb.rbrIn_tiK62SCGUDRat_C DDRC_RatDeb.rbrIn_tiK63AicSCBUDRat_C DDRC_RatDeb.rbrIn_tiK63AicSCGUDRat_C DDRC_RatDeb.rbrIn_tiK63ORUDRat_C DDRC_RatDeb.rbrIn_tiK63SCBUDRat_C DDRC_RatDeb.rbrIn_tiK63SCGUDRat_C
      DDRC_RatDeb.rbrIn_tiK63ShuntSCBUDRat_C DDRC_RatDeb.rbrIn_tiK64AicSCBUDRat_C DDRC_RatDeb.rbrIn_tiK64AicSCGUDRat_C DDRC_RatDeb.rbrIn_tiK64ORUDRat_C DDRC_RatDeb.rbrIn_tiK64SCBUDRat_C DDRC_RatDeb.rbrIn_tiK64SCGUDRat_C
      DDRC_RatDeb.rbrIn_tiK64ShuntSCBUDRat_C DDRC_RatDeb.rbrIn_tiK65AicSCBUDRat_C DDRC_RatDeb.rbrIn_tiK65AicSCGUDRat_C DDRC_RatDeb.rbrIn_tiK65ORUDRat_C DDRC_RatDeb.rbrIn_tiK65SCBUDRat_C DDRC_RatDeb.rbrIn_tiK65SCGUDRat_C
      DDRC_RatDeb.rbrIn_tiK65ShuntSCBUDRat_C DDRC_RatDeb.rbrIn_tiK74ORUDRat_C DDRC_RatDeb.rbrIn_tiK74SCBUDRat_C DDRC_RatDeb.rbrIn_tiK74SCGUDRat_C DDRC_RatDeb.rbrIn_tiK75ORUDRat_C DDRC_RatDeb.rbrIn_tiK75SCBUDRat_C
      DDRC_RatDeb.rbrIn_tiK75SCGUDRat_C DDRC_RatDeb.rbrIn_tiK76ORUDRat_C DDRC_RatDeb.rbrIn_tiK76SCBUDRat_C DDRC_RatDeb.rbrIn_tiK76SCGUDRat_C DDRC_RatDeb.rbrIn_tiK77ORUDRat_C DDRC_RatDeb.rbrIn_tiK77SCBUDRat_C
      DDRC_RatDeb.rbrIn_tiK77SCGUDRat_C DDRC_RatDeb.rbrIn_tiK78ORUDRat_C DDRC_RatDeb.rbrIn_tiK78SCBUDRat_C DDRC_RatDeb.rbrIn_tiK78SCGUDRat_C DDRC_RatDeb.rbrOut_tiK07OLUDRat_C DDRC_RatDeb.rbrOut_tiK07ORUDRat_C
      DDRC_RatDeb.rbrOut_tiK07OTUDRat_C DDRC_RatDeb.rbrOut_tiK07SCBUDRat_C DDRC_RatDeb.rbrOut_tiK07SCGUDRat_C DDRC_RatDeb.rbrOut_tiK08OLUDRat_C DDRC_RatDeb.rbrOut_tiK08ORUDRat_C DDRC_RatDeb.rbrOut_tiK08OTUDRat_C
      DDRC_RatDeb.rbrOut_tiK08SCBUDRat_C DDRC_RatDeb.rbrOut_tiK08SCGUDRat_C DDRC_RatDeb.rbrOut_tiK09OLUDRat_C DDRC_RatDeb.rbrOut_tiK09ORUDRat_C DDRC_RatDeb.rbrOut_tiK09OTUDRat_C DDRC_RatDeb.rbrOut_tiK09SCBUDRat_C
      DDRC_RatDeb.rbrOut_tiK09SCGUDRat_C DDRC_RatDeb.rbrOut_tiK12OLUDRat_C DDRC_RatDeb.rbrOut_tiK12OTUDRat_C DDRC_RatDeb.rbrOut_tiK12SCBUDRat_C DDRC_RatDeb.rbrOut_tiK12SCGUDRat_C DDRC_RatDeb.rbrOut_tiK13OLUDRat_C
      DDRC_RatDeb.rbrOut_tiK13OTUDRat_C DDRC_RatDeb.rbrOut_tiK13SCBUDRat_C DDRC_RatDeb.rbrOut_tiK13SCGUDRat_C DDRC_RatDeb.rbrOut_tiK14OLUDRat_C DDRC_RatDeb.rbrOut_tiK14OTUDRat_C DDRC_RatDeb.rbrOut_tiK14SCBUDRat_C
      DDRC_RatDeb.rbrOut_tiK14SCGUDRat_C DDRC_RatDeb.rbrOut_tiK15OLUDRat_C DDRC_RatDeb.rbrOut_tiK15OTUDRat_C DDRC_RatDeb.rbrOut_tiK15SCBUDRat_C DDRC_RatDeb.rbrOut_tiK15SCGUDRat_C DDRC_RatDeb.rbrOut_tiK16OLUDRat_C
      DDRC_RatDeb.rbrOut_tiK16OTUDRat_C DDRC_RatDeb.rbrOut_tiK16SCBUDRat_C DDRC_RatDeb.rbrOut_tiK16SCGUDRat_C DDRC_RatDeb.rbrOut_tiK25ORUDRat_C DDRC_RatDeb.rbrOut_tiK25SCBUDRat_C DDRC_RatDeb.rbrOut_tiK25SCGUDRat_C
      DDRC_RatDeb.rbrOut_tiK29OLUDRat_C DDRC_RatDeb.rbrOut_tiK29ORUDRat_C DDRC_RatDeb.rbrOut_tiK29OTUDRat_C DDRC_RatDeb.rbrOut_tiK29SCBUDRat_C DDRC_RatDeb.rbrOut_tiK29SCGUDRat_C DDRC_RatDeb.rbrOut_tiK51OLUDRat_C
      DDRC_RatDeb.rbrOut_tiK51OTUDRat_C DDRC_RatDeb.rbrOut_tiK51SCBUDRat_C DDRC_RatDeb.rbrOut_tiK51SCGUDRat_C DDRC_RatDeb.rbrOut_tiK62ORUDRat_C DDRC_RatDeb.rbrOut_tiK62SCBUDRat_C DDRC_RatDeb.rbrOut_tiK62SCGUDRat_C
      DDRC_RatDeb.rbrOut_tiK73OLUDRat_C DDRC_RatDeb.rbrOut_tiK73ORUDRat_C DDRC_RatDeb.rbrOut_tiK73OTUDRat_C DDRC_RatDeb.rbrOut_tiK73SCBUDRat_C DDRC_RatDeb.rbrOut_tiK73SCGUDRat_C DDRC_RatDeb.rbrOut_tiK80OLUDRat_C
      DDRC_RatDeb.rbrOut_tiK80OTUDRat_C DDRC_RatDeb.rbrOut_tiK80SCBUDRat_C DDRC_RatDeb.rbrOut_tiK80SCGUDRat_C DDRC_RatDeb.rbrOut_tiK81OLUDRat_C DDRC_RatDeb.rbrOut_tiK81OTUDRat_C DDRC_RatDeb.rbrOut_tiK81SCBUDRat_C
      DDRC_RatDeb.rbrOut_tiK81SCGUDRat_C DDRC_RatDeb.rbrOut_tiK82OLUDRat_C DDRC_RatDeb.rbrOut_tiK82OTUDRat_C DDRC_RatDeb.rbrOut_tiK82SCBUDRat_C DDRC_RatDeb.rbrOut_tiK82SCGUDRat_C DDRC_RatDeb.rbrOut_tiK83OLUDRat_C
      DDRC_RatDeb.rbrOut_tiK83OTUDRat_C DDRC_RatDeb.rbrOut_tiK83SCBUDRat_C DDRC_RatDeb.rbrOut_tiK83SCGUDRat_C DDRC_RatDeb.rbrOut_tiK84OLUDRat_C DDRC_RatDeb.rbrOut_tiK84OTUDRat_C DDRC_RatDeb.rbrOut_tiK84SCBUDRat_C
      DDRC_RatDeb.rbrOut_tiK84SCGUDRat_C DDRC_RatDeb.rbrOut_tiK85OLUDRat_C DDRC_RatDeb.rbrOut_tiK85OTUDRat_C DDRC_RatDeb.rbrOut_tiK85SCBUDRat_C DDRC_RatDeb.rbrOut_tiK85SCGUDRat_C DDRC_RatDeb.rbrOut_tiK86OLUDRat_C
      DDRC_RatDeb.rbrOut_tiK86OTUDRat_C DDRC_RatDeb.rbrOut_tiK86SCBUDRat_C DDRC_RatDeb.rbrOut_tiK86SCGUDRat_C DDRC_RatDeb.rbrOut_tiK87OLUDRat_C DDRC_RatDeb.rbrOut_tiK87OTUDRat_C DDRC_RatDeb.rbrOut_tiK87SCBUDRat_C
      DDRC_RatDeb.rbrOut_tiK87SCGUDRat_C DDRC_RatDeb.rbr_mo_DvUBAT_FWsUDRat_C DDRC_RatDeb.rbr_mo_OVErr_VPR6UDRat_C DDRC_RatDeb.rbr_mo_OVWarn_VPR6UDRat_C DDRC_RatDeb.rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2UDRat_C DDRC_RatDeb.rbr_mo_OV_UBAT_MONUDRat_C
      DDRC_RatDeb.rbr_mo_OV_UBRM24_FLEXINUDRat_C DDRC_RatDeb.rbr_mo_OV_UBRM24_LOADSUDRat_C DDRC_RatDeb.rbr_mo_OV_UBRM24_MONUDRat_C DDRC_RatDeb.rbr_mo_OV_VDD5UDRat_C DDRC_RatDeb.rbr_mo_OV_VDD5_INUDRat_C DDRC_RatDeb.rbr_mo_OV_VPR6UDRat_C
      DDRC_RatDeb.rbr_mo_OV_VSS3UDRat_C DDRC_RatDeb.rbr_mo_OV_VSS4UDRat_C DDRC_RatDeb.rbr_mo_Temp1_HTErrUDRat_C DDRC_RatDeb.rbr_mo_Temp1_HTWarnUDRat_C DDRC_RatDeb.rbr_mo_Temp2_HTErrUDRat_C DDRC_RatDeb.rbr_mo_Temp2_HTWarnUDRat_C
      DDRC_RatDeb.rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2UDRat_C DDRC_RatDeb.rbr_mo_UV_VDD5UDRat_C DDRC_RatDeb.rbr_mo_UV_VDD5_INUDRat_C DDRC_RatDeb.rbr_mo_UV_VPR6UDRat_C DDRC_RatDeb.rbr_mo_UV_VSS3UDRat_C DDRC_RatDeb.rbr_mo_UV_VSS4UDRat_C
      DDRC_RatDeb.bds_dsm_EventUpDownUDRat_C
    /end DEF_CHARACTERISTIC
    /begin LOC_MEASUREMENT
      DDRC_St.DFC_bds_TimeInRowDebFault DDRC_St.DFC_bds_EventInRowDebFault DDRC_St.DFC_DevLibBattUHi DDRC_St.DFC_DevLibBattULo DDRC_St.DFC_bds_TimeUpDownDebFault DDRC_St.DFC_rbr_inA13OR
      DDRC_St.DFC_rbr_inA13SCB DDRC_St.DFC_rbr_inA13SCG DDRC_St.DFC_rbr_inA14OR DDRC_St.DFC_rbr_inA14SCB DDRC_St.DFC_rbr_inA14SCG DDRC_St.DFC_rbr_inA21OR
      DDRC_St.DFC_rbr_inA21SCB DDRC_St.DFC_rbr_inA21SCG DDRC_St.DFC_rbr_inA22OR DDRC_St.DFC_rbr_inA22SCB DDRC_St.DFC_rbr_inA22SCG DDRC_St.DFC_rbr_inA23OR
      DDRC_St.DFC_rbr_inA23SCB DDRC_St.DFC_rbr_inA23SCG DDRC_St.DFC_rbr_inA24OR DDRC_St.DFC_rbr_inA24SCB DDRC_St.DFC_rbr_inA24SCG DDRC_St.DFC_rbr_inA25OR
      DDRC_St.DFC_rbr_inA25SCB DDRC_St.DFC_rbr_inA25SCG DDRC_St.DFC_rbr_inA26OR DDRC_St.DFC_rbr_inA26SCB DDRC_St.DFC_rbr_inA26SCG DDRC_St.DFC_rbr_inA27OR
      DDRC_St.DFC_rbr_inA27SCB DDRC_St.DFC_rbr_inA27SCG DDRC_St.DFC_rbr_inA28OR DDRC_St.DFC_rbr_inA28SCB DDRC_St.DFC_rbr_inA28SCG DDRC_St.DFC_rbr_inA29OR
      DDRC_St.DFC_rbr_inA29SCB DDRC_St.DFC_rbr_inA29SCG DDRC_St.DFC_rbr_inA36AicSCB DDRC_St.DFC_rbr_inA36AicSCG DDRC_St.DFC_rbr_inA36OR DDRC_St.DFC_rbr_inA36SCB
      DDRC_St.DFC_rbr_inA36SCG DDRC_St.DFC_rbr_inA36ShuntSCB DDRC_St.DFC_rbr_inA37AicSCB DDRC_St.DFC_rbr_inA37AicSCG DDRC_St.DFC_rbr_inA37OR DDRC_St.DFC_rbr_inA37SCB
      DDRC_St.DFC_rbr_inA37SCG DDRC_St.DFC_rbr_inA37ShuntSCB DDRC_St.DFC_rbr_inA38AicSCB DDRC_St.DFC_rbr_inA38AicSCG DDRC_St.DFC_rbr_inA38OR DDRC_St.DFC_rbr_inA38SCB
      DDRC_St.DFC_rbr_inA38SCG DDRC_St.DFC_rbr_inA38ShuntSCB DDRC_St.DFC_rbr_inA39AicSCB DDRC_St.DFC_rbr_inA39AicSCG DDRC_St.DFC_rbr_inA39OR DDRC_St.DFC_rbr_inA39SCB
      DDRC_St.DFC_rbr_inA39SCG DDRC_St.DFC_rbr_inA39ShuntSCB DDRC_St.DFC_rbr_inA40OR DDRC_St.DFC_rbr_inA40SCB DDRC_St.DFC_rbr_inA40SCG DDRC_St.DFC_rbr_inA41OR
      DDRC_St.DFC_rbr_inA41SCB DDRC_St.DFC_rbr_inA41SCG DDRC_St.DFC_rbr_inA42OR DDRC_St.DFC_rbr_inA42SCB DDRC_St.DFC_rbr_inA42SCG DDRC_St.DFC_rbr_inA43AicSCB
      DDRC_St.DFC_rbr_inA43AicSCG DDRC_St.DFC_rbr_inA43OR DDRC_St.DFC_rbr_inA43SCB DDRC_St.DFC_rbr_inA43SCG DDRC_St.DFC_rbr_inA43ShuntSCB DDRC_St.DFC_rbr_inA44OL
      DDRC_St.DFC_rbr_inA44SCB DDRC_St.DFC_rbr_inA44SCG DDRC_St.DFC_rbr_inA57OR DDRC_St.DFC_rbr_inA57SCB DDRC_St.DFC_rbr_inA57SCG DDRC_St.DFC_rbr_inA59OL
      DDRC_St.DFC_rbr_inA59SCB DDRC_St.DFC_rbr_inA59SCG DDRC_St.DFC_rbr_inK10OR DDRC_St.DFC_rbr_inK10SCB DDRC_St.DFC_rbr_inK10SCG DDRC_St.DFC_rbr_inK11OR
      DDRC_St.DFC_rbr_inK11SCB DDRC_St.DFC_rbr_inK11SCG DDRC_St.DFC_rbr_inK30AicSCB DDRC_St.DFC_rbr_inK30AicSCG DDRC_St.DFC_rbr_inK30OR DDRC_St.DFC_rbr_inK30SCB
      DDRC_St.DFC_rbr_inK30SCG DDRC_St.DFC_rbr_inK30ShuntSCB DDRC_St.DFC_rbr_inK31OR DDRC_St.DFC_rbr_inK31SCB DDRC_St.DFC_rbr_inK31SCG DDRC_St.DFC_rbr_inK32OR
      DDRC_St.DFC_rbr_inK32SCB DDRC_St.DFC_rbr_inK32SCG DDRC_St.DFC_rbr_inK33OR DDRC_St.DFC_rbr_inK33SCB DDRC_St.DFC_rbr_inK33SCG DDRC_St.DFC_rbr_inK34OR
      DDRC_St.DFC_rbr_inK34SCB DDRC_St.DFC_rbr_inK34SCG DDRC_St.DFC_rbr_inK35OR DDRC_St.DFC_rbr_inK35SCB DDRC_St.DFC_rbr_inK35SCG DDRC_St.DFC_rbr_inK36OR
      DDRC_St.DFC_rbr_inK36SCB DDRC_St.DFC_rbr_inK36SCG DDRC_St.DFC_rbr_inK37AicSCB DDRC_St.DFC_rbr_inK37AicSCG DDRC_St.DFC_rbr_inK37OR DDRC_St.DFC_rbr_inK37SCB
      DDRC_St.DFC_rbr_inK37SCG DDRC_St.DFC_rbr_inK37ShuntSCB DDRC_St.DFC_rbr_inK38AicSCB DDRC_St.DFC_rbr_inK38AicSCG DDRC_St.DFC_rbr_inK38OR DDRC_St.DFC_rbr_inK38SCB
      DDRC_St.DFC_rbr_inK38SCG DDRC_St.DFC_rbr_inK38ShuntSCB DDRC_St.DFC_rbr_inK39AicSCB DDRC_St.DFC_rbr_inK39AicSCG DDRC_St.DFC_rbr_inK39OR DDRC_St.DFC_rbr_inK39SCB
      DDRC_St.DFC_rbr_inK39SCG DDRC_St.DFC_rbr_inK39ShuntSCB DDRC_St.DFC_rbr_inK40AicSCB DDRC_St.DFC_rbr_inK40AicSCG DDRC_St.DFC_rbr_inK40OR DDRC_St.DFC_rbr_inK40SCB
      DDRC_St.DFC_rbr_inK40SCG DDRC_St.DFC_rbr_inK40ShuntSCB DDRC_St.DFC_rbr_inK41AicSCB DDRC_St.DFC_rbr_inK41AicSCG DDRC_St.DFC_rbr_inK41OR DDRC_St.DFC_rbr_inK41SCB
      DDRC_St.DFC_rbr_inK41SCG DDRC_St.DFC_rbr_inK41ShuntSCB DDRC_St.DFC_rbr_inK42AicSCB DDRC_St.DFC_rbr_inK42AicSCG DDRC_St.DFC_rbr_inK42OR DDRC_St.DFC_rbr_inK42SCB
      DDRC_St.DFC_rbr_inK42SCG DDRC_St.DFC_rbr_inK42ShuntSCB DDRC_St.DFC_rbr_inK43OR DDRC_St.DFC_rbr_inK43SCB DDRC_St.DFC_rbr_inK43SCG DDRC_St.DFC_rbr_inK44AicSCB
      DDRC_St.DFC_rbr_inK44AicSCG DDRC_St.DFC_rbr_inK44OR DDRC_St.DFC_rbr_inK44SCB DDRC_St.DFC_rbr_inK44SCG DDRC_St.DFC_rbr_inK44ShuntSCB DDRC_St.DFC_rbr_inK45AicSCB
      DDRC_St.DFC_rbr_inK45AicSCG DDRC_St.DFC_rbr_inK45OR DDRC_St.DFC_rbr_inK45SCB DDRC_St.DFC_rbr_inK45SCG DDRC_St.DFC_rbr_inK45ShuntSCB DDRC_St.DFC_rbr_inK52OR
      DDRC_St.DFC_rbr_inK52SCB DDRC_St.DFC_rbr_inK52SCG DDRC_St.DFC_rbr_inK53OR DDRC_St.DFC_rbr_inK53SCB DDRC_St.DFC_rbr_inK53SCG DDRC_St.DFC_rbr_inK54AicSCB
      DDRC_St.DFC_rbr_inK54AicSCG DDRC_St.DFC_rbr_inK54OR DDRC_St.DFC_rbr_inK54SCB DDRC_St.DFC_rbr_inK54SCG DDRC_St.DFC_rbr_inK54ShuntSCB DDRC_St.DFC_rbr_inK55AicSCB
      DDRC_St.DFC_rbr_inK55AicSCG DDRC_St.DFC_rbr_inK55OR DDRC_St.DFC_rbr_inK55SCB DDRC_St.DFC_rbr_inK55SCG DDRC_St.DFC_rbr_inK55ShuntSCB DDRC_St.DFC_rbr_inK56OR
      DDRC_St.DFC_rbr_inK56SCB DDRC_St.DFC_rbr_inK56SCG DDRC_St.DFC_rbr_inK57OR DDRC_St.DFC_rbr_inK57SCB DDRC_St.DFC_rbr_inK57SCG DDRC_St.DFC_rbr_inK58OR
      DDRC_St.DFC_rbr_inK58SCB DDRC_St.DFC_rbr_inK58SCG DDRC_St.DFC_rbr_inK59OR DDRC_St.DFC_rbr_inK59SCB DDRC_St.DFC_rbr_inK59SCG DDRC_St.DFC_rbr_inK60OR
      DDRC_St.DFC_rbr_inK60SCB DDRC_St.DFC_rbr_inK60SCG DDRC_St.DFC_rbr_inK61AicSCB DDRC_St.DFC_rbr_inK61AicSCG DDRC_St.DFC_rbr_inK61OR DDRC_St.DFC_rbr_inK61SCB
      DDRC_St.DFC_rbr_inK61SCG DDRC_St.DFC_rbr_inK61ShuntSCB DDRC_St.DFC_rbr_inK62OR DDRC_St.DFC_rbr_inK62SCB DDRC_St.DFC_rbr_inK62SCG DDRC_St.DFC_rbr_inK63AicSCB
      DDRC_St.DFC_rbr_inK63AicSCG DDRC_St.DFC_rbr_inK63OR DDRC_St.DFC_rbr_inK63SCB DDRC_St.DFC_rbr_inK63SCG DDRC_St.DFC_rbr_inK63ShuntSCB DDRC_St.DFC_rbr_inK64AicSCB
      DDRC_St.DFC_rbr_inK64AicSCG DDRC_St.DFC_rbr_inK64OR DDRC_St.DFC_rbr_inK64SCB DDRC_St.DFC_rbr_inK64SCG DDRC_St.DFC_rbr_inK64ShuntSCB DDRC_St.DFC_rbr_inK65AicSCB
      DDRC_St.DFC_rbr_inK65AicSCG DDRC_St.DFC_rbr_inK65OR DDRC_St.DFC_rbr_inK65SCB DDRC_St.DFC_rbr_inK65SCG DDRC_St.DFC_rbr_inK65ShuntSCB DDRC_St.DFC_rbr_inK74OR
      DDRC_St.DFC_rbr_inK74SCB DDRC_St.DFC_rbr_inK74SCG DDRC_St.DFC_rbr_inK75OR DDRC_St.DFC_rbr_inK75SCB DDRC_St.DFC_rbr_inK75SCG DDRC_St.DFC_rbr_inK76OR
      DDRC_St.DFC_rbr_inK76SCB DDRC_St.DFC_rbr_inK76SCG DDRC_St.DFC_rbr_inK77OR DDRC_St.DFC_rbr_inK77SCB DDRC_St.DFC_rbr_inK77SCG DDRC_St.DFC_rbr_inK78OR
      DDRC_St.DFC_rbr_inK78SCB DDRC_St.DFC_rbr_inK78SCG DDRC_St.DFC_rbr_mo_DvUBAT_FWs DDRC_St.DFC_rbr_mo_OVErr_VPR6 DDRC_St.DFC_rbr_mo_OVWarn_VPR6 DDRC_St.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3
      DDRC_St.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2 DDRC_St.DFC_rbr_mo_OV_UBAT_MON DDRC_St.DFC_rbr_mo_OV_UBRM24_FLEXIN DDRC_St.DFC_rbr_mo_OV_UBRM24_LOADS DDRC_St.DFC_rbr_mo_OV_UBRM24_MON DDRC_St.DFC_rbr_mo_OV_VDD5
      DDRC_St.DFC_rbr_mo_OV_VDD5_IN DDRC_St.DFC_rbr_mo_OV_VPR6 DDRC_St.DFC_rbr_mo_OV_VSS3 DDRC_St.DFC_rbr_mo_OV_VSS4 DDRC_St.DFC_rbr_mo_Temp1_HTErr DDRC_St.DFC_rbr_mo_Temp1_HTWarn
      DDRC_St.DFC_rbr_mo_Temp2_HTErr DDRC_St.DFC_rbr_mo_Temp2_HTWarn DDRC_St.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3 DDRC_St.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2 DDRC_St.DFC_rbr_mo_UV_VDD5 DDRC_St.DFC_rbr_mo_UV_VDD5_IN
      DDRC_St.DFC_rbr_mo_UV_VPR6 DDRC_St.DFC_rbr_mo_UV_VSS3 DDRC_St.DFC_rbr_mo_UV_VSS4 DDRC_St.DFC_rbr_outA01OL DDRC_St.DFC_rbr_outA01OT DDRC_St.DFC_rbr_outA01SCB
      DDRC_St.DFC_rbr_outA01SCG DDRC_St.DFC_rbr_outA02OL DDRC_St.DFC_rbr_outA02OR DDRC_St.DFC_rbr_outA02OT DDRC_St.DFC_rbr_outA02SCB DDRC_St.DFC_rbr_outA02SCG
      DDRC_St.DFC_rbr_outA03OL DDRC_St.DFC_rbr_outA03OT DDRC_St.DFC_rbr_outA03SCB DDRC_St.DFC_rbr_outA03SCG DDRC_St.DFC_rbr_outA04OL DDRC_St.DFC_rbr_outA04OT
      DDRC_St.DFC_rbr_outA04SCB DDRC_St.DFC_rbr_outA04SCG DDRC_St.DFC_rbr_outA05OL DDRC_St.DFC_rbr_outA05OR DDRC_St.DFC_rbr_outA05OT DDRC_St.DFC_rbr_outA05SCB
      DDRC_St.DFC_rbr_outA05SCG DDRC_St.DFC_rbr_outA06OL DDRC_St.DFC_rbr_outA06OR DDRC_St.DFC_rbr_outA06OT DDRC_St.DFC_rbr_outA06SCB DDRC_St.DFC_rbr_outA06SCG
      DDRC_St.DFC_rbr_outA07OL DDRC_St.DFC_rbr_outA07OT DDRC_St.DFC_rbr_outA07SCB DDRC_St.DFC_rbr_outA07SCG DDRC_St.DFC_rbr_outA08OL DDRC_St.DFC_rbr_outA08OT
      DDRC_St.DFC_rbr_outA08SCB DDRC_St.DFC_rbr_outA08SCG DDRC_St.DFC_rbr_outA09OL DDRC_St.DFC_rbr_outA09OR DDRC_St.DFC_rbr_outA09OT DDRC_St.DFC_rbr_outA09SCB
      DDRC_St.DFC_rbr_outA09SCG DDRC_St.DFC_rbr_outA10OL DDRC_St.DFC_rbr_outA10OT DDRC_St.DFC_rbr_outA10SCB DDRC_St.DFC_rbr_outA10SCG DDRC_St.DFC_rbr_outA11OL
      DDRC_St.DFC_rbr_outA11OT DDRC_St.DFC_rbr_outA11SCB DDRC_St.DFC_rbr_outA11SCG DDRC_St.DFC_rbr_outA12OR DDRC_St.DFC_rbr_outA12SCB DDRC_St.DFC_rbr_outA12SCG
      DDRC_St.DFC_rbr_outA16OL DDRC_St.DFC_rbr_outA16OT DDRC_St.DFC_rbr_outA16SCB DDRC_St.DFC_rbr_outA16SCG DDRC_St.DFC_rbr_outA17OL DDRC_St.DFC_rbr_outA17OR
      DDRC_St.DFC_rbr_outA17OT DDRC_St.DFC_rbr_outA17SCB DDRC_St.DFC_rbr_outA17SCG DDRC_St.DFC_rbr_outA18OL DDRC_St.DFC_rbr_outA18OT DDRC_St.DFC_rbr_outA18SCB
      DDRC_St.DFC_rbr_outA18SCG DDRC_St.DFC_rbr_outA19OL DDRC_St.DFC_rbr_outA19OR DDRC_St.DFC_rbr_outA19OT DDRC_St.DFC_rbr_outA19SCB DDRC_St.DFC_rbr_outA19SCG
      DDRC_St.DFC_rbr_outA20OL DDRC_St.DFC_rbr_outA20OR DDRC_St.DFC_rbr_outA20OT DDRC_St.DFC_rbr_outA20SCB DDRC_St.DFC_rbr_outA20SCG DDRC_St.DFC_rbr_outA31OL
      DDRC_St.DFC_rbr_outA31OR DDRC_St.DFC_rbr_outA31OT DDRC_St.DFC_rbr_outA31SCB DDRC_St.DFC_rbr_outA31SCG DDRC_St.DFC_rbr_outA32OL DDRC_St.DFC_rbr_outA32OR
      DDRC_St.DFC_rbr_outA32OT DDRC_St.DFC_rbr_outA32SCB DDRC_St.DFC_rbr_outA32SCG DDRC_St.DFC_rbr_outA33OL DDRC_St.DFC_rbr_outA33OR DDRC_St.DFC_rbr_outA33OT
      DDRC_St.DFC_rbr_outA33SCB DDRC_St.DFC_rbr_outA33SCG DDRC_St.DFC_rbr_outA34OL DDRC_St.DFC_rbr_outA34OR DDRC_St.DFC_rbr_outA34OT DDRC_St.DFC_rbr_outA34SCB
      DDRC_St.DFC_rbr_outA34SCG DDRC_St.DFC_rbr_outA35OL DDRC_St.DFC_rbr_outA35OR DDRC_St.DFC_rbr_outA35OT DDRC_St.DFC_rbr_outA35SCB DDRC_St.DFC_rbr_outA35SCG
      DDRC_St.DFC_rbr_outA46OL DDRC_St.DFC_rbr_outA46OR DDRC_St.DFC_rbr_outA46OT DDRC_St.DFC_rbr_outA46SCB DDRC_St.DFC_rbr_outA46SCG DDRC_St.DFC_rbr_outA47OL
      DDRC_St.DFC_rbr_outA47OR DDRC_St.DFC_rbr_outA47OT DDRC_St.DFC_rbr_outA47SCB DDRC_St.DFC_rbr_outA47SCG DDRC_St.DFC_rbr_outA48OL DDRC_St.DFC_rbr_outA48OR
      DDRC_St.DFC_rbr_outA48OT DDRC_St.DFC_rbr_outA48SCB DDRC_St.DFC_rbr_outA48SCG DDRC_St.DFC_rbr_outA49OL DDRC_St.DFC_rbr_outA49OT DDRC_St.DFC_rbr_outA49SCB
      DDRC_St.DFC_rbr_outA49SCG DDRC_St.DFC_rbr_outA50OL DDRC_St.DFC_rbr_outA50OT DDRC_St.DFC_rbr_outA50SCB DDRC_St.DFC_rbr_outA50SCG DDRC_St.DFC_rbr_outA51OL
      DDRC_St.DFC_rbr_outA51OR DDRC_St.DFC_rbr_outA51OT DDRC_St.DFC_rbr_outA51SCB DDRC_St.DFC_rbr_outA51SCG DDRC_St.DFC_rbr_outA52OL DDRC_St.DFC_rbr_outA52OR
      DDRC_St.DFC_rbr_outA52OT DDRC_St.DFC_rbr_outA52SCB DDRC_St.DFC_rbr_outA52SCG DDRC_St.DFC_rbr_outA53OL DDRC_St.DFC_rbr_outA53OR DDRC_St.DFC_rbr_outA53OT
      DDRC_St.DFC_rbr_outA53SCB DDRC_St.DFC_rbr_outA53SCG DDRC_St.DFC_rbr_outA54OL DDRC_St.DFC_rbr_outA54OR DDRC_St.DFC_rbr_outA54OT DDRC_St.DFC_rbr_outA54SCB
      DDRC_St.DFC_rbr_outA54SCG DDRC_St.DFC_rbr_outA55OL DDRC_St.DFC_rbr_outA55OT DDRC_St.DFC_rbr_outA55SCB DDRC_St.DFC_rbr_outA55SCG DDRC_St.DFC_rbr_outA56OL
      DDRC_St.DFC_rbr_outA56OT DDRC_St.DFC_rbr_outA56SCB DDRC_St.DFC_rbr_outA56SCG DDRC_St.DFC_rbr_outA58OL DDRC_St.DFC_rbr_outA58OT DDRC_St.DFC_rbr_outA58SCB
      DDRC_St.DFC_rbr_outA58SCG DDRC_St.DFC_rbr_outK07OL DDRC_St.DFC_rbr_outK07OR DDRC_St.DFC_rbr_outK07OT DDRC_St.DFC_rbr_outK07SCB DDRC_St.DFC_rbr_outK07SCG
      DDRC_St.DFC_rbr_outK08OL DDRC_St.DFC_rbr_outK08OR DDRC_St.DFC_rbr_outK08OT DDRC_St.DFC_rbr_outK08SCB DDRC_St.DFC_rbr_outK08SCG DDRC_St.DFC_rbr_outK09OL
      DDRC_St.DFC_rbr_outK09OR DDRC_St.DFC_rbr_outK09OT DDRC_St.DFC_rbr_outK09SCB DDRC_St.DFC_rbr_outK09SCG DDRC_St.DFC_rbr_outK12OL DDRC_St.DFC_rbr_outK12OT
      DDRC_St.DFC_rbr_outK12SCB DDRC_St.DFC_rbr_outK12SCG DDRC_St.DFC_rbr_outK13OL DDRC_St.DFC_rbr_outK13OT DDRC_St.DFC_rbr_outK13SCB DDRC_St.DFC_rbr_outK13SCG
      DDRC_St.DFC_rbr_outK14OL DDRC_St.DFC_rbr_outK14OR DDRC_St.DFC_rbr_outK14OT DDRC_St.DFC_rbr_outK14SCB DDRC_St.DFC_rbr_outK14SCG DDRC_St.DFC_rbr_outK15OL
      DDRC_St.DFC_rbr_outK15OR DDRC_St.DFC_rbr_outK15OT DDRC_St.DFC_rbr_outK15SCB DDRC_St.DFC_rbr_outK15SCG DDRC_St.DFC_rbr_outK16OL DDRC_St.DFC_rbr_outK16OR
      DDRC_St.DFC_rbr_outK16OT DDRC_St.DFC_rbr_outK16SCB DDRC_St.DFC_rbr_outK16SCG DDRC_St.DFC_rbr_outK17OL DDRC_St.DFC_rbr_outK17OR DDRC_St.DFC_rbr_outK17OT
