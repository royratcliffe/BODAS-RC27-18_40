    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM6_17"
    VALUE
    0x808012BA
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM6_18_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM6_18"
    VALUE
    0x808012BB
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM6_2_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM6_2"
    VALUE
    0x808012BC
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM6_20_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM6_20"
    VALUE
    0x808012BD
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM6_21_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM6_21"
    VALUE
    0x808012BE
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM6_25_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM6_25"
    VALUE
    0x808012BF
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM6_4_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM6_4"
    VALUE
    0x808012C0
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM6_5_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM6_5"
    VALUE
    0x808012C1
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM6_7_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM6_7"
    VALUE
    0x808012C2
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM6_8_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM6_8"
    VALUE
    0x808012C3
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM7_1_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM7_1"
    VALUE
    0x808012C4
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM7_12_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM7_12"
    VALUE
    0x808012C5
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM7_13_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM7_13"
    VALUE
    0x808012C6
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM7_14_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM7_14"
    VALUE
    0x808012C7
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM7_15_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM7_15"
    VALUE
    0x808012C8
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM7_16_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM7_16"
    VALUE
    0x808012C9
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM7_17_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM7_17"
    VALUE
    0x808012CA
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM7_2_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM7_2"
    VALUE
    0x808012CB
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM7_20_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM7_20"
    VALUE
    0x808012CC
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM7_25_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM7_25"
    VALUE
    0x808012CD
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM7_26_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM7_26"
    VALUE
    0x808012CE
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM7_28_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM7_28"
    VALUE
    0x808012CF
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM7_29_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM7_29"
    VALUE
    0x808012D0
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM7_30_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM7_30"
    VALUE
    0x808012D1
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM7_31_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM7_31"
    VALUE
    0x808012D2
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM8_0_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM8_0"
    VALUE
    0x808012D3
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM8_1_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM8_1"
    VALUE
    0x808012D4
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM8_10_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM8_10"
    VALUE
    0x808012D5
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM8_11_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM8_11"
    VALUE
    0x808012D6
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM8_12_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM8_12"
    VALUE
    0x808012D7
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM8_13_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM8_13"
    VALUE
    0x808012D8
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM8_16_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM8_16"
    VALUE
    0x808012D9
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM8_18_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM8_18"
    VALUE
    0x808012DA
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM8_2_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM8_2"
    VALUE
    0x808012DB
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM8_3_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM8_3"
    VALUE
    0x808012DC
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM8_30_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM8_30"
    VALUE
    0x808012DD
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM8_31_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM8_31"
    VALUE
    0x808012DE
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM8_4_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM8_4"
    VALUE
    0x808012DF
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM9_0_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM9_0"
    VALUE
    0x808012E0
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM9_1_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM9_1"
    VALUE
    0x808012E1
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM9_15_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM9_15"
    VALUE
    0x808012E2
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM9_3_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM9_3"
    VALUE
    0x808012E3
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MoCSOPICO_C
    "fault class per DFC / Fault class for check DFC_MoCSOPICO"
    VALUE
    0x808012E4
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MoFVarPostBldSel_C
    "fault class per DFC / Fault class for check DFC_MoFVarPostBldSel"
    VALUE
    0x808012E5
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MoSysCtrlReIni_C
    "fault class per DFC / Fault class for check DFC_MoSysCtrlReIni"
    VALUE
    0x808012E6
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MoXEMMHwLTMCUFW_C
    "fault class per DFC / Fault class for check DFC_MoXEMMHwLTMCUFW"
    VALUE
    0x808012E7
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MoXEMMHwLTMonBIST_C
    "fault class per DFC / Fault class for check DFC_MoXEMMHwLTMonBIST"
    VALUE
    0x808012E8
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MoXEMMHwLTRegMonTest_C
    "fault class per DFC / Fault class for check DFC_MoXEMMHwLTRegMonTest"
    VALUE
    0x808012E9
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MoXEMMHwLTStbySMUAlvTest_C
    "fault class per DFC / Fault class for check DFC_MoXEMMHwLTStbySMUAlvTest"
    VALUE
    0x808012EA
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MoXEMMHwLTTempSens_C
    "fault class per DFC / Fault class for check DFC_MoXEMMHwLTTempSens"
    VALUE
    0x808012EB
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MoXEMMHwLTUCBCfg_C
    "fault class per DFC / Fault class for check DFC_MoXEMMHwLTUCBCfg"
    VALUE
    0x808012EC
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_OCWDAABEActv_C
    "fault class per DFC / Fault class for check DFC_OCWDAABEActv"
    VALUE
    0x808012ED
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_OCWDACom_C
    "fault class per DFC / Fault class for check DFC_OCWDACom"
    VALUE
    0x808012EE
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_OCWDAErrPin_C
    "fault class per DFC / Fault class for check DFC_OCWDAErrPin"
    VALUE
    0x808012EF
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_SWReset_0_C
    "fault class per DFC / Fault class for check DFC_SWReset_0"
    VALUE
    0x808012F0
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_SWReset_1_C
    "fault class per DFC / Fault class for check DFC_SWReset_1"
    VALUE
    0x808012F1
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_SWReset_2_C
    "fault class per DFC / Fault class for check DFC_SWReset_2"
    VALUE
    0x808012F2
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDebFault1_C
    "fault class per DFC / Fault class for check DFC_bds_NoDebFault1"
    VALUE
    0x808012F3
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_ctDstTrig_C
    ""
    VALUE
    0x808012F4
    Val_Wu8
    254.0
    OneToOne
    1.0
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DbLv_C
    "Debounce level limit for creating fault entry (valid for all DFCs)"
    VALUE
    0x808012F5
    Val_Wu8
    15.00
    DFES_OneToOne
    0.00
    15.00

    FORMAT "%5.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_Unused_C
    "manufacterer specific trouble code / "
    VALUE
    0x80802B6C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    READ_ONLY

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_TimeInRowDebFault_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_TimeInRowDebFault"
    VALUE
    0x80802B6E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_EventInRowDebFault_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_EventInRowDebFault"
    VALUE
    0x80802B70
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_DevLibBattUHi_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_DevLibBattUHi"
    VALUE
    0x80802B72
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_DevLibBattULo_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_DevLibBattULo"
    VALUE
    0x80802B74
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_TimeUpDownDebFault_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_TimeUpDownDebFault"
    VALUE
    0x80802B76
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA13OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA13OR"
    VALUE
    0x80802B78
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA13SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA13SCB"
    VALUE
    0x80802B7A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA13SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA13SCG"
    VALUE
    0x80802B7C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA14OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA14OR"
    VALUE
    0x80802B7E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA14SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA14SCB"
    VALUE
    0x80802B80
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA14SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA14SCG"
    VALUE
    0x80802B82
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA21OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA21OR"
    VALUE
    0x80802B84
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA21SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA21SCB"
    VALUE
    0x80802B86
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA21SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA21SCG"
    VALUE
    0x80802B88
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA22OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA22OR"
    VALUE
    0x80802B8A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA22SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA22SCB"
    VALUE
    0x80802B8C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA22SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA22SCG"
    VALUE
    0x80802B8E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA23OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA23OR"
    VALUE
    0x80802B90
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA23SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA23SCB"
    VALUE
    0x80802B92
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA23SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA23SCG"
    VALUE
    0x80802B94
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA24OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA24OR"
    VALUE
    0x80802B96
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA24SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA24SCB"
    VALUE
    0x80802B98
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA24SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA24SCG"
    VALUE
    0x80802B9A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA25OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA25OR"
    VALUE
    0x80802B9C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA25SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA25SCB"
    VALUE
    0x80802B9E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA25SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA25SCG"
    VALUE
    0x80802BA0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA26OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA26OR"
    VALUE
    0x80802BA2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA26SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA26SCB"
    VALUE
    0x80802BA4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA26SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA26SCG"
    VALUE
    0x80802BA6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA27OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA27OR"
    VALUE
    0x80802BA8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA27SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA27SCB"
    VALUE
    0x80802BAA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA27SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA27SCG"
    VALUE
    0x80802BAC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA28OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA28OR"
    VALUE
    0x80802BAE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA28SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA28SCB"
    VALUE
    0x80802BB0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA28SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA28SCG"
    VALUE
    0x80802BB2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA29OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA29OR"
    VALUE
    0x80802BB4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA29SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA29SCB"
    VALUE
    0x80802BB6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA29SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA29SCG"
    VALUE
    0x80802BB8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA36AicSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA36AicSCB"
    VALUE
    0x80802BBA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA36AicSCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA36AicSCG"
    VALUE
    0x80802BBC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA36OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA36OR"
    VALUE
    0x80802BBE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA36SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA36SCB"
    VALUE
    0x80802BC0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA36SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA36SCG"
    VALUE
    0x80802BC2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA36ShuntSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA36ShuntSCB"
    VALUE
    0x80802BC4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA37AicSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA37AicSCB"
    VALUE
    0x80802BC6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA37AicSCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA37AicSCG"
    VALUE
    0x80802BC8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA37OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA37OR"
    VALUE
    0x80802BCA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA37SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA37SCB"
    VALUE
    0x80802BCC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA37SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA37SCG"
    VALUE
    0x80802BCE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA37ShuntSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA37ShuntSCB"
    VALUE
    0x80802BD0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA38AicSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA38AicSCB"
    VALUE
    0x80802BD2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA38AicSCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA38AicSCG"
    VALUE
    0x80802BD4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA38OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA38OR"
    VALUE
    0x80802BD6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA38SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA38SCB"
    VALUE
    0x80802BD8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA38SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA38SCG"
    VALUE
    0x80802BDA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA38ShuntSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA38ShuntSCB"
    VALUE
    0x80802BDC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA39AicSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA39AicSCB"
    VALUE
    0x80802BDE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA39AicSCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA39AicSCG"
    VALUE
    0x80802BE0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA39OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA39OR"
    VALUE
    0x80802BE2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA39SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA39SCB"
    VALUE
    0x80802BE4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA39SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA39SCG"
    VALUE
    0x80802BE6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA39ShuntSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA39ShuntSCB"
    VALUE
    0x80802BE8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA40OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA40OR"
    VALUE
    0x80802BEA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA40SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA40SCB"
    VALUE
    0x80802BEC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA40SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA40SCG"
    VALUE
    0x80802BEE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA41OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA41OR"
    VALUE
    0x80802BF0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA41SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA41SCB"
    VALUE
    0x80802BF2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA41SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA41SCG"
    VALUE
    0x80802BF4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA42OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA42OR"
    VALUE
    0x80802BF6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA42SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA42SCB"
    VALUE
    0x80802BF8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA42SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA42SCG"
    VALUE
    0x80802BFA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA43AicSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA43AicSCB"
    VALUE
    0x80802BFC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA43AicSCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA43AicSCG"
    VALUE
    0x80802BFE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA43OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA43OR"
    VALUE
    0x80802C00
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA43SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA43SCB"
    VALUE
    0x80802C02
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA43SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA43SCG"
    VALUE
    0x80802C04
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA43ShuntSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA43ShuntSCB"
    VALUE
    0x80802C06
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA44OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA44OL"
    VALUE
    0x80802C08
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA44SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA44SCB"
    VALUE
    0x80802C0A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA44SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA44SCG"
    VALUE
    0x80802C0C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA57OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA57OR"
    VALUE
    0x80802C0E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA57SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA57SCB"
    VALUE
    0x80802C10
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA57SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA57SCG"
    VALUE
    0x80802C12
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA59OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA59OL"
    VALUE
    0x80802C14
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA59SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA59SCB"
    VALUE
    0x80802C16
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA59SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA59SCG"
    VALUE
    0x80802C18
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK10OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK10OR"
    VALUE
    0x80802C1A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK10SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK10SCB"
    VALUE
    0x80802C1C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK10SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK10SCG"
    VALUE
    0x80802C1E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK11OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK11OR"
    VALUE
    0x80802C20
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK11SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK11SCB"
    VALUE
    0x80802C22
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK11SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK11SCG"
    VALUE
    0x80802C24
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK30AicSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK30AicSCB"
    VALUE
    0x80802C26
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK30AicSCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK30AicSCG"
    VALUE
    0x80802C28
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK30OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK30OR"
    VALUE
    0x80802C2A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK30SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK30SCB"
    VALUE
    0x80802C2C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK30SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK30SCG"
    VALUE
    0x80802C2E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK30ShuntSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK30ShuntSCB"
    VALUE
    0x80802C30
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK31OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK31OR"
    VALUE
    0x80802C32
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK31SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK31SCB"
    VALUE
    0x80802C34
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK31SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK31SCG"
    VALUE
    0x80802C36
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK32OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK32OR"
    VALUE
    0x80802C38
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK32SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK32SCB"
    VALUE
    0x80802C3A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK32SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK32SCG"
    VALUE
    0x80802C3C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK33OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK33OR"
    VALUE
    0x80802C3E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK33SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK33SCB"
    VALUE
    0x80802C40
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK33SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK33SCG"
    VALUE
    0x80802C42
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK34OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK34OR"
    VALUE
    0x80802C44
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK34SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK34SCB"
    VALUE
    0x80802C46
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK34SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK34SCG"
    VALUE
    0x80802C48
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK35OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK35OR"
    VALUE
    0x80802C4A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK35SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK35SCB"
    VALUE
    0x80802C4C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK35SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK35SCG"
    VALUE
    0x80802C4E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK36OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK36OR"
    VALUE
    0x80802C50
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK36SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK36SCB"
    VALUE
    0x80802C52
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK36SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK36SCG"
    VALUE
    0x80802C54
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK37AicSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK37AicSCB"
    VALUE
    0x80802C56
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK37AicSCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK37AicSCG"
    VALUE
    0x80802C58
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK37OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK37OR"
    VALUE
    0x80802C5A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK37SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK37SCB"
    VALUE
    0x80802C5C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK37SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK37SCG"
    VALUE
    0x80802C5E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK37ShuntSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK37ShuntSCB"
    VALUE
    0x80802C60
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK38AicSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK38AicSCB"
    VALUE
    0x80802C62
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK38AicSCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK38AicSCG"
    VALUE
    0x80802C64
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK38OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK38OR"
    VALUE
    0x80802C66
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK38SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK38SCB"
    VALUE
    0x80802C68
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK38SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK38SCG"
    VALUE
    0x80802C6A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK38ShuntSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK38ShuntSCB"
    VALUE
    0x80802C6C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK39AicSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK39AicSCB"
    VALUE
    0x80802C6E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK39AicSCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK39AicSCG"
    VALUE
    0x80802C70
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK39OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK39OR"
    VALUE
    0x80802C72
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK39SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK39SCB"
    VALUE
    0x80802C74
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK39SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK39SCG"
    VALUE
    0x80802C76
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK39ShuntSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK39ShuntSCB"
    VALUE
    0x80802C78
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK40AicSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK40AicSCB"
    VALUE
    0x80802C7A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK40AicSCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK40AicSCG"
    VALUE
    0x80802C7C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK40OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK40OR"
    VALUE
    0x80802C7E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK40SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK40SCB"
    VALUE
    0x80802C80
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK40SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK40SCG"
    VALUE
    0x80802C82
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK40ShuntSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK40ShuntSCB"
    VALUE
    0x80802C84
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK41AicSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK41AicSCB"
    VALUE
    0x80802C86
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK41AicSCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK41AicSCG"
    VALUE
    0x80802C88
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK41OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK41OR"
    VALUE
    0x80802C8A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK41SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK41SCB"
    VALUE
    0x80802C8C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK41SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK41SCG"
    VALUE
    0x80802C8E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK41ShuntSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK41ShuntSCB"
    VALUE
    0x80802C90
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK42AicSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK42AicSCB"
    VALUE
    0x80802C92
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK42AicSCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK42AicSCG"
    VALUE
    0x80802C94
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK42OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK42OR"
    VALUE
    0x80802C96
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK42SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK42SCB"
    VALUE
    0x80802C98
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK42SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK42SCG"
    VALUE
    0x80802C9A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK42ShuntSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK42ShuntSCB"
    VALUE
    0x80802C9C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK43OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK43OR"
    VALUE
    0x80802C9E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK43SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK43SCB"
    VALUE
    0x80802CA0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK43SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK43SCG"
    VALUE
    0x80802CA2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK44AicSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK44AicSCB"
    VALUE
    0x80802CA4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK44AicSCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK44AicSCG"
    VALUE
    0x80802CA6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK44OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK44OR"
    VALUE
    0x80802CA8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK44SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK44SCB"
    VALUE
    0x80802CAA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK44SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK44SCG"
    VALUE
    0x80802CAC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK44ShuntSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK44ShuntSCB"
    VALUE
    0x80802CAE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK45AicSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK45AicSCB"
    VALUE
    0x80802CB0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK45AicSCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK45AicSCG"
    VALUE
    0x80802CB2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK45OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK45OR"
    VALUE
    0x80802CB4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK45SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK45SCB"
    VALUE
    0x80802CB6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK45SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK45SCG"
    VALUE
    0x80802CB8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK45ShuntSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK45ShuntSCB"
    VALUE
    0x80802CBA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK52OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK52OR"
    VALUE
    0x80802CBC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK52SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK52SCB"
    VALUE
    0x80802CBE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK52SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK52SCG"
    VALUE
    0x80802CC0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK53OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK53OR"
    VALUE
    0x80802CC2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK53SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK53SCB"
    VALUE
    0x80802CC4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK53SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK53SCG"
    VALUE
    0x80802CC6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK54AicSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK54AicSCB"
    VALUE
    0x80802CC8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK54AicSCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK54AicSCG"
    VALUE
    0x80802CCA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK54OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK54OR"
    VALUE
    0x80802CCC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK54SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK54SCB"
    VALUE
    0x80802CCE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK54SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK54SCG"
    VALUE
    0x80802CD0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK54ShuntSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK54ShuntSCB"
    VALUE
    0x80802CD2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK55AicSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK55AicSCB"
    VALUE
    0x80802CD4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK55AicSCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK55AicSCG"
    VALUE
    0x80802CD6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK55OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK55OR"
    VALUE
    0x80802CD8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK55SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK55SCB"
    VALUE
    0x80802CDA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK55SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK55SCG"
    VALUE
    0x80802CDC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK55ShuntSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK55ShuntSCB"
    VALUE
    0x80802CDE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK56OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK56OR"
    VALUE
    0x80802CE0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK56SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK56SCB"
    VALUE
    0x80802CE2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK56SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK56SCG"
    VALUE
    0x80802CE4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK57OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK57OR"
    VALUE
    0x80802CE6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK57SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK57SCB"
    VALUE
    0x80802CE8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK57SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK57SCG"
    VALUE
    0x80802CEA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK58OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK58OR"
    VALUE
    0x80802CEC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK58SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK58SCB"
    VALUE
    0x80802CEE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK58SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK58SCG"
    VALUE
    0x80802CF0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK59OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK59OR"
    VALUE
    0x80802CF2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK59SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK59SCB"
    VALUE
    0x80802CF4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK59SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK59SCG"
    VALUE
    0x80802CF6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK60OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK60OR"
    VALUE
    0x80802CF8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK60SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK60SCB"
    VALUE
    0x80802CFA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK60SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK60SCG"
    VALUE
    0x80802CFC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK61AicSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK61AicSCB"
    VALUE
    0x80802CFE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK61AicSCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK61AicSCG"
    VALUE
    0x80802D00
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK61OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK61OR"
    VALUE
    0x80802D02
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK61SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK61SCB"
    VALUE
    0x80802D04
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK61SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK61SCG"
    VALUE
    0x80802D06
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK61ShuntSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK61ShuntSCB"
    VALUE
    0x80802D08
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK62OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK62OR"
    VALUE
    0x80802D0A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK62SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK62SCB"
    VALUE
    0x80802D0C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK62SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK62SCG"
    VALUE
    0x80802D0E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK63AicSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK63AicSCB"
    VALUE
    0x80802D10
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK63AicSCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK63AicSCG"
    VALUE
    0x80802D12
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK63OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK63OR"
    VALUE
    0x80802D14
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK63SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK63SCB"
    VALUE
    0x80802D16
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK63SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK63SCG"
    VALUE
    0x80802D18
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK63ShuntSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK63ShuntSCB"
    VALUE
    0x80802D1A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK64AicSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK64AicSCB"
    VALUE
    0x80802D1C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK64AicSCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK64AicSCG"
    VALUE
    0x80802D1E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK64OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK64OR"
    VALUE
    0x80802D20
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK64SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK64SCB"
    VALUE
    0x80802D22
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK64SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK64SCG"
    VALUE
    0x80802D24
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK64ShuntSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK64ShuntSCB"
    VALUE
    0x80802D26
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK65AicSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK65AicSCB"
    VALUE
    0x80802D28
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK65AicSCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK65AicSCG"
    VALUE
    0x80802D2A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK65OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK65OR"
    VALUE
    0x80802D2C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK65SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK65SCB"
    VALUE
    0x80802D2E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK65SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK65SCG"
    VALUE
    0x80802D30
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK65ShuntSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK65ShuntSCB"
    VALUE
    0x80802D32
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK74OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK74OR"
    VALUE
    0x80802D34
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK74SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK74SCB"
    VALUE
    0x80802D36
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK74SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK74SCG"
    VALUE
    0x80802D38
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK75OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK75OR"
    VALUE
    0x80802D3A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK75SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK75SCB"
    VALUE
    0x80802D3C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK75SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK75SCG"
    VALUE
    0x80802D3E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK76OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK76OR"
    VALUE
    0x80802D40
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK76SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK76SCB"
    VALUE
    0x80802D42
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK76SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK76SCG"
    VALUE
    0x80802D44
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK77OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK77OR"
    VALUE
    0x80802D46
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK77SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK77SCB"
    VALUE
    0x80802D48
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK77SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK77SCG"
    VALUE
    0x80802D4A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK78OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK78OR"
    VALUE
    0x80802D4C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK78SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK78SCB"
    VALUE
    0x80802D4E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK78SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK78SCG"
    VALUE
    0x80802D50
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_DvUBAT_FWs_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_DvUBAT_FWs"
    VALUE
    0x80802D52
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_OVErr_VPR6_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_OVErr_VPR6"
    VALUE
    0x80802D54
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_OVWarn_VPR6_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_OVWarn_VPR6"
    VALUE
    0x80802D56
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3"
    VALUE
    0x80802D58
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2"
    VALUE
    0x80802D5A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_OV_UBAT_MON_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_OV_UBAT_MON"
    VALUE
    0x80802D5C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_OV_UBRM24_FLEXIN_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_OV_UBRM24_FLEXIN"
    VALUE
    0x80802D5E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_OV_UBRM24_LOADS_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_OV_UBRM24_LOADS"
    VALUE
    0x80802D60
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_OV_UBRM24_MON_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_OV_UBRM24_MON"
    VALUE
    0x80802D62
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_OV_VDD5_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_OV_VDD5"
    VALUE
    0x80802D64
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_OV_VDD5_IN_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_OV_VDD5_IN"
    VALUE
    0x80802D66
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_OV_VPR6_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_OV_VPR6"
    VALUE
    0x80802D68
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_OV_VSS3_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_OV_VSS3"
    VALUE
    0x80802D6A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_OV_VSS4_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_OV_VSS4"
    VALUE
    0x80802D6C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_Temp1_HTErr_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_Temp1_HTErr"
    VALUE
    0x80802D6E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_Temp1_HTWarn_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_Temp1_HTWarn"
    VALUE
    0x80802D70
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_Temp2_HTErr_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_Temp2_HTErr"
    VALUE
    0x80802D72
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_Temp2_HTWarn_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_Temp2_HTWarn"
    VALUE
    0x80802D74
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3"
    VALUE
    0x80802D76
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2"
    VALUE
    0x80802D78
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_UV_VDD5_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_UV_VDD5"
    VALUE
    0x80802D7A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_UV_VDD5_IN_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_UV_VDD5_IN"
    VALUE
    0x80802D7C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_UV_VPR6_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_UV_VPR6"
    VALUE
    0x80802D7E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_UV_VSS3_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_UV_VSS3"
    VALUE
    0x80802D80
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_UV_VSS4_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_UV_VSS4"
    VALUE
    0x80802D82
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA01OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA01OL"
    VALUE
    0x80802D84
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA01OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA01OT"
    VALUE
    0x80802D86
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA01SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA01SCB"
    VALUE
    0x80802D88
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA01SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA01SCG"
    VALUE
    0x80802D8A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA02OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA02OL"
    VALUE
    0x80802D8C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA02OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA02OR"
    VALUE
    0x80802D8E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA02OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA02OT"
    VALUE
    0x80802D90
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA02SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA02SCB"
    VALUE
    0x80802D92
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA02SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA02SCG"
    VALUE
    0x80802D94
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA03OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA03OL"
    VALUE
    0x80802D96
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA03OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA03OT"
    VALUE
    0x80802D98
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA03SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA03SCB"
    VALUE
    0x80802D9A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA03SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA03SCG"
    VALUE
    0x80802D9C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA04OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA04OL"
    VALUE
    0x80802D9E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA04OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA04OT"
    VALUE
    0x80802DA0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA04SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA04SCB"
    VALUE
    0x80802DA2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA04SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA04SCG"
    VALUE
    0x80802DA4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA05OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA05OL"
    VALUE
    0x80802DA6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA05OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA05OR"
    VALUE
    0x80802DA8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA05OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA05OT"
    VALUE
    0x80802DAA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA05SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA05SCB"
    VALUE
    0x80802DAC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA05SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA05SCG"
    VALUE
    0x80802DAE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA06OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA06OL"
    VALUE
    0x80802DB0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA06OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA06OR"
    VALUE
    0x80802DB2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA06OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA06OT"
    VALUE
    0x80802DB4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA06SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA06SCB"
    VALUE
    0x80802DB6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA06SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA06SCG"
    VALUE
    0x80802DB8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA07OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA07OL"
    VALUE
    0x80802DBA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA07OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA07OT"
    VALUE
    0x80802DBC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA07SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA07SCB"
    VALUE
    0x80802DBE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA07SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA07SCG"
    VALUE
    0x80802DC0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA08OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA08OL"
    VALUE
    0x80802DC2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA08OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA08OT"
    VALUE
    0x80802DC4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA08SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA08SCB"
    VALUE
    0x80802DC6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA08SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA08SCG"
    VALUE
    0x80802DC8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA09OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA09OL"
    VALUE
    0x80802DCA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA09OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA09OR"
    VALUE
    0x80802DCC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA09OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA09OT"
    VALUE
    0x80802DCE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA09SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA09SCB"
    VALUE
    0x80802DD0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA09SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA09SCG"
    VALUE
    0x80802DD2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA10OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA10OL"
    VALUE
    0x80802DD4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA10OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA10OT"
    VALUE
    0x80802DD6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA10SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA10SCB"
    VALUE
    0x80802DD8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA10SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA10SCG"
    VALUE
    0x80802DDA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA11OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA11OL"
    VALUE
    0x80802DDC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA11OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA11OT"
    VALUE
    0x80802DDE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA11SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA11SCB"
    VALUE
    0x80802DE0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA11SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA11SCG"
    VALUE
    0x80802DE2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA12OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA12OR"
    VALUE
    0x80802DE4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA12SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA12SCB"
    VALUE
    0x80802DE6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA12SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA12SCG"
    VALUE
    0x80802DE8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA16OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA16OL"
    VALUE
    0x80802DEA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA16OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA16OT"
    VALUE
    0x80802DEC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA16SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA16SCB"
    VALUE
    0x80802DEE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA16SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA16SCG"
    VALUE
    0x80802DF0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA17OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA17OL"
    VALUE
    0x80802DF2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA17OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA17OR"
    VALUE
    0x80802DF4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA17OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA17OT"
    VALUE
    0x80802DF6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA17SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA17SCB"
    VALUE
    0x80802DF8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA17SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA17SCG"
    VALUE
    0x80802DFA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA18OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA18OL"
    VALUE
    0x80802DFC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA18OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA18OT"
    VALUE
    0x80802DFE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA18SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA18SCB"
    VALUE
    0x80802E00
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA18SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA18SCG"
    VALUE
    0x80802E02
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA19OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA19OL"
    VALUE
    0x80802E04
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA19OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA19OR"
    VALUE
    0x80802E06
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA19OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA19OT"
    VALUE
    0x80802E08
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA19SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA19SCB"
    VALUE
    0x80802E0A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA19SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA19SCG"
    VALUE
    0x80802E0C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA20OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA20OL"
    VALUE
    0x80802E0E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA20OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA20OR"
    VALUE
    0x80802E10
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA20OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA20OT"
    VALUE
    0x80802E12
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA20SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA20SCB"
    VALUE
    0x80802E14
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA20SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA20SCG"
    VALUE
    0x80802E16
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA31OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA31OL"
    VALUE
    0x80802E18
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA31OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA31OR"
    VALUE
    0x80802E1A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA31OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA31OT"
    VALUE
    0x80802E1C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA31SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA31SCB"
    VALUE
    0x80802E1E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA31SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA31SCG"
    VALUE
    0x80802E20
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA32OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA32OL"
    VALUE
    0x80802E22
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA32OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA32OR"
    VALUE
    0x80802E24
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA32OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA32OT"
    VALUE
    0x80802E26
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA32SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA32SCB"
    VALUE
    0x80802E28
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA32SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA32SCG"
    VALUE
    0x80802E2A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA33OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA33OL"
    VALUE
    0x80802E2C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA33OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA33OR"
    VALUE
    0x80802E2E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA33OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA33OT"
    VALUE
    0x80802E30
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA33SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA33SCB"
    VALUE
    0x80802E32
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA33SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA33SCG"
    VALUE
    0x80802E34
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA34OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA34OL"
    VALUE
    0x80802E36
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA34OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA34OR"
    VALUE
    0x80802E38
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA34OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA34OT"
    VALUE
    0x80802E3A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA34SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA34SCB"
    VALUE
    0x80802E3C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA34SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA34SCG"
    VALUE
    0x80802E3E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA35OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA35OL"
    VALUE
    0x80802E40
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA35OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA35OR"
    VALUE
    0x80802E42
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA35OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA35OT"
    VALUE
    0x80802E44
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA35SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA35SCB"
    VALUE
    0x80802E46
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA35SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA35SCG"
    VALUE
    0x80802E48
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA46OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA46OL"
    VALUE
    0x80802E4A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA46OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA46OR"
    VALUE
    0x80802E4C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA46OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA46OT"
    VALUE
    0x80802E4E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA46SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA46SCB"
    VALUE
    0x80802E50
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA46SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA46SCG"
    VALUE
    0x80802E52
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA47OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA47OL"
    VALUE
    0x80802E54
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA47OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA47OR"
    VALUE
    0x80802E56
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA47OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA47OT"
    VALUE
    0x80802E58
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA47SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA47SCB"
    VALUE
    0x80802E5A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA47SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA47SCG"
    VALUE
    0x80802E5C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA48OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA48OL"
    VALUE
    0x80802E5E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA48OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA48OR"
    VALUE
    0x80802E60
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA48OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA48OT"
    VALUE
    0x80802E62
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA48SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA48SCB"
    VALUE
    0x80802E64
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA48SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA48SCG"
    VALUE
    0x80802E66
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA49OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA49OL"
    VALUE
    0x80802E68
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA49OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA49OT"
    VALUE
    0x80802E6A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA49SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA49SCB"
    VALUE
    0x80802E6C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA49SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA49SCG"
    VALUE
    0x80802E6E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA50OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA50OL"
    VALUE
    0x80802E70
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA50OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA50OT"
    VALUE
    0x80802E72
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA50SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA50SCB"
    VALUE
    0x80802E74
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA50SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA50SCG"
    VALUE
    0x80802E76
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA51OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA51OL"
    VALUE
    0x80802E78
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA51OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA51OR"
    VALUE
    0x80802E7A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA51OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA51OT"
    VALUE
    0x80802E7C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA51SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA51SCB"
    VALUE
    0x80802E7E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA51SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA51SCG"
    VALUE
    0x80802E80
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA52OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA52OL"
    VALUE
    0x80802E82
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA52OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA52OR"
    VALUE
    0x80802E84
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA52OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA52OT"
    VALUE
    0x80802E86
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA52SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA52SCB"
    VALUE
    0x80802E88
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA52SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA52SCG"
    VALUE
    0x80802E8A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA53OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA53OL"
    VALUE
    0x80802E8C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA53OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA53OR"
    VALUE
    0x80802E8E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA53OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA53OT"
    VALUE
    0x80802E90
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA53SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA53SCB"
    VALUE
    0x80802E92
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA53SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA53SCG"
    VALUE
    0x80802E94
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA54OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA54OL"
    VALUE
    0x80802E96
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA54OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA54OR"
    VALUE
    0x80802E98
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA54OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA54OT"
    VALUE
    0x80802E9A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA54SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA54SCB"
    VALUE
    0x80802E9C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA54SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA54SCG"
    VALUE
    0x80802E9E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA55OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA55OL"
    VALUE
    0x80802EA0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA55OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA55OT"
    VALUE
    0x80802EA2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA55SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA55SCB"
    VALUE
    0x80802EA4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA55SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA55SCG"
    VALUE
    0x80802EA6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA56OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA56OL"
    VALUE
    0x80802EA8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA56OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA56OT"
    VALUE
    0x80802EAA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA56SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA56SCB"
    VALUE
    0x80802EAC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA56SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA56SCG"
    VALUE
    0x80802EAE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA58OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA58OL"
    VALUE
    0x80802EB0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA58OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA58OT"
    VALUE
    0x80802EB2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA58SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA58SCB"
    VALUE
    0x80802EB4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA58SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA58SCG"
    VALUE
    0x80802EB6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK07OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK07OL"
    VALUE
    0x80802EB8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK07OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK07OR"
    VALUE
    0x80802EBA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK07OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK07OT"
    VALUE
    0x80802EBC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK07SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK07SCB"
    VALUE
    0x80802EBE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK07SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK07SCG"
    VALUE
    0x80802EC0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK08OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK08OL"
    VALUE
    0x80802EC2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK08OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK08OR"
    VALUE
    0x80802EC4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK08OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK08OT"
    VALUE
    0x80802EC6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK08SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK08SCB"
    VALUE
    0x80802EC8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK08SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK08SCG"
    VALUE
    0x80802ECA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK09OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK09OL"
    VALUE
    0x80802ECC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK09OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK09OR"
    VALUE
    0x80802ECE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK09OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK09OT"
    VALUE
    0x80802ED0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK09SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK09SCB"
    VALUE
    0x80802ED2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK09SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK09SCG"
    VALUE
    0x80802ED4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK12OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK12OL"
    VALUE
    0x80802ED6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK12OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK12OT"
    VALUE
    0x80802ED8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK12SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK12SCB"
    VALUE
    0x80802EDA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK12SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK12SCG"
    VALUE
    0x80802EDC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK13OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK13OL"
    VALUE
    0x80802EDE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK13OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK13OT"
    VALUE
    0x80802EE0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK13SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK13SCB"
    VALUE
    0x80802EE2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK13SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK13SCG"
    VALUE
    0x80802EE4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK14OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK14OL"
    VALUE
    0x80802EE6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK14OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK14OR"
    VALUE
    0x80802EE8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK14OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK14OT"
    VALUE
    0x80802EEA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK14SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK14SCB"
    VALUE
    0x80802EEC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK14SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK14SCG"
    VALUE
    0x80802EEE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK15OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK15OL"
    VALUE
    0x80802EF0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK15OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK15OR"
    VALUE
    0x80802EF2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK15OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK15OT"
    VALUE
    0x80802EF4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK15SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK15SCB"
    VALUE
    0x80802EF6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK15SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK15SCG"
    VALUE
    0x80802EF8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK16OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK16OL"
    VALUE
    0x80802EFA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK16OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK16OR"
    VALUE
    0x80802EFC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK16OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK16OT"
    VALUE
    0x80802EFE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK16SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK16SCB"
    VALUE
    0x80802F00
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK16SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK16SCG"
    VALUE
    0x80802F02
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK17OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK17OL"
    VALUE
    0x80802F04
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK17OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK17OR"
    VALUE
    0x80802F06
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK17OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK17OT"
    VALUE
    0x80802F08
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK17SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK17SCB"
    VALUE
    0x80802F0A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK17SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK17SCG"
    VALUE
    0x80802F0C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK25OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK25OR"
    VALUE
    0x80802F0E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK25SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK25SCB"
    VALUE
    0x80802F10
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK25SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK25SCG"
    VALUE
    0x80802F12
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK29OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK29OL"
    VALUE
    0x80802F14
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK29OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK29OR"
    VALUE
    0x80802F16
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK29OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK29OT"
    VALUE
    0x80802F18
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK29SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK29SCB"
    VALUE
    0x80802F1A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK29SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK29SCG"
    VALUE
    0x80802F1C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK51OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK51OL"
    VALUE
    0x80802F1E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK51OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK51OT"
    VALUE
    0x80802F20
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK51SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK51SCB"
    VALUE
    0x80802F22
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK51SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK51SCG"
    VALUE
    0x80802F24
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK62OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK62OR"
    VALUE
    0x80802F26
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK62SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK62SCB"
    VALUE
    0x80802F28
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK62SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK62SCG"
    VALUE
    0x80802F2A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK73OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK73OL"
    VALUE
    0x80802F2C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK73OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK73OR"
    VALUE
    0x80802F2E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK73OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK73OT"
    VALUE
    0x80802F30
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK73SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK73SCB"
    VALUE
    0x80802F32
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK73SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK73SCG"
    VALUE
    0x80802F34
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK80OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK80OL"
    VALUE
    0x80802F36
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK80OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK80OT"
    VALUE
    0x80802F38
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK80SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK80SCB"
    VALUE
    0x80802F3A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK80SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK80SCG"
    VALUE
    0x80802F3C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK81OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK81OL"
    VALUE
    0x80802F3E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK81OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK81OT"
    VALUE
    0x80802F40
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK81SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK81SCB"
    VALUE
    0x80802F42
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK81SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK81SCG"
    VALUE
    0x80802F44
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK82OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK82OL"
    VALUE
    0x80802F46
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK82OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK82OT"
    VALUE
    0x80802F48
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK82SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK82SCB"
    VALUE
    0x80802F4A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK82SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK82SCG"
    VALUE
    0x80802F4C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK83OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK83OL"
    VALUE
    0x80802F4E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK83OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK83OT"
    VALUE
    0x80802F50
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK83SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK83SCB"
    VALUE
    0x80802F52
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK83SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK83SCG"
    VALUE
    0x80802F54
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK84OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK84OL"
    VALUE
    0x80802F56
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK84OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK84OT"
    VALUE
    0x80802F58
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK84SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK84SCB"
    VALUE
    0x80802F5A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK84SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK84SCG"
    VALUE
    0x80802F5C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK85OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK85OL"
    VALUE
    0x80802F5E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK85OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK85OT"
    VALUE
    0x80802F60
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK85SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK85SCB"
    VALUE
    0x80802F62
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK85SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK85SCG"
    VALUE
    0x80802F64
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK86OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK86OL"
    VALUE
    0x80802F66
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK86OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK86OT"
    VALUE
    0x80802F68
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK86SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK86SCB"
    VALUE
    0x80802F6A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK86SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK86SCG"
    VALUE
    0x80802F6C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK87OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK87OL"
    VALUE
    0x80802F6E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK87OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK87OT"
    VALUE
    0x80802F70
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK87SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK87SCB"
    VALUE
    0x80802F72
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK87SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK87SCG"
    VALUE
    0x80802F74
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_EventUpDownDebFault_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_EventUpDownDebFault"
    VALUE
    0x80802F76
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_DSMDummy_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_DSMDummy"
    VALUE
    0x80802F78
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canGetDataNoBuf_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canGetDataNoBuf"
    VALUE
    0x80802F7A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canGetDataParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canGetDataParam"
    VALUE
    0x80802F7C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canGetDataboxNoInit_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canGetDataboxNoInit"
    VALUE
    0x80802F7E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canGetDataboxParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canGetDataboxParam"
    VALUE
    0x80802F80
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canGetRxBufStatusParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canGetRxBufStatusParam"
    VALUE
    0x80802F82
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canGetStatusParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canGetStatusParam"
    VALUE
    0x80802F84
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canGetTxBufStatusParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canGetTxBufStatusParam"
    VALUE
    0x80802F86
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canInitParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canInitParam"
    VALUE
    0x80802F88
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canInitRxDataboxOverlap_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canInitRxDataboxOverlap"
    VALUE
    0x80802F8A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canInitRxDataboxParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canInitRxDataboxParam"
    VALUE
    0x80802F8C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canInitTxDataboxParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canInitTxDataboxParam"
    VALUE
    0x80802F8E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canIpduGroupControl_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canIpduGroupControl"
    VALUE
    0x80802F90
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canIsDataboxFreeNoInit_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canIsDataboxFreeNoInit"
    VALUE
    0x80802F92
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canIsDataboxFreeParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canIsDataboxFreeParam"
    VALUE
    0x80802F94
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canIsTxEmptyParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canIsTxEmptyParam"
    VALUE
    0x80802F96
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canRegBusOffCallbInvState_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canRegBusOffCallbInvState"
    VALUE
    0x80802F98
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canRegBusOffCallbParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canRegBusOffCallbParam"
    VALUE
    0x80802F9A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canRegRxBufInvState_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canRegRxBufInvState"
    VALUE
    0x80802F9C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canRegRxBufOverlap_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canRegRxBufOverlap"
    VALUE
    0x80802F9E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canRegRxBufParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canRegRxBufParam"
    VALUE
    0x80802FA0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canRegRxCallbInvState_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canRegRxCallbInvState"
    VALUE
    0x80802FA2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canRegRxCallbParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canRegRxCallbParam"
    VALUE
    0x80802FA4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canRegRxDataboxInvNumb_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canRegRxDataboxInvNumb"
    VALUE
    0x80802FA6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canRegRxDataboxInvState_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canRegRxDataboxInvState"
    VALUE
    0x80802FA8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canRegRxDataboxOverlap_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canRegRxDataboxOverlap"
    VALUE
    0x80802FAA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canRegRxDataboxParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canRegRxDataboxParam"
    VALUE
    0x80802FAC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canRegTxBufInvState_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canRegTxBufInvState"
    VALUE
    0x80802FAE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canRegTxBufOverlap_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canRegTxBufOverlap"
    VALUE
    0x80802FB0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canRegTxBufParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canRegTxBufParam"
    VALUE
    0x80802FB2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canRegTxDataboxInvNumb_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canRegTxDataboxInvNumb"
    VALUE
    0x80802FB4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canRegTxDataboxInvState_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canRegTxDataboxInvState"
    VALUE
    0x80802FB6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canRegTxDataboxOverlap_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canRegTxDataboxOverlap"
    VALUE
    0x80802FB8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canRegTxDataboxParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canRegTxDataboxParam"
    VALUE
    0x80802FBA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canResetTxBufParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canResetTxBufParam"
    VALUE
    0x80802FBC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canSendDataBufOvfl_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canSendDataBufOvfl"
    VALUE
    0x80802FBE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canSendDataParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canSendDataParam"
    VALUE
    0x80802FC0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canSendDataboxNoInit_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canSendDataboxNoInit"
    VALUE
    0x80802FC2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canSendDataboxParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canSendDataboxParam"
    VALUE
    0x80802FC4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canSetTxCycleParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canSetTxCycleParam"
    VALUE
    0x80802FC6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canStartParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canStartParam"
    VALUE
    0x80802FC8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canStopParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canStopParam"
    VALUE
    0x80802FCA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_can_ClearIpduGroup_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_can_ClearIpduGroup"
    VALUE
    0x80802FCC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_can_ReceiveSignal_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_can_ReceiveSignal"
    VALUE
    0x80802FCE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_can_SendSignal_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_can_SendSignal"
    VALUE
    0x80802FD0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_can_SetIpduGroup_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_can_SetIpduGroup"
    VALUE
    0x80802FD2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_dsmDTCJ1939_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_dsmDTCJ1939"
    VALUE
    0x80802FD4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_dsmDelDTCJ1939_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_dsmDelDTCJ1939"
    VALUE
    0x80802FD6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_dsmDelErrors_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_dsmDelErrors"
    VALUE
    0x80802FD8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_dsmGetDFES_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_dsmGetDFES"
    VALUE
    0x80802FDA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_dsmGetDTCJ1939_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_dsmGetDTCJ1939"
    VALUE
    0x80802FDC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_dsmGetErrors_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_dsmGetErrors"
    VALUE
    0x80802FDE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_dsmGetNumErrors_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_dsmGetNumErrors"
    VALUE
    0x80802FE0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_dsmInitQueueOverflow_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_dsmInitQueueOverflow"
    VALUE
    0x80802FE2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_dsmNumDTCJ1939_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_dsmNumDTCJ1939"
    VALUE
    0x80802FE4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_dsmTesterror_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_dsmTesterror"
    VALUE
    0x80802FE6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_dsmUpdateDebError_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_dsmUpdateDebError"
    VALUE
    0x80802FE8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_dsmUpdateError_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_dsmUpdateError"
    VALUE
    0x80802FEA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_dsmgetDFCStatus_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_dsmgetDFCStatus"
    VALUE
    0x80802FEC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_dsmtestErrorDFC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_dsmtestErrorDFC"
    VALUE
    0x80802FEE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inAi_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inAi"
    VALUE
    0x80802FF0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inAic_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inAic"
    VALUE
    0x80802FF2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inAicCfg_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inAicCfg"
    VALUE
    0x80802FF4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inAicGetStatus_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inAicGetStatus"
    VALUE
    0x80802FF6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inAid_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inAid"
    VALUE
    0x80802FF8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inAidCfg_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inAidCfg"
    VALUE
    0x80802FFA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inAiv_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inAiv"
    VALUE
    0x80802FFC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inAivCfg_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inAivCfg"
    VALUE
    0x80802FFE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inAivGetStatus_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inAivGetStatus"
    VALUE
    0x80803000
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inDi_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inDi"
    VALUE
    0x80803002
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inFi_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inFi"
    VALUE
    0x80803004
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inFiCfg_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inFiCfg"
    VALUE
    0x80803006
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inFiGetStatus_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inFiGetStatus"
    VALUE
    0x80803008
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inFi_Buffered_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inFi_Buffered"
    VALUE
    0x8080300A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inPhase_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inPhase"
    VALUE
    0x8080300C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inPhaseGetStatus_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inPhaseGetStatus"
    VALUE
    0x8080300E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inPhaseResetCounter_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inPhaseResetCounter"
    VALUE
    0x80803010
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inRi_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inRi"
    VALUE
    0x80803012
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inRiCfg_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inRiCfg"
    VALUE
    0x80803014
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inRiCfgTemp_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inRiCfgTemp"
    VALUE
    0x80803016
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inRiGetStatus_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inRiGetStatus"
    VALUE
    0x80803018
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inRiGetTemp_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inRiGetTemp"
    VALUE
    0x8080301A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inSentCopyFDFifo_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inSentCopyFDFifo"
    VALUE
    0x8080301C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inSentDisable_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inSentDisable"
    VALUE
    0x8080301E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inSentEnable_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inSentEnable"
    VALUE
    0x80803020
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inSentGetErrorStatus_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inSentGetErrorStatus"
    VALUE
    0x80803022
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inSentGetFD_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inSentGetFD"
    VALUE
    0x80803024
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inSentGetSD_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inSentGetSD"
    VALUE
    0x80803026
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inSentGetSDDatabox_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inSentGetSDDatabox"
    VALUE
    0x80803028
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inSentGetStatus_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inSentGetStatus"
    VALUE
    0x8080302A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inSentInitSDDatabox_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inSentInitSDDatabox"
    VALUE
    0x8080302C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inSentRegisterCopyFDFifo_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inSentRegisterCopyFDFifo"
    VALUE
    0x8080302E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inSentRegisterFDFifo_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inSentRegisterFDFifo"
    VALUE
    0x80803030
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inSentRegisterSDDataboxes_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inSentRegisterSDDataboxes"
    VALUE
    0x80803032
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_isobusCanRxBufferOverflow_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_isobusCanRxBufferOverflow"
    VALUE
    0x80803034
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_isobusGetCaAddrParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_isobusGetCaAddrParam"
    VALUE
    0x80803036
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_isobusGetDiagnosticParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_isobusGetDiagnosticParam"
    VALUE
    0x80803038
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_isobusGetRxDataboxStatusParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_isobusGetRxDataboxStatusParam"
    VALUE
    0x8080303A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_isobusGetStatusParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_isobusGetStatusParam"
    VALUE
    0x8080303C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_isobusInitCommCaMissing_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_isobusInitCommCaMissing"
    VALUE
    0x8080303E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_isobusInitCommParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_isobusInitCommParam"
    VALUE
    0x80803040
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_isobusInitCommState_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_isobusInitCommState"
    VALUE
    0x80803042
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_isobusInitDiagnosticParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_isobusInitDiagnosticParam"
    VALUE
    0x80803044
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_isobusInitFailureListParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_isobusInitFailureListParam"
    VALUE
    0x80803046
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_isobusInitRxDataboxParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_isobusInitRxDataboxParam"
    VALUE
    0x80803048
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_isobusInitTxDataboxParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_isobusInitTxDataboxParam"
    VALUE
    0x8080304A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_isobusRegRxDataboxOverlap_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_isobusRegRxDataboxOverlap"
    VALUE
    0x8080304C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_isobusRegRxDataboxParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_isobusRegRxDataboxParam"
    VALUE
    0x8080304E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_isobusRegRxDataboxState_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_isobusRegRxDataboxState"
    VALUE
    0x80803050
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_isobusRegTxDataboxOverlap_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_isobusRegTxDataboxOverlap"
    VALUE
    0x80803052
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_isobusRegTxDataboxParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_isobusRegTxDataboxParam"
    VALUE
    0x80803054
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_isobusRegTxDataboxState_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_isobusRegTxDataboxState"
    VALUE
    0x80803056
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_isobusRegisterErrClrCallbackParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_isobusRegisterErrClrCallbackParam"
    VALUE
    0x80803058
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_isobusRegisterInstancesOverlap_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_isobusRegisterInstancesOverlap"
    VALUE
    0x8080305A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_isobusRegisterInstancesParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_isobusRegisterInstancesParam"
    VALUE
    0x8080305C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_isobusRegisterInstancesState_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_isobusRegisterInstancesState"
    VALUE
    0x8080305E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_isobusSendDataboxParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_isobusSendDataboxParam"
    VALUE
    0x80803060
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_isobusSendRequestPGNParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_isobusSendRequestPGNParam"
    VALUE
    0x80803062
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_isobusSetCaAddrCaUsed_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_isobusSetCaAddrCaUsed"
    VALUE
    0x80803064
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_isobusSetCaAddrComm_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_isobusSetCaAddrComm"
    VALUE
    0x80803066
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_isobusSetCaAddrInvCan_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_isobusSetCaAddrInvCan"
    VALUE
    0x80803068
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_isobusSetCaAddrParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_isobusSetCaAddrParam"
    VALUE
    0x8080306A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_isobusSetCaInfoParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_isobusSetCaInfoParam"
    VALUE
    0x8080306C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_isobusSetCaNameParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_isobusSetCaNameParam"
    VALUE
    0x8080306E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_isobusSftyCanTxErr_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_isobusSftyCanTxErr"
    VALUE
    0x80803070
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_lin_ReceiveSignal_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_lin_ReceiveSignal"
    VALUE
    0x80803072
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_lin_SendSignal_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_lin_SendSignal"
    VALUE
    0x80803074
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_lin_getStatus_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_lin_getStatus"
    VALUE
    0x80803076
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_lin_gotoSleep_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_lin_gotoSleep"
    VALUE
    0x80803078
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_lin_scheduleRequest_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_lin_scheduleRequest"
    VALUE
    0x8080307A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_lin_wakeUp_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_lin_wakeUp"
    VALUE
    0x8080307C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_memFlsCfgShr_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_memFlsCfgShr"
    VALUE
    0x8080307E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_memGetStatus_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_memGetStatus"
    VALUE
    0x80803080
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_memMarkBlock_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_memMarkBlock"
    VALUE
    0x80803082
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_memReadApi1Error_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_memReadApi1Error"
    VALUE
    0x80803084
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_memReadApi2Error_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_memReadApi2Error"
    VALUE
    0x80803086
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_memReadBlock_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_memReadBlock"
    VALUE
    0x80803088
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_memReadCalibInputError_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_memReadCalibInputError"
    VALUE
    0x8080308A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_memReadCalibOuputError_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_memReadCalibOuputError"
    VALUE
    0x8080308C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_memReadSystemError_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_memReadSystemError"
    VALUE
    0x8080308E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_memWriteBlock_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_memWriteBlock"
    VALUE
    0x80803090
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_moOV_FirstConstADC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_moOV_FirstConstADC"
    VALUE
    0x80803092
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_moOV_SecondConstADC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_moOV_SecondConstADC"
    VALUE
    0x80803094
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_moUV_FirstConstADC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_moUV_FirstConstADC"
    VALUE
    0x80803096
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_moUV_SecondConstADC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_moUV_SecondConstADC"
    VALUE
    0x80803098
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_INH_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_INH"
    VALUE
    0x8080309A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_INHLatch_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_INHLatch"
    VALUE
    0x8080309C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_adcPDD_fail_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_adcPDD_fail"
    VALUE
    0x8080309E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_memoryProtection_err_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_memoryProtection_err"
    VALUE
    0x808030A0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA02OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA02OC"
    VALUE
    0x808030A2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA02Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA02Unintended"
    VALUE
    0x808030A4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA03OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA03OC"
    VALUE
    0x808030A6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA03Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA03Unintended"
    VALUE
    0x808030A8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA04OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA04OC"
    VALUE
    0x808030AA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA04Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA04Unintended"
    VALUE
    0x808030AC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA05OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA05OC"
    VALUE
    0x808030AE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA05Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA05Unintended"
    VALUE
    0x808030B0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA07OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA07OC"
    VALUE
    0x808030B2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA07Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA07Unintended"
    VALUE
    0x808030B4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA08OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA08OC"
    VALUE
    0x808030B6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA08Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA08Unintended"
    VALUE
    0x808030B8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA09OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA09OC"
    VALUE
    0x808030BA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA09Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA09Unintended"
    VALUE
    0x808030BC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA10OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA10OC"
    VALUE
    0x808030BE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA10Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA10Unintended"
    VALUE
    0x808030C0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA17OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA17OC"
    VALUE
    0x808030C2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA17Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA17Unintended"
    VALUE
    0x808030C4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA18OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA18OC"
    VALUE
    0x808030C6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA18Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA18Unintended"
    VALUE
    0x808030C8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA19OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA19OC"
    VALUE
    0x808030CA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA19Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA19Unintended"
    VALUE
    0x808030CC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA20OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA20OC"
    VALUE
    0x808030CE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA20Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA20Unintended"
    VALUE
    0x808030D0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA31OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA31OC"
    VALUE
    0x808030D2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA31Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA31Unintended"
    VALUE
    0x808030D4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA32OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA32OC"
    VALUE
    0x808030D6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA32Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA32Unintended"
    VALUE
    0x808030D8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA33OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA33OC"
    VALUE
    0x808030DA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA33Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA33Unintended"
    VALUE
    0x808030DC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA34OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA34OC"
    VALUE
    0x808030DE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA34Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA34Unintended"
    VALUE
    0x808030E0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA35OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA35OC"
    VALUE
    0x808030E2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA35Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA35Unintended"
    VALUE
    0x808030E4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA46OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA46OC"
    VALUE
    0x808030E6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA46Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA46Unintended"
    VALUE
    0x808030E8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA47OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA47OC"
    VALUE
    0x808030EA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA47Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA47Unintended"
    VALUE
    0x808030EC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA48OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA48OC"
    VALUE
    0x808030EE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA48Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA48Unintended"
    VALUE
    0x808030F0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA51OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA51OC"
    VALUE
    0x808030F2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA51Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA51Unintended"
    VALUE
    0x808030F4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA52OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA52OC"
    VALUE
    0x808030F6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA52Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA52Unintended"
    VALUE
    0x808030F8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA53OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA53OC"
    VALUE
    0x808030FA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA53Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA53Unintended"
    VALUE
    0x808030FC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA54OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA54OC"
    VALUE
    0x808030FE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA54Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA54Unintended"
    VALUE
    0x80803100
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outAov_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outAov"
    VALUE
    0x80803102
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outAovCfg_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outAovCfg"
    VALUE
    0x80803104
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outAovCfgPI_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outAovCfgPI"
    VALUE
    0x80803106
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outAovGetStatus_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outAovGetStatus"
    VALUE
    0x80803108
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outAovGetVoltage_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outAovGetVoltage"
    VALUE
    0x8080310A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outAovResetError_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outAovResetError"
    VALUE
    0x8080310C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outDo_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outDo"
    VALUE
    0x8080310E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outDoCfgPwrLs_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outDoCfgPwrLs"
    VALUE
    0x80803110
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outDoDisable_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outDoDisable"
    VALUE
    0x80803112
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outDoGetCurrent_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outDoGetCurrent"
    VALUE
    0x80803114
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outDoGetStatus_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outDoGetStatus"
    VALUE
    0x80803116
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outDoResetError_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outDoResetError"
    VALUE
    0x80803118
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK07OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK07OC"
    VALUE
    0x8080311A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK07Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK07Unintended"
    VALUE
    0x8080311C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK08OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK08OC"
    VALUE
    0x8080311E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK08Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK08Unintended"
    VALUE
    0x80803120
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK09OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK09OC"
    VALUE
    0x80803122
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK09Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK09Unintended"
    VALUE
    0x80803124
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK12OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK12OC"
    VALUE
    0x80803126
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK12Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK12Unintended"
    VALUE
    0x80803128
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK13OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK13OC"
    VALUE
    0x8080312A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK13Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK13Unintended"
    VALUE
    0x8080312C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK14OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK14OC"
    VALUE
    0x8080312E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK14Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK14Unintended"
    VALUE
    0x80803130
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK15OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK15OC"
    VALUE
    0x80803132
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK15Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK15Unintended"
    VALUE
    0x80803134
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK16OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK16OC"
    VALUE
    0x80803136
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK16Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK16Unintended"
    VALUE
    0x80803138
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK17OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK17OC"
    VALUE
    0x8080313A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK17Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK17Unintended"
    VALUE
    0x8080313C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK29OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK29OC"
    VALUE
    0x8080313E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK29Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK29Unintended"
    VALUE
    0x80803140
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK51OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK51OC"
    VALUE
    0x80803142
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK51Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK51Unintended"
    VALUE
    0x80803144
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK73OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK73OC"
    VALUE
    0x80803146
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK73Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK73Unintended"
    VALUE
    0x80803148
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outPo_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outPo"
    VALUE
    0x8080314A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outPoCfg_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outPoCfg"
    VALUE
    0x8080314C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outPoCfgPeriod_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outPoCfgPeriod"
    VALUE
    0x8080314E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outPoCfgPwrLs_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outPoCfgPwrLs"
    VALUE
    0x80803150
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outPoDisable_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outPoDisable"
    VALUE
    0x80803152
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outPoGetCurrent_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outPoGetCurrent"
    VALUE
    0x80803154
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outPoGetStatus_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outPoGetStatus"
    VALUE
    0x80803156
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outPoResetError_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outPoResetError"
    VALUE
    0x80803158
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outPoc_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outPoc"
    VALUE
    0x8080315A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outPocCfg_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outPocCfg"
    VALUE
    0x8080315C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outPocCfgDither_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outPocCfgDither"
    VALUE
    0x8080315E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outPocCfgPI_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outPocCfgPI"
    VALUE
    0x80803160
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outPod_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outPod"
    VALUE
    0x80803162
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outPodCfg_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outPodCfg"
    VALUE
    0x80803164
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outPodCfgPeriod_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outPodCfgPeriod"
    VALUE
    0x80803166
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_rsmFfiApiCallErr_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_rsmFfiApiCallErr"
    VALUE
    0x80803168
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safout_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safout"
    VALUE
    0x8080316A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutCfg_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutCfg"
    VALUE
    0x8080316C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl1_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl1"
    VALUE
    0x8080316E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl10_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl10"
    VALUE
    0x80803170
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl10Dev_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl10Dev"
    VALUE
    0x80803172
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl10OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl10OR"
    VALUE
    0x80803174
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl11_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl11"
    VALUE
    0x80803176
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl11Dev_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl11Dev"
    VALUE
    0x80803178
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl11OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl11OR"
    VALUE
    0x8080317A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl12_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl12"
    VALUE
    0x8080317C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl12Dev_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl12Dev"
    VALUE
    0x8080317E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl12OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl12OR"
    VALUE
    0x80803180
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl13_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl13"
    VALUE
    0x80803182
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl13Dev_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl13Dev"
    VALUE
    0x80803184
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl13OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl13OR"
    VALUE
    0x80803186
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl14_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl14"
    VALUE
    0x80803188
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl14Dev_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl14Dev"
    VALUE
    0x8080318A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl14OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl14OR"
    VALUE
    0x8080318C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl15_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl15"
    VALUE
    0x8080318E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl15Dev_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl15Dev"
    VALUE
    0x80803190
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl15OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl15OR"
    VALUE
    0x80803192
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl16_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl16"
    VALUE
    0x80803194
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl16Dev_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl16Dev"
    VALUE
    0x80803196
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl16OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl16OR"
    VALUE
    0x80803198
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl17_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl17"
    VALUE
    0x8080319A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl17Dev_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl17Dev"
    VALUE
    0x8080319C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl17OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl17OR"
    VALUE
    0x8080319E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl18_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl18"
    VALUE
    0x808031A0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl18Dev_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl18Dev"
    VALUE
    0x808031A2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl18OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl18OR"
    VALUE
    0x808031A4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl1Dev_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl1Dev"
    VALUE
    0x808031A6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl1OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl1OR"
    VALUE
    0x808031A8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl2_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl2"
    VALUE
    0x808031AA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl2Dev_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl2Dev"
    VALUE
    0x808031AC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl2OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl2OR"
    VALUE
    0x808031AE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl3_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl3"
    VALUE
    0x808031B0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl3Dev_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl3Dev"
    VALUE
    0x808031B2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl3OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl3OR"
    VALUE
    0x808031B4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl4_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl4"
    VALUE
    0x808031B6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl4Dev_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl4Dev"
    VALUE
    0x808031B8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl4OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl4OR"
    VALUE
    0x808031BA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl5_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl5"
    VALUE
    0x808031BC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl5Dev_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl5Dev"
    VALUE
    0x808031BE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl5OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl5OR"
    VALUE
    0x808031C0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl6_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl6"
    VALUE
    0x808031C2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl6Dev_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl6Dev"
    VALUE
    0x808031C4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl6OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl6OR"
    VALUE
    0x808031C6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl7_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl7"
    VALUE
    0x808031C8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl7Dev_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl7Dev"
    VALUE
    0x808031CA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl7OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl7OR"
    VALUE
    0x808031CC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl8_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl8"
    VALUE
    0x808031CE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl8Dev_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl8Dev"
    VALUE
    0x808031D0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl8OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl8OR"
    VALUE
    0x808031D2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl9_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl9"
    VALUE
    0x808031D4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl9Dev_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl9Dev"
    VALUE
    0x808031D6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl9OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl9OR"
    VALUE
    0x808031D8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutDevError_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutDevError"
    VALUE
    0x808031DA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutGetStatus_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutGetStatus"
    VALUE
    0x808031DC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutIgnoreError_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutIgnoreError"
    VALUE
    0x808031DE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutResetError_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutResetError"
    VALUE
    0x808031E0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutUnlock_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutUnlock"
    VALUE
    0x808031E2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safout_cfgDiag_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safout_cfgDiag"
    VALUE
    0x808031E4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_secAccessDenied_RC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_secAccessDenied_RC"
    VALUE
    0x808031E6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_secAccessDenied_WDBI_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_secAccessDenied_WDBI"
    VALUE
    0x808031E8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_secEvalRespKey_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_secEvalRespKey"
    VALUE
    0x808031EA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_secFlashingFailure_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_secFlashingFailure"
    VALUE
    0x808031EC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_secGetLevel_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_secGetLevel"
    VALUE
    0x808031EE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_secGetRnd_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_secGetRnd"
    VALUE
    0x808031F0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_secGetSeed_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_secGetSeed"
    VALUE
    0x808031F2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_secInvalidPassword_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_secInvalidPassword"
    VALUE
    0x808031F4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_secIsRequestAllowed_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_secIsRequestAllowed"
    VALUE
    0x808031F6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_secResetLevel_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_secResetLevel"
    VALUE
    0x808031F8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_secSaveSecret_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_secSaveSecret"
    VALUE
    0x808031FA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_secSetLevel_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_secSetLevel"
    VALUE
    0x808031FC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_sysAit_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_sysAit"
    VALUE
    0x808031FE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_sysAiv_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_sysAiv"
    VALUE
    0x80803200
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_sysDi_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_sysDi"
    VALUE
    0x80803202
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_sysDo_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_sysDo"
    VALUE
    0x80803204
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_sysGetVss_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_sysGetVss"
    VALUE
    0x80803206
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_sysInit_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_sysInit"
    VALUE
    0x80803208
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_sysOperHrIntegrityErr_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_sysOperHrIntegrityErr"
    VALUE
    0x8080320A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_sysOperHrsSaturated_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_sysOperHrsSaturated"
    VALUE
    0x8080320C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_sysSetVss_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_sysSetVss"
    VALUE
    0x8080320E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_sys_coreload_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_sys_coreload"
    VALUE
    0x80803210
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_sys_taskload_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_sys_taskload"
    VALUE
    0x80803212
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_OV_VSS1_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_OV_VSS1"
    VALUE
    0x80803214
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_OV_VSS2_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_OV_VSS2"
    VALUE
    0x80803216
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_UV_VSS1_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_UV_VSS1"
    VALUE
    0x80803218
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_UV_VSS2_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_UV_VSS2"
    VALUE
    0x8080321A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_CANSM_E_BUS_OFF_NETWORK_0_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_CANSM_E_BUS_OFF_NETWORK_0"
    VALUE
    0x8080321C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_CANSM_E_BUS_OFF_NETWORK_1_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_CANSM_E_BUS_OFF_NETWORK_1"
    VALUE
    0x8080321E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_CANSM_E_BUS_OFF_NETWORK_2_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_CANSM_E_BUS_OFF_NETWORK_2"
    VALUE
    0x80803220
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_CANSM_E_BUS_OFF_NETWORK_3_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_CANSM_E_BUS_OFF_NETWORK_3"
    VALUE
    0x80803222
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_CANTRCV_E_NO_TRCV_CONTROL_0_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_CANTRCV_E_NO_TRCV_CONTROL_0"
    VALUE
    0x80803224
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_CAN_E_TIMEOUT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_CAN_E_TIMEOUT"
    VALUE
    0x80803226
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_COMM_E_NET_START_IND_CHANNEL_0_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_COMM_E_NET_START_IND_CHANNEL_0"
    VALUE
    0x80803228
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_COMM_E_NET_START_IND_CHANNEL_1_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_COMM_E_NET_START_IND_CHANNEL_1"
    VALUE
    0x8080322A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_COMM_E_NET_START_IND_CHANNEL_2_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_COMM_E_NET_START_IND_CHANNEL_2"
    VALUE
    0x8080322C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_COMM_E_NET_START_IND_CHANNEL_3_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_COMM_E_NET_START_IND_CHANNEL_3"
    VALUE
    0x8080322E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_COMM_E_NET_START_IND_CHANNEL_4_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_COMM_E_NET_START_IND_CHANNEL_4"
    VALUE
    0x80803230
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_COMM_E_NET_START_IND_CHANNEL_5_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_COMM_E_NET_START_IND_CHANNEL_5"
    VALUE
    0x80803232
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_LIN_E_TIMEOUT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_LIN_E_TIMEOUT"
    VALUE
    0x80803234
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rba_MultiStackTrace_Threshold_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rba_MultiStackTrace_Threshold"
    VALUE
    0x80803236
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_ETH_E_ACCESS_0_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_ETH_E_ACCESS_0"
    VALUE
    0x80803238
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_RBA_IOEXTLIB_KEEPALIVE_DRV_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_RBA_IOEXTLIB_KEEPALIVE_DRV"
    VALUE
    0x8080323A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_RBA_IOEXTLIB_KEEPALIVE_INI_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_RBA_IOEXTLIB_KEEPALIVE_INI"
    VALUE
    0x8080323C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rba_MRly_Diag_Stk_Event_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rba_MRly_Diag_Stk_Event"
    VALUE
    0x8080323E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rba_MemDiagExtd_MemReadSngErr_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rba_MemDiagExtd_MemReadSngErr"
    VALUE
    0x80803240
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rba_MemDiag_MemReadErr_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rba_MemDiag_MemReadErr"
    VALUE
    0x80803242
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rba_MemDiag_MemWrErr_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rba_MemDiag_MemWrErr"
    VALUE
    0x80803244
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rba_SyC_IrrSwOffTrigEngRun_Event_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rba_SyC_IrrSwOffTrigEngRun_Event"
    VALUE
    0x80803246
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rba_T15_Diag_ComInVld_Event_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rba_T15_Diag_ComInVld_Event"
    VALUE
    0x80803248
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rba_T15_Diag_ComOff_HwOn_Event_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rba_T15_Diag_ComOff_HwOn_Event"
    VALUE
    0x8080324A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rba_T15_Diag_ComOn_HwOff_Event_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rba_T15_Diag_ComOn_HwOff_Event"
    VALUE
    0x8080324C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM0_0_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_0"
    VALUE
    0x8080324E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM0_1_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_1"
    VALUE
    0x80803250
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM0_10_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_10"
    VALUE
    0x80803252
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM0_11_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_11"
    VALUE
    0x80803254
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM0_13_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_13"
    VALUE
    0x80803256
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM0_14_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_14"
    VALUE
    0x80803258
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM0_2_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_2"
    VALUE
    0x8080325A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM0_22_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_22"
    VALUE
    0x8080325C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM0_23_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_23"
    VALUE
    0x8080325E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM0_4_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_4"
    VALUE
    0x80803260
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM0_5_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_5"
    VALUE
    0x80803262
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM0_7_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_7"
    VALUE
    0x80803264
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM0_8_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_8"
    VALUE
    0x80803266
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM10_16_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM10_16"
    VALUE
    0x80803268
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM10_17_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM10_17"
    VALUE
    0x8080326A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM10_21_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM10_21"
    VALUE
    0x8080326C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM11_0_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_0"
    VALUE
    0x8080326E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM11_1_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_1"
    VALUE
    0x80803270
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM11_2_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_2"
    VALUE
    0x80803272
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM11_3_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_3"
    VALUE
    0x80803274
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM11_4_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_4"
    VALUE
    0x80803276
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM11_5_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_5"
    VALUE
    0x80803278
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM11_8_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_8"
    VALUE
    0x8080327A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM11_9_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_9"
    VALUE
    0x8080327C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM1_0_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_0"
    VALUE
    0x8080327E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM1_1_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_1"
    VALUE
    0x80803280
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM1_10_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_10"
    VALUE
    0x80803282
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM1_11_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_11"
    VALUE
    0x80803284
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM1_13_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_13"
    VALUE
    0x80803286
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM1_14_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_14"
    VALUE
    0x80803288
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM1_2_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_2"
    VALUE
    0x8080328A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM1_22_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_22"
    VALUE
    0x8080328C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM1_23_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_23"
    VALUE
    0x8080328E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM1_4_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_4"
    VALUE
    0x80803290
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM1_5_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_5"
    VALUE
    0x80803292
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM1_7_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_7"
    VALUE
    0x80803294
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM1_8_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_8"
    VALUE
    0x80803296
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM21_0_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM21_0"
    VALUE
    0x80803298
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM21_16_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM21_16"
    VALUE
    0x8080329A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM21_3_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM21_3"
    VALUE
    0x8080329C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM2_1_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_1"
    VALUE
    0x8080329E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM2_10_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_10"
    VALUE
    0x808032A0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM2_11_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_11"
    VALUE
    0x808032A2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM2_13_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_13"
    VALUE
    0x808032A4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM2_14_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_14"
    VALUE
    0x808032A6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM2_2_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_2"
    VALUE
    0x808032A8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM2_22_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_22"
    VALUE
    0x808032AA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM2_23_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_23"
    VALUE
    0x808032AC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM2_4_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_4"
    VALUE
    0x808032AE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM2_5_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_5"
    VALUE
    0x808032B0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM2_7_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_7"
    VALUE
    0x808032B2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM2_8_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_8"
    VALUE
    0x808032B4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM3_1_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_1"
    VALUE
    0x808032B6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM3_10_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_10"
    VALUE
    0x808032B8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM3_11_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_11"
    VALUE
    0x808032BA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM3_13_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_13"
    VALUE
    0x808032BC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM3_14_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_14"
    VALUE
    0x808032BE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM3_2_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_2"
    VALUE
    0x808032C0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM3_22_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_22"
    VALUE
    0x808032C2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM3_23_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_23"
    VALUE
    0x808032C4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM3_4_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_4"
    VALUE
    0x808032C6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM3_5_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_5"
    VALUE
    0x808032C8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM3_7_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_7"
    VALUE
    0x808032CA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM3_8_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_8"
    VALUE
    0x808032CC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM6_0_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_0"
    VALUE
    0x808032CE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM6_11_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_11"
    VALUE
    0x808032D0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM6_12_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_12"
    VALUE
    0x808032D2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM6_14_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_14"
    VALUE
    0x808032D4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM6_15_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_15"
    VALUE
    0x808032D6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM6_17_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_17"
    VALUE
    0x808032D8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM6_18_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_18"
    VALUE
    0x808032DA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM6_2_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_2"
    VALUE
    0x808032DC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM6_20_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_20"
    VALUE
    0x808032DE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM6_21_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_21"
    VALUE
    0x808032E0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM6_25_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_25"
    VALUE
    0x808032E2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM6_4_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_4"
    VALUE
    0x808032E4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM6_5_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_5"
    VALUE
    0x808032E6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM6_7_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_7"
    VALUE
    0x808032E8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM6_8_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_8"
    VALUE
    0x808032EA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM7_1_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_1"
    VALUE
    0x808032EC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM7_12_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_12"
    VALUE
    0x808032EE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM7_13_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_13"
    VALUE
    0x808032F0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM7_14_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_14"
    VALUE
    0x808032F2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM7_15_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_15"
    VALUE
    0x808032F4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM7_16_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_16"
    VALUE
    0x808032F6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM7_17_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_17"
    VALUE
    0x808032F8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM7_2_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_2"
    VALUE
    0x808032FA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM7_20_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_20"
    VALUE
    0x808032FC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM7_25_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_25"
    VALUE
    0x808032FE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM7_26_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_26"
    VALUE
    0x80803300
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM7_28_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_28"
    VALUE
    0x80803302
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM7_29_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_29"
    VALUE
    0x80803304
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM7_30_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_30"
    VALUE
    0x80803306
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM7_31_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_31"
    VALUE
    0x80803308
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM8_0_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_0"
    VALUE
    0x8080330A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM8_1_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_1"
    VALUE
    0x8080330C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM8_10_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_10"
    VALUE
    0x8080330E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM8_11_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_11"
    VALUE
    0x80803310
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM8_12_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_12"
    VALUE
    0x80803312
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM8_13_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_13"
    VALUE
    0x80803314
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM8_16_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_16"
    VALUE
    0x80803316
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM8_18_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_18"
    VALUE
    0x80803318
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM8_2_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_2"
    VALUE
    0x8080331A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM8_3_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_3"
    VALUE
    0x8080331C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM8_30_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_30"
    VALUE
    0x8080331E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM8_31_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_31"
    VALUE
    0x80803320
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM8_4_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_4"
    VALUE
    0x80803322
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM9_0_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM9_0"
    VALUE
    0x80803324
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM9_1_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM9_1"
    VALUE
    0x80803326
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM9_15_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM9_15"
    VALUE
    0x80803328
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM9_3_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM9_3"
    VALUE
    0x8080332A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MoCSOPICO_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MoCSOPICO"
    VALUE
    0x8080332C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MoFVarPostBldSel_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MoFVarPostBldSel"
    VALUE
    0x8080332E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MoSysCtrlReIni_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MoSysCtrlReIni"
    VALUE
    0x80803330
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MoXEMMHwLTMCUFW_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MoXEMMHwLTMCUFW"
    VALUE
    0x80803332
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MoXEMMHwLTMonBIST_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MoXEMMHwLTMonBIST"
    VALUE
    0x80803334
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MoXEMMHwLTRegMonTest_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MoXEMMHwLTRegMonTest"
    VALUE
    0x80803336
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MoXEMMHwLTStbySMUAlvTest_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MoXEMMHwLTStbySMUAlvTest"
    VALUE
    0x80803338
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MoXEMMHwLTTempSens_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MoXEMMHwLTTempSens"
    VALUE
    0x8080333A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MoXEMMHwLTUCBCfg_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MoXEMMHwLTUCBCfg"
    VALUE
    0x8080333C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_OCWDAABEActv_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_OCWDAABEActv"
    VALUE
    0x8080333E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_OCWDACom_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_OCWDACom"
    VALUE
    0x80803340
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_OCWDAErrPin_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_OCWDAErrPin"
    VALUE
    0x80803342
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_SWReset_0_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_SWReset_0"
    VALUE
    0x80803344
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_SWReset_1_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_SWReset_1"
    VALUE
    0x80803346
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_SWReset_2_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_SWReset_2"
    VALUE
    0x80803348
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDebFault1_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDebFault1"
    VALUE
    0x8080334A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_Unused_C
    "OBD specific trouble code / "
    VALUE
    0x80804132
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    READ_ONLY

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_TimeInRowDebFault_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_TimeInRowDebFault"
    VALUE
    0x80804134
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_EventInRowDebFault_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_EventInRowDebFault"
    VALUE
    0x80804136
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_DevLibBattUHi_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_DevLibBattUHi"
    VALUE
    0x80804138
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_DevLibBattULo_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_DevLibBattULo"
    VALUE
    0x8080413A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_TimeUpDownDebFault_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_TimeUpDownDebFault"
    VALUE
    0x8080413C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA13OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA13OR"
    VALUE
    0x8080413E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA13SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA13SCB"
    VALUE
    0x80804140
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA13SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA13SCG"
    VALUE
    0x80804142
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA14OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA14OR"
    VALUE
    0x80804144
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA14SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA14SCB"
    VALUE
    0x80804146
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA14SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA14SCG"
    VALUE
    0x80804148
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA21OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA21OR"
    VALUE
    0x8080414A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA21SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA21SCB"
    VALUE
    0x8080414C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA21SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA21SCG"
    VALUE
    0x8080414E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA22OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA22OR"
    VALUE
    0x80804150
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA22SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA22SCB"
    VALUE
    0x80804152
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA22SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA22SCG"
    VALUE
    0x80804154
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA23OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA23OR"
    VALUE
    0x80804156
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA23SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA23SCB"
    VALUE
    0x80804158
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA23SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA23SCG"
    VALUE
    0x8080415A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA24OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA24OR"
    VALUE
    0x8080415C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA24SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA24SCB"
    VALUE
    0x8080415E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA24SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA24SCG"
    VALUE
    0x80804160
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA25OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA25OR"
    VALUE
    0x80804162
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA25SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA25SCB"
    VALUE
    0x80804164
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA25SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA25SCG"
    VALUE
    0x80804166
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA26OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA26OR"
    VALUE
    0x80804168
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA26SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA26SCB"
    VALUE
    0x8080416A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA26SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA26SCG"
    VALUE
    0x8080416C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA27OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA27OR"
    VALUE
    0x8080416E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA27SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA27SCB"
    VALUE
    0x80804170
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA27SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA27SCG"
    VALUE
    0x80804172
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA28OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA28OR"
    VALUE
    0x80804174
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA28SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA28SCB"
    VALUE
    0x80804176
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA28SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA28SCG"
    VALUE
    0x80804178
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA29OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA29OR"
    VALUE
    0x8080417A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA29SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA29SCB"
    VALUE
    0x8080417C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA29SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA29SCG"
    VALUE
    0x8080417E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA36AicSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA36AicSCB"
    VALUE
    0x80804180
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA36AicSCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA36AicSCG"
    VALUE
    0x80804182
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA36OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA36OR"
    VALUE
    0x80804184
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA36SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA36SCB"
    VALUE
    0x80804186
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA36SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA36SCG"
    VALUE
    0x80804188
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA36ShuntSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA36ShuntSCB"
    VALUE
    0x8080418A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA37AicSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA37AicSCB"
    VALUE
    0x8080418C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA37AicSCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA37AicSCG"
    VALUE
    0x8080418E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA37OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA37OR"
    VALUE
    0x80804190
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA37SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA37SCB"
    VALUE
    0x80804192
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA37SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA37SCG"
    VALUE
    0x80804194
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA37ShuntSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA37ShuntSCB"
    VALUE
    0x80804196
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA38AicSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA38AicSCB"
    VALUE
    0x80804198
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA38AicSCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA38AicSCG"
    VALUE
    0x8080419A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA38OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA38OR"
    VALUE
    0x8080419C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA38SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA38SCB"
    VALUE
    0x8080419E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA38SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA38SCG"
    VALUE
    0x808041A0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA38ShuntSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA38ShuntSCB"
    VALUE
    0x808041A2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA39AicSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA39AicSCB"
    VALUE
    0x808041A4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA39AicSCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA39AicSCG"
    VALUE
    0x808041A6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA39OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA39OR"
    VALUE
    0x808041A8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA39SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA39SCB"
    VALUE
    0x808041AA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA39SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA39SCG"
    VALUE
    0x808041AC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA39ShuntSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA39ShuntSCB"
    VALUE
    0x808041AE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA40OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA40OR"
    VALUE
    0x808041B0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA40SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA40SCB"
    VALUE
    0x808041B2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA40SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA40SCG"
    VALUE
    0x808041B4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA41OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA41OR"
    VALUE
    0x808041B6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA41SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA41SCB"
    VALUE
    0x808041B8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA41SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA41SCG"
    VALUE
    0x808041BA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA42OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA42OR"
    VALUE
    0x808041BC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA42SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA42SCB"
    VALUE
    0x808041BE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA42SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA42SCG"
    VALUE
    0x808041C0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA43AicSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA43AicSCB"
    VALUE
    0x808041C2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA43AicSCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA43AicSCG"
    VALUE
    0x808041C4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA43OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA43OR"
    VALUE
    0x808041C6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA43SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA43SCB"
    VALUE
    0x808041C8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA43SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA43SCG"
    VALUE
    0x808041CA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA43ShuntSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA43ShuntSCB"
    VALUE
    0x808041CC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA44OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA44OL"
    VALUE
    0x808041CE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA44SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA44SCB"
    VALUE
    0x808041D0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA44SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA44SCG"
    VALUE
    0x808041D2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA57OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA57OR"
    VALUE
    0x808041D4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA57SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA57SCB"
    VALUE
    0x808041D6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA57SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA57SCG"
    VALUE
    0x808041D8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA59OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA59OL"
    VALUE
    0x808041DA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA59SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA59SCB"
    VALUE
    0x808041DC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA59SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA59SCG"
    VALUE
    0x808041DE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK10OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK10OR"
    VALUE
    0x808041E0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK10SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK10SCB"
    VALUE
    0x808041E2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK10SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK10SCG"
    VALUE
    0x808041E4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK11OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK11OR"
    VALUE
    0x808041E6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK11SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK11SCB"
    VALUE
    0x808041E8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK11SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK11SCG"
    VALUE
    0x808041EA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK30AicSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK30AicSCB"
    VALUE
    0x808041EC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK30AicSCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK30AicSCG"
    VALUE
    0x808041EE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK30OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK30OR"
    VALUE
    0x808041F0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK30SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK30SCB"
    VALUE
    0x808041F2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK30SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK30SCG"
    VALUE
    0x808041F4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK30ShuntSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK30ShuntSCB"
    VALUE
    0x808041F6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK31OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK31OR"
    VALUE
    0x808041F8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK31SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK31SCB"
    VALUE
    0x808041FA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK31SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK31SCG"
    VALUE
    0x808041FC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK32OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK32OR"
    VALUE
    0x808041FE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK32SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK32SCB"
    VALUE
    0x80804200
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK32SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK32SCG"
    VALUE
    0x80804202
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK33OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK33OR"
    VALUE
    0x80804204
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK33SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK33SCB"
    VALUE
    0x80804206
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK33SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK33SCG"
    VALUE
    0x80804208
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK34OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK34OR"
    VALUE
    0x8080420A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK34SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK34SCB"
    VALUE
    0x8080420C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK34SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK34SCG"
    VALUE
    0x8080420E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK35OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK35OR"
    VALUE
    0x80804210
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK35SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK35SCB"
    VALUE
    0x80804212
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK35SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK35SCG"
    VALUE
    0x80804214
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK36OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK36OR"
    VALUE
    0x80804216
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK36SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK36SCB"
    VALUE
    0x80804218
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK36SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK36SCG"
    VALUE
    0x8080421A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK37AicSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK37AicSCB"
    VALUE
    0x8080421C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK37AicSCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK37AicSCG"
    VALUE
    0x8080421E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK37OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK37OR"
    VALUE
    0x80804220
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK37SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK37SCB"
    VALUE
    0x80804222
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK37SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK37SCG"
    VALUE
    0x80804224
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK37ShuntSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK37ShuntSCB"
    VALUE
    0x80804226
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK38AicSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK38AicSCB"
    VALUE
    0x80804228
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK38AicSCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK38AicSCG"
    VALUE
    0x8080422A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK38OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK38OR"
    VALUE
    0x8080422C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK38SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK38SCB"
    VALUE
    0x8080422E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK38SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK38SCG"
    VALUE
    0x80804230
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK38ShuntSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK38ShuntSCB"
    VALUE
    0x80804232
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK39AicSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK39AicSCB"
    VALUE
    0x80804234
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK39AicSCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK39AicSCG"
    VALUE
    0x80804236
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK39OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK39OR"
    VALUE
    0x80804238
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK39SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK39SCB"
    VALUE
    0x8080423A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK39SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK39SCG"
    VALUE
    0x8080423C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK39ShuntSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK39ShuntSCB"
    VALUE
    0x8080423E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK40AicSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK40AicSCB"
    VALUE
    0x80804240
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK40AicSCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK40AicSCG"
    VALUE
    0x80804242
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK40OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK40OR"
    VALUE
    0x80804244
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK40SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK40SCB"
    VALUE
    0x80804246
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK40SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK40SCG"
    VALUE
    0x80804248
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK40ShuntSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK40ShuntSCB"
    VALUE
    0x8080424A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK41AicSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK41AicSCB"
    VALUE
    0x8080424C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK41AicSCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK41AicSCG"
    VALUE
    0x8080424E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK41OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK41OR"
    VALUE
    0x80804250
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK41SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK41SCB"
    VALUE
    0x80804252
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK41SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK41SCG"
    VALUE
    0x80804254
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK41ShuntSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK41ShuntSCB"
    VALUE
    0x80804256
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK42AicSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK42AicSCB"
    VALUE
    0x80804258
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK42AicSCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK42AicSCG"
    VALUE
    0x8080425A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK42OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK42OR"
    VALUE
    0x8080425C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK42SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK42SCB"
    VALUE
    0x8080425E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK42SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK42SCG"
    VALUE
    0x80804260
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK42ShuntSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK42ShuntSCB"
    VALUE
    0x80804262
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK43OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK43OR"
    VALUE
    0x80804264
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK43SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK43SCB"
    VALUE
    0x80804266
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK43SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK43SCG"
    VALUE
    0x80804268
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK44AicSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK44AicSCB"
    VALUE
    0x8080426A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK44AicSCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK44AicSCG"
    VALUE
    0x8080426C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK44OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK44OR"
    VALUE
    0x8080426E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK44SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK44SCB"
    VALUE
    0x80804270
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK44SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK44SCG"
    VALUE
    0x80804272
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK44ShuntSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK44ShuntSCB"
    VALUE
    0x80804274
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK45AicSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK45AicSCB"
    VALUE
    0x80804276
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK45AicSCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK45AicSCG"
    VALUE
    0x80804278
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK45OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK45OR"
    VALUE
    0x8080427A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK45SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK45SCB"
    VALUE
    0x8080427C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK45SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK45SCG"
    VALUE
    0x8080427E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK45ShuntSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK45ShuntSCB"
    VALUE
    0x80804280
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK52OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK52OR"
    VALUE
    0x80804282
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK52SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK52SCB"
    VALUE
    0x80804284
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK52SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK52SCG"
    VALUE
    0x80804286
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK53OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK53OR"
    VALUE
    0x80804288
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK53SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK53SCB"
    VALUE
    0x8080428A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK53SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK53SCG"
    VALUE
    0x8080428C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK54AicSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK54AicSCB"
    VALUE
    0x8080428E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK54AicSCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK54AicSCG"
    VALUE
    0x80804290
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK54OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK54OR"
    VALUE
    0x80804292
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK54SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK54SCB"
    VALUE
    0x80804294
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK54SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK54SCG"
    VALUE
    0x80804296
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK54ShuntSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK54ShuntSCB"
    VALUE
    0x80804298
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK55AicSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK55AicSCB"
    VALUE
    0x8080429A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK55AicSCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK55AicSCG"
    VALUE
    0x8080429C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK55OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK55OR"
    VALUE
    0x8080429E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK55SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK55SCB"
    VALUE
    0x808042A0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK55SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK55SCG"
    VALUE
    0x808042A2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK55ShuntSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK55ShuntSCB"
    VALUE
    0x808042A4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK56OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK56OR"
    VALUE
    0x808042A6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK56SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK56SCB"
    VALUE
    0x808042A8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK56SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK56SCG"
    VALUE
    0x808042AA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK57OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK57OR"
    VALUE
    0x808042AC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK57SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK57SCB"
    VALUE
    0x808042AE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK57SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK57SCG"
    VALUE
    0x808042B0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK58OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK58OR"
    VALUE
    0x808042B2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK58SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK58SCB"
    VALUE
    0x808042B4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK58SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK58SCG"
    VALUE
    0x808042B6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK59OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK59OR"
    VALUE
    0x808042B8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK59SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK59SCB"
    VALUE
    0x808042BA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK59SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK59SCG"
    VALUE
    0x808042BC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK60OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK60OR"
    VALUE
    0x808042BE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK60SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK60SCB"
    VALUE
    0x808042C0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK60SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK60SCG"
    VALUE
    0x808042C2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK61AicSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK61AicSCB"
    VALUE
    0x808042C4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK61AicSCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK61AicSCG"
    VALUE
    0x808042C6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK61OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK61OR"
    VALUE
    0x808042C8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK61SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK61SCB"
    VALUE
    0x808042CA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK61SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK61SCG"
    VALUE
    0x808042CC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK61ShuntSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK61ShuntSCB"
    VALUE
    0x808042CE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK62OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK62OR"
    VALUE
    0x808042D0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK62SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK62SCB"
    VALUE
    0x808042D2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK62SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK62SCG"
    VALUE
    0x808042D4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK63AicSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK63AicSCB"
    VALUE
    0x808042D6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK63AicSCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK63AicSCG"
    VALUE
    0x808042D8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK63OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK63OR"
    VALUE
    0x808042DA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK63SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK63SCB"
    VALUE
    0x808042DC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK63SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK63SCG"
    VALUE
    0x808042DE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK63ShuntSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK63ShuntSCB"
    VALUE
    0x808042E0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK64AicSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK64AicSCB"
    VALUE
    0x808042E2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK64AicSCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK64AicSCG"
    VALUE
    0x808042E4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK64OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK64OR"
    VALUE
    0x808042E6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK64SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK64SCB"
    VALUE
    0x808042E8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK64SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK64SCG"
    VALUE
    0x808042EA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK64ShuntSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK64ShuntSCB"
    VALUE
    0x808042EC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK65AicSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK65AicSCB"
    VALUE
    0x808042EE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK65AicSCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK65AicSCG"
    VALUE
    0x808042F0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK65OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK65OR"
    VALUE
    0x808042F2
    Val_Wu16
    65535.00
    DFES_OneToOne
