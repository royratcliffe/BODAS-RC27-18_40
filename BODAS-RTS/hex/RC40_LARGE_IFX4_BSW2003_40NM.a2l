    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK65OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK65OR"
    VALUE
    0x808042F2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK65SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK65SCB"
    VALUE
    0x808042F4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK65SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK65SCG"
    VALUE
    0x808042F6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK65ShuntSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK65ShuntSCB"
    VALUE
    0x808042F8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK74OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK74OR"
    VALUE
    0x808042FA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK74SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK74SCB"
    VALUE
    0x808042FC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK74SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK74SCG"
    VALUE
    0x808042FE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK75OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK75OR"
    VALUE
    0x80804300
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK75SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK75SCB"
    VALUE
    0x80804302
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK75SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK75SCG"
    VALUE
    0x80804304
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK76OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK76OR"
    VALUE
    0x80804306
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK76SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK76SCB"
    VALUE
    0x80804308
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK76SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK76SCG"
    VALUE
    0x8080430A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK77OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK77OR"
    VALUE
    0x8080430C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK77SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK77SCB"
    VALUE
    0x8080430E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK77SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK77SCG"
    VALUE
    0x80804310
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK78OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK78OR"
    VALUE
    0x80804312
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK78SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK78SCB"
    VALUE
    0x80804314
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK78SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK78SCG"
    VALUE
    0x80804316
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_DvUBAT_FWs_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_DvUBAT_FWs"
    VALUE
    0x80804318
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_OVErr_VPR6_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_OVErr_VPR6"
    VALUE
    0x8080431A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_OVWarn_VPR6_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_OVWarn_VPR6"
    VALUE
    0x8080431C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3"
    VALUE
    0x8080431E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2"
    VALUE
    0x80804320
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_OV_UBAT_MON_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_OV_UBAT_MON"
    VALUE
    0x80804322
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_OV_UBRM24_FLEXIN_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_OV_UBRM24_FLEXIN"
    VALUE
    0x80804324
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_OV_UBRM24_LOADS_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_OV_UBRM24_LOADS"
    VALUE
    0x80804326
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_OV_UBRM24_MON_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_OV_UBRM24_MON"
    VALUE
    0x80804328
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_OV_VDD5_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_OV_VDD5"
    VALUE
    0x8080432A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_OV_VDD5_IN_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_OV_VDD5_IN"
    VALUE
    0x8080432C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_OV_VPR6_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_OV_VPR6"
    VALUE
    0x8080432E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_OV_VSS3_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_OV_VSS3"
    VALUE
    0x80804330
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_OV_VSS4_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_OV_VSS4"
    VALUE
    0x80804332
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_Temp1_HTErr_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_Temp1_HTErr"
    VALUE
    0x80804334
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_Temp1_HTWarn_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_Temp1_HTWarn"
    VALUE
    0x80804336
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_Temp2_HTErr_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_Temp2_HTErr"
    VALUE
    0x80804338
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_Temp2_HTWarn_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_Temp2_HTWarn"
    VALUE
    0x8080433A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3"
    VALUE
    0x8080433C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2"
    VALUE
    0x8080433E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_UV_VDD5_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_UV_VDD5"
    VALUE
    0x80804340
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_UV_VDD5_IN_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_UV_VDD5_IN"
    VALUE
    0x80804342
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_UV_VPR6_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_UV_VPR6"
    VALUE
    0x80804344
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_UV_VSS3_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_UV_VSS3"
    VALUE
    0x80804346
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_UV_VSS4_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_UV_VSS4"
    VALUE
    0x80804348
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA01OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA01OL"
    VALUE
    0x8080434A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA01OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA01OT"
    VALUE
    0x8080434C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA01SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA01SCB"
    VALUE
    0x8080434E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA01SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA01SCG"
    VALUE
    0x80804350
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA02OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA02OL"
    VALUE
    0x80804352
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA02OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA02OR"
    VALUE
    0x80804354
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA02OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA02OT"
    VALUE
    0x80804356
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA02SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA02SCB"
    VALUE
    0x80804358
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA02SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA02SCG"
    VALUE
    0x8080435A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA03OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA03OL"
    VALUE
    0x8080435C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA03OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA03OT"
    VALUE
    0x8080435E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA03SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA03SCB"
    VALUE
    0x80804360
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA03SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA03SCG"
    VALUE
    0x80804362
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA04OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA04OL"
    VALUE
    0x80804364
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA04OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA04OT"
    VALUE
    0x80804366
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA04SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA04SCB"
    VALUE
    0x80804368
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA04SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA04SCG"
    VALUE
    0x8080436A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA05OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA05OL"
    VALUE
    0x8080436C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA05OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA05OR"
    VALUE
    0x8080436E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA05OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA05OT"
    VALUE
    0x80804370
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA05SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA05SCB"
    VALUE
    0x80804372
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA05SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA05SCG"
    VALUE
    0x80804374
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA06OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA06OL"
    VALUE
    0x80804376
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA06OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA06OR"
    VALUE
    0x80804378
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA06OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA06OT"
    VALUE
    0x8080437A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA06SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA06SCB"
    VALUE
    0x8080437C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA06SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA06SCG"
    VALUE
    0x8080437E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA07OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA07OL"
    VALUE
    0x80804380
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA07OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA07OT"
    VALUE
    0x80804382
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA07SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA07SCB"
    VALUE
    0x80804384
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA07SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA07SCG"
    VALUE
    0x80804386
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA08OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA08OL"
    VALUE
    0x80804388
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA08OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA08OT"
    VALUE
    0x8080438A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA08SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA08SCB"
    VALUE
    0x8080438C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA08SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA08SCG"
    VALUE
    0x8080438E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA09OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA09OL"
    VALUE
    0x80804390
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA09OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA09OR"
    VALUE
    0x80804392
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA09OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA09OT"
    VALUE
    0x80804394
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA09SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA09SCB"
    VALUE
    0x80804396
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA09SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA09SCG"
    VALUE
    0x80804398
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA10OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA10OL"
    VALUE
    0x8080439A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA10OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA10OT"
    VALUE
    0x8080439C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA10SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA10SCB"
    VALUE
    0x8080439E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA10SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA10SCG"
    VALUE
    0x808043A0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA11OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA11OL"
    VALUE
    0x808043A2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA11OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA11OT"
    VALUE
    0x808043A4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA11SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA11SCB"
    VALUE
    0x808043A6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA11SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA11SCG"
    VALUE
    0x808043A8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA12OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA12OR"
    VALUE
    0x808043AA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA12SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA12SCB"
    VALUE
    0x808043AC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA12SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA12SCG"
    VALUE
    0x808043AE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA16OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA16OL"
    VALUE
    0x808043B0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA16OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA16OT"
    VALUE
    0x808043B2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA16SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA16SCB"
    VALUE
    0x808043B4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA16SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA16SCG"
    VALUE
    0x808043B6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA17OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA17OL"
    VALUE
    0x808043B8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA17OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA17OR"
    VALUE
    0x808043BA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA17OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA17OT"
    VALUE
    0x808043BC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA17SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA17SCB"
    VALUE
    0x808043BE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA17SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA17SCG"
    VALUE
    0x808043C0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA18OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA18OL"
    VALUE
    0x808043C2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA18OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA18OT"
    VALUE
    0x808043C4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA18SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA18SCB"
    VALUE
    0x808043C6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA18SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA18SCG"
    VALUE
    0x808043C8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA19OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA19OL"
    VALUE
    0x808043CA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA19OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA19OR"
    VALUE
    0x808043CC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA19OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA19OT"
    VALUE
    0x808043CE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA19SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA19SCB"
    VALUE
    0x808043D0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA19SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA19SCG"
    VALUE
    0x808043D2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA20OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA20OL"
    VALUE
    0x808043D4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA20OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA20OR"
    VALUE
    0x808043D6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA20OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA20OT"
    VALUE
    0x808043D8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA20SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA20SCB"
    VALUE
    0x808043DA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA20SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA20SCG"
    VALUE
    0x808043DC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA31OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA31OL"
    VALUE
    0x808043DE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA31OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA31OR"
    VALUE
    0x808043E0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA31OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA31OT"
    VALUE
    0x808043E2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA31SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA31SCB"
    VALUE
    0x808043E4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA31SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA31SCG"
    VALUE
    0x808043E6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA32OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA32OL"
    VALUE
    0x808043E8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA32OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA32OR"
    VALUE
    0x808043EA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA32OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA32OT"
    VALUE
    0x808043EC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA32SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA32SCB"
    VALUE
    0x808043EE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA32SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA32SCG"
    VALUE
    0x808043F0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA33OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA33OL"
    VALUE
    0x808043F2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA33OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA33OR"
    VALUE
    0x808043F4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA33OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA33OT"
    VALUE
    0x808043F6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA33SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA33SCB"
    VALUE
    0x808043F8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA33SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA33SCG"
    VALUE
    0x808043FA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA34OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA34OL"
    VALUE
    0x808043FC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA34OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA34OR"
    VALUE
    0x808043FE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA34OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA34OT"
    VALUE
    0x80804400
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA34SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA34SCB"
    VALUE
    0x80804402
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA34SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA34SCG"
    VALUE
    0x80804404
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA35OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA35OL"
    VALUE
    0x80804406
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA35OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA35OR"
    VALUE
    0x80804408
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA35OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA35OT"
    VALUE
    0x8080440A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA35SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA35SCB"
    VALUE
    0x8080440C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA35SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA35SCG"
    VALUE
    0x8080440E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA46OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA46OL"
    VALUE
    0x80804410
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA46OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA46OR"
    VALUE
    0x80804412
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA46OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA46OT"
    VALUE
    0x80804414
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA46SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA46SCB"
    VALUE
    0x80804416
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA46SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA46SCG"
    VALUE
    0x80804418
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA47OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA47OL"
    VALUE
    0x8080441A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA47OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA47OR"
    VALUE
    0x8080441C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA47OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA47OT"
    VALUE
    0x8080441E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA47SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA47SCB"
    VALUE
    0x80804420
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA47SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA47SCG"
    VALUE
    0x80804422
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA48OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA48OL"
    VALUE
    0x80804424
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA48OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA48OR"
    VALUE
    0x80804426
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA48OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA48OT"
    VALUE
    0x80804428
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA48SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA48SCB"
    VALUE
    0x8080442A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA48SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA48SCG"
    VALUE
    0x8080442C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA49OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA49OL"
    VALUE
    0x8080442E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA49OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA49OT"
    VALUE
    0x80804430
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA49SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA49SCB"
    VALUE
    0x80804432
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA49SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA49SCG"
    VALUE
    0x80804434
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA50OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA50OL"
    VALUE
    0x80804436
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA50OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA50OT"
    VALUE
    0x80804438
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA50SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA50SCB"
    VALUE
    0x8080443A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA50SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA50SCG"
    VALUE
    0x8080443C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA51OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA51OL"
    VALUE
    0x8080443E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA51OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA51OR"
    VALUE
    0x80804440
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA51OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA51OT"
    VALUE
    0x80804442
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA51SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA51SCB"
    VALUE
    0x80804444
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA51SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA51SCG"
    VALUE
    0x80804446
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA52OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA52OL"
    VALUE
    0x80804448
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA52OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA52OR"
    VALUE
    0x8080444A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA52OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA52OT"
    VALUE
    0x8080444C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA52SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA52SCB"
    VALUE
    0x8080444E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA52SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA52SCG"
    VALUE
    0x80804450
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA53OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA53OL"
    VALUE
    0x80804452
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA53OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA53OR"
    VALUE
    0x80804454
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA53OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA53OT"
    VALUE
    0x80804456
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA53SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA53SCB"
    VALUE
    0x80804458
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA53SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA53SCG"
    VALUE
    0x8080445A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA54OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA54OL"
    VALUE
    0x8080445C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA54OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA54OR"
    VALUE
    0x8080445E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA54OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA54OT"
    VALUE
    0x80804460
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA54SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA54SCB"
    VALUE
    0x80804462
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA54SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA54SCG"
    VALUE
    0x80804464
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA55OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA55OL"
    VALUE
    0x80804466
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA55OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA55OT"
    VALUE
    0x80804468
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA55SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA55SCB"
    VALUE
    0x8080446A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA55SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA55SCG"
    VALUE
    0x8080446C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA56OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA56OL"
    VALUE
    0x8080446E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA56OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA56OT"
    VALUE
    0x80804470
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA56SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA56SCB"
    VALUE
    0x80804472
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA56SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA56SCG"
    VALUE
    0x80804474
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA58OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA58OL"
    VALUE
    0x80804476
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA58OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA58OT"
    VALUE
    0x80804478
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA58SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA58SCB"
    VALUE
    0x8080447A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA58SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA58SCG"
    VALUE
    0x8080447C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK07OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK07OL"
    VALUE
    0x8080447E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK07OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK07OR"
    VALUE
    0x80804480
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK07OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK07OT"
    VALUE
    0x80804482
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK07SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK07SCB"
    VALUE
    0x80804484
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK07SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK07SCG"
    VALUE
    0x80804486
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK08OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK08OL"
    VALUE
    0x80804488
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK08OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK08OR"
    VALUE
    0x8080448A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK08OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK08OT"
    VALUE
    0x8080448C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK08SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK08SCB"
    VALUE
    0x8080448E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK08SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK08SCG"
    VALUE
    0x80804490
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK09OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK09OL"
    VALUE
    0x80804492
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK09OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK09OR"
    VALUE
    0x80804494
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK09OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK09OT"
    VALUE
    0x80804496
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK09SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK09SCB"
    VALUE
    0x80804498
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK09SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK09SCG"
    VALUE
    0x8080449A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK12OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK12OL"
    VALUE
    0x8080449C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK12OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK12OT"
    VALUE
    0x8080449E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK12SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK12SCB"
    VALUE
    0x808044A0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK12SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK12SCG"
    VALUE
    0x808044A2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK13OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK13OL"
    VALUE
    0x808044A4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK13OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK13OT"
    VALUE
    0x808044A6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK13SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK13SCB"
    VALUE
    0x808044A8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK13SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK13SCG"
    VALUE
    0x808044AA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK14OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK14OL"
    VALUE
    0x808044AC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK14OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK14OR"
    VALUE
    0x808044AE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK14OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK14OT"
    VALUE
    0x808044B0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK14SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK14SCB"
    VALUE
    0x808044B2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK14SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK14SCG"
    VALUE
    0x808044B4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK15OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK15OL"
    VALUE
    0x808044B6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK15OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK15OR"
    VALUE
    0x808044B8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK15OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK15OT"
    VALUE
    0x808044BA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK15SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK15SCB"
    VALUE
    0x808044BC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK15SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK15SCG"
    VALUE
    0x808044BE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK16OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK16OL"
    VALUE
    0x808044C0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK16OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK16OR"
    VALUE
    0x808044C2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK16OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK16OT"
    VALUE
    0x808044C4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK16SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK16SCB"
    VALUE
    0x808044C6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK16SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK16SCG"
    VALUE
    0x808044C8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK17OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK17OL"
    VALUE
    0x808044CA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK17OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK17OR"
    VALUE
    0x808044CC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK17OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK17OT"
    VALUE
    0x808044CE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK17SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK17SCB"
    VALUE
    0x808044D0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK17SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK17SCG"
    VALUE
    0x808044D2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK25OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK25OR"
    VALUE
    0x808044D4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK25SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK25SCB"
    VALUE
    0x808044D6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK25SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK25SCG"
    VALUE
    0x808044D8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK29OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK29OL"
    VALUE
    0x808044DA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK29OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK29OR"
    VALUE
    0x808044DC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK29OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK29OT"
    VALUE
    0x808044DE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK29SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK29SCB"
    VALUE
    0x808044E0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK29SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK29SCG"
    VALUE
    0x808044E2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK51OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK51OL"
    VALUE
    0x808044E4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK51OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK51OT"
    VALUE
    0x808044E6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK51SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK51SCB"
    VALUE
    0x808044E8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK51SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK51SCG"
    VALUE
    0x808044EA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK62OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK62OR"
    VALUE
    0x808044EC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK62SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK62SCB"
    VALUE
    0x808044EE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK62SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK62SCG"
    VALUE
    0x808044F0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK73OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK73OL"
    VALUE
    0x808044F2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK73OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK73OR"
    VALUE
    0x808044F4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK73OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK73OT"
    VALUE
    0x808044F6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK73SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK73SCB"
    VALUE
    0x808044F8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK73SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK73SCG"
    VALUE
    0x808044FA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK80OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK80OL"
    VALUE
    0x808044FC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK80OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK80OT"
    VALUE
    0x808044FE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK80SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK80SCB"
    VALUE
    0x80804500
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK80SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK80SCG"
    VALUE
    0x80804502
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK81OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK81OL"
    VALUE
    0x80804504
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK81OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK81OT"
    VALUE
    0x80804506
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK81SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK81SCB"
    VALUE
    0x80804508
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK81SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK81SCG"
    VALUE
    0x8080450A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK82OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK82OL"
    VALUE
    0x8080450C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK82OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK82OT"
    VALUE
    0x8080450E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK82SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK82SCB"
    VALUE
    0x80804510
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK82SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK82SCG"
    VALUE
    0x80804512
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK83OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK83OL"
    VALUE
    0x80804514
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK83OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK83OT"
    VALUE
    0x80804516
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK83SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK83SCB"
    VALUE
    0x80804518
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK83SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK83SCG"
    VALUE
    0x8080451A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK84OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK84OL"
    VALUE
    0x8080451C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK84OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK84OT"
    VALUE
    0x8080451E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK84SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK84SCB"
    VALUE
    0x80804520
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK84SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK84SCG"
    VALUE
    0x80804522
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK85OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK85OL"
    VALUE
    0x80804524
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK85OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK85OT"
    VALUE
    0x80804526
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK85SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK85SCB"
    VALUE
    0x80804528
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK85SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK85SCG"
    VALUE
    0x8080452A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK86OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK86OL"
    VALUE
    0x8080452C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK86OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK86OT"
    VALUE
    0x8080452E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK86SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK86SCB"
    VALUE
    0x80804530
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK86SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK86SCG"
    VALUE
    0x80804532
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK87OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK87OL"
    VALUE
    0x80804534
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK87OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK87OT"
    VALUE
    0x80804536
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK87SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK87SCB"
    VALUE
    0x80804538
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK87SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK87SCG"
    VALUE
    0x8080453A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_EventUpDownDebFault_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_EventUpDownDebFault"
    VALUE
    0x8080453C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_DSMDummy_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_DSMDummy"
    VALUE
    0x8080453E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canGetDataNoBuf_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canGetDataNoBuf"
    VALUE
    0x80804540
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canGetDataParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canGetDataParam"
    VALUE
    0x80804542
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canGetDataboxNoInit_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canGetDataboxNoInit"
    VALUE
    0x80804544
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canGetDataboxParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canGetDataboxParam"
    VALUE
    0x80804546
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canGetRxBufStatusParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canGetRxBufStatusParam"
    VALUE
    0x80804548
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canGetStatusParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canGetStatusParam"
    VALUE
    0x8080454A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canGetTxBufStatusParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canGetTxBufStatusParam"
    VALUE
    0x8080454C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canInitParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canInitParam"
    VALUE
    0x8080454E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canInitRxDataboxOverlap_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canInitRxDataboxOverlap"
    VALUE
    0x80804550
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canInitRxDataboxParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canInitRxDataboxParam"
    VALUE
    0x80804552
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canInitTxDataboxParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canInitTxDataboxParam"
    VALUE
    0x80804554
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canIpduGroupControl_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canIpduGroupControl"
    VALUE
    0x80804556
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canIsDataboxFreeNoInit_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canIsDataboxFreeNoInit"
    VALUE
    0x80804558
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canIsDataboxFreeParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canIsDataboxFreeParam"
    VALUE
    0x8080455A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canIsTxEmptyParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canIsTxEmptyParam"
    VALUE
    0x8080455C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canRegBusOffCallbInvState_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canRegBusOffCallbInvState"
    VALUE
    0x8080455E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canRegBusOffCallbParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canRegBusOffCallbParam"
    VALUE
    0x80804560
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canRegRxBufInvState_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canRegRxBufInvState"
    VALUE
    0x80804562
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canRegRxBufOverlap_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canRegRxBufOverlap"
    VALUE
    0x80804564
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canRegRxBufParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canRegRxBufParam"
    VALUE
    0x80804566
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canRegRxCallbInvState_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canRegRxCallbInvState"
    VALUE
    0x80804568
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canRegRxCallbParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canRegRxCallbParam"
    VALUE
    0x8080456A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canRegRxDataboxInvNumb_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canRegRxDataboxInvNumb"
    VALUE
    0x8080456C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canRegRxDataboxInvState_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canRegRxDataboxInvState"
    VALUE
    0x8080456E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canRegRxDataboxOverlap_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canRegRxDataboxOverlap"
    VALUE
    0x80804570
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canRegRxDataboxParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canRegRxDataboxParam"
    VALUE
    0x80804572
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canRegTxBufInvState_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canRegTxBufInvState"
    VALUE
    0x80804574
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canRegTxBufOverlap_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canRegTxBufOverlap"
    VALUE
    0x80804576
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canRegTxBufParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canRegTxBufParam"
    VALUE
    0x80804578
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canRegTxDataboxInvNumb_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canRegTxDataboxInvNumb"
    VALUE
    0x8080457A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canRegTxDataboxInvState_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canRegTxDataboxInvState"
    VALUE
    0x8080457C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canRegTxDataboxOverlap_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canRegTxDataboxOverlap"
    VALUE
    0x8080457E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canRegTxDataboxParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canRegTxDataboxParam"
    VALUE
    0x80804580
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canResetTxBufParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canResetTxBufParam"
    VALUE
    0x80804582
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canSendDataBufOvfl_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canSendDataBufOvfl"
    VALUE
    0x80804584
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canSendDataParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canSendDataParam"
    VALUE
    0x80804586
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canSendDataboxNoInit_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canSendDataboxNoInit"
    VALUE
    0x80804588
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canSendDataboxParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canSendDataboxParam"
    VALUE
    0x8080458A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canSetTxCycleParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canSetTxCycleParam"
    VALUE
    0x8080458C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canStartParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canStartParam"
    VALUE
    0x8080458E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canStopParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canStopParam"
    VALUE
    0x80804590
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_can_ClearIpduGroup_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_can_ClearIpduGroup"
    VALUE
    0x80804592
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_can_ReceiveSignal_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_can_ReceiveSignal"
    VALUE
    0x80804594
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_can_SendSignal_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_can_SendSignal"
    VALUE
    0x80804596
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_can_SetIpduGroup_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_can_SetIpduGroup"
    VALUE
    0x80804598
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_dsmDTCJ1939_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_dsmDTCJ1939"
    VALUE
    0x8080459A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_dsmDelDTCJ1939_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_dsmDelDTCJ1939"
    VALUE
    0x8080459C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_dsmDelErrors_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_dsmDelErrors"
    VALUE
    0x8080459E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_dsmGetDFES_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_dsmGetDFES"
    VALUE
    0x808045A0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_dsmGetDTCJ1939_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_dsmGetDTCJ1939"
    VALUE
    0x808045A2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_dsmGetErrors_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_dsmGetErrors"
    VALUE
    0x808045A4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_dsmGetNumErrors_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_dsmGetNumErrors"
    VALUE
    0x808045A6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_dsmInitQueueOverflow_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_dsmInitQueueOverflow"
    VALUE
    0x808045A8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_dsmNumDTCJ1939_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_dsmNumDTCJ1939"
    VALUE
    0x808045AA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_dsmTesterror_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_dsmTesterror"
    VALUE
    0x808045AC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_dsmUpdateDebError_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_dsmUpdateDebError"
    VALUE
    0x808045AE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_dsmUpdateError_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_dsmUpdateError"
    VALUE
    0x808045B0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_dsmgetDFCStatus_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_dsmgetDFCStatus"
    VALUE
    0x808045B2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_dsmtestErrorDFC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_dsmtestErrorDFC"
    VALUE
    0x808045B4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inAi_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inAi"
    VALUE
    0x808045B6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inAic_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inAic"
    VALUE
    0x808045B8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inAicCfg_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inAicCfg"
    VALUE
    0x808045BA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inAicGetStatus_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inAicGetStatus"
    VALUE
    0x808045BC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inAid_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inAid"
    VALUE
    0x808045BE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inAidCfg_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inAidCfg"
    VALUE
    0x808045C0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inAiv_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inAiv"
    VALUE
    0x808045C2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inAivCfg_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inAivCfg"
    VALUE
    0x808045C4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inAivGetStatus_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inAivGetStatus"
    VALUE
    0x808045C6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inDi_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inDi"
    VALUE
    0x808045C8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inFi_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inFi"
    VALUE
    0x808045CA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inFiCfg_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inFiCfg"
    VALUE
    0x808045CC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inFiGetStatus_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inFiGetStatus"
    VALUE
    0x808045CE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inFi_Buffered_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inFi_Buffered"
    VALUE
    0x808045D0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inPhase_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inPhase"
    VALUE
    0x808045D2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inPhaseGetStatus_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inPhaseGetStatus"
    VALUE
    0x808045D4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inPhaseResetCounter_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inPhaseResetCounter"
    VALUE
    0x808045D6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inRi_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inRi"
    VALUE
    0x808045D8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inRiCfg_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inRiCfg"
    VALUE
    0x808045DA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inRiCfgTemp_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inRiCfgTemp"
    VALUE
    0x808045DC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inRiGetStatus_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inRiGetStatus"
    VALUE
    0x808045DE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inRiGetTemp_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inRiGetTemp"
    VALUE
    0x808045E0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inSentCopyFDFifo_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inSentCopyFDFifo"
    VALUE
    0x808045E2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inSentDisable_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inSentDisable"
    VALUE
    0x808045E4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inSentEnable_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inSentEnable"
    VALUE
    0x808045E6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inSentGetErrorStatus_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inSentGetErrorStatus"
    VALUE
    0x808045E8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inSentGetFD_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inSentGetFD"
    VALUE
    0x808045EA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inSentGetSD_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inSentGetSD"
    VALUE
    0x808045EC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inSentGetSDDatabox_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inSentGetSDDatabox"
    VALUE
    0x808045EE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inSentGetStatus_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inSentGetStatus"
    VALUE
    0x808045F0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inSentInitSDDatabox_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inSentInitSDDatabox"
    VALUE
    0x808045F2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inSentRegisterCopyFDFifo_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inSentRegisterCopyFDFifo"
    VALUE
    0x808045F4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inSentRegisterFDFifo_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inSentRegisterFDFifo"
    VALUE
    0x808045F6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inSentRegisterSDDataboxes_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inSentRegisterSDDataboxes"
    VALUE
    0x808045F8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_isobusCanRxBufferOverflow_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_isobusCanRxBufferOverflow"
    VALUE
    0x808045FA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_isobusGetCaAddrParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_isobusGetCaAddrParam"
    VALUE
    0x808045FC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_isobusGetDiagnosticParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_isobusGetDiagnosticParam"
    VALUE
    0x808045FE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_isobusGetRxDataboxStatusParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_isobusGetRxDataboxStatusParam"
    VALUE
    0x80804600
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_isobusGetStatusParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_isobusGetStatusParam"
    VALUE
    0x80804602
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_isobusInitCommCaMissing_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_isobusInitCommCaMissing"
    VALUE
    0x80804604
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_isobusInitCommParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_isobusInitCommParam"
    VALUE
    0x80804606
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_isobusInitCommState_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_isobusInitCommState"
    VALUE
    0x80804608
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_isobusInitDiagnosticParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_isobusInitDiagnosticParam"
    VALUE
    0x8080460A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_isobusInitFailureListParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_isobusInitFailureListParam"
    VALUE
    0x8080460C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_isobusInitRxDataboxParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_isobusInitRxDataboxParam"
    VALUE
    0x8080460E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_isobusInitTxDataboxParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_isobusInitTxDataboxParam"
    VALUE
    0x80804610
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_isobusRegRxDataboxOverlap_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_isobusRegRxDataboxOverlap"
    VALUE
    0x80804612
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_isobusRegRxDataboxParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_isobusRegRxDataboxParam"
    VALUE
    0x80804614
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_isobusRegRxDataboxState_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_isobusRegRxDataboxState"
    VALUE
    0x80804616
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_isobusRegTxDataboxOverlap_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_isobusRegTxDataboxOverlap"
    VALUE
    0x80804618
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_isobusRegTxDataboxParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_isobusRegTxDataboxParam"
    VALUE
    0x8080461A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_isobusRegTxDataboxState_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_isobusRegTxDataboxState"
    VALUE
    0x8080461C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_isobusRegisterErrClrCallbackParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_isobusRegisterErrClrCallbackParam"
    VALUE
    0x8080461E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_isobusRegisterInstancesOverlap_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_isobusRegisterInstancesOverlap"
    VALUE
    0x80804620
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_isobusRegisterInstancesParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_isobusRegisterInstancesParam"
    VALUE
    0x80804622
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_isobusRegisterInstancesState_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_isobusRegisterInstancesState"
    VALUE
    0x80804624
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_isobusSendDataboxParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_isobusSendDataboxParam"
    VALUE
    0x80804626
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_isobusSendRequestPGNParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_isobusSendRequestPGNParam"
    VALUE
    0x80804628
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_isobusSetCaAddrCaUsed_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_isobusSetCaAddrCaUsed"
    VALUE
    0x8080462A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_isobusSetCaAddrComm_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_isobusSetCaAddrComm"
    VALUE
    0x8080462C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_isobusSetCaAddrInvCan_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_isobusSetCaAddrInvCan"
    VALUE
    0x8080462E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_isobusSetCaAddrParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_isobusSetCaAddrParam"
    VALUE
    0x80804630
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_isobusSetCaInfoParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_isobusSetCaInfoParam"
    VALUE
    0x80804632
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_isobusSetCaNameParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_isobusSetCaNameParam"
    VALUE
    0x80804634
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_isobusSftyCanTxErr_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_isobusSftyCanTxErr"
    VALUE
    0x80804636
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_lin_ReceiveSignal_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_lin_ReceiveSignal"
    VALUE
    0x80804638
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_lin_SendSignal_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_lin_SendSignal"
    VALUE
    0x8080463A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_lin_getStatus_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_lin_getStatus"
    VALUE
    0x8080463C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_lin_gotoSleep_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_lin_gotoSleep"
    VALUE
    0x8080463E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_lin_scheduleRequest_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_lin_scheduleRequest"
    VALUE
    0x80804640
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_lin_wakeUp_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_lin_wakeUp"
    VALUE
    0x80804642
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_memFlsCfgShr_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_memFlsCfgShr"
    VALUE
    0x80804644
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_memGetStatus_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_memGetStatus"
    VALUE
    0x80804646
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_memMarkBlock_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_memMarkBlock"
    VALUE
    0x80804648
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_memReadApi1Error_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_memReadApi1Error"
    VALUE
    0x8080464A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_memReadApi2Error_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_memReadApi2Error"
    VALUE
    0x8080464C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_memReadBlock_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_memReadBlock"
    VALUE
    0x8080464E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_memReadCalibInputError_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_memReadCalibInputError"
    VALUE
    0x80804650
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_memReadCalibOuputError_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_memReadCalibOuputError"
    VALUE
    0x80804652
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_memReadSystemError_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_memReadSystemError"
    VALUE
    0x80804654
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_memWriteBlock_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_memWriteBlock"
    VALUE
    0x80804656
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_moOV_FirstConstADC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_moOV_FirstConstADC"
    VALUE
    0x80804658
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_moOV_SecondConstADC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_moOV_SecondConstADC"
    VALUE
    0x8080465A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_moUV_FirstConstADC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_moUV_FirstConstADC"
    VALUE
    0x8080465C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_moUV_SecondConstADC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_moUV_SecondConstADC"
    VALUE
    0x8080465E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_INH_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_INH"
    VALUE
    0x80804660
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_INHLatch_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_INHLatch"
    VALUE
    0x80804662
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_adcPDD_fail_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_adcPDD_fail"
    VALUE
    0x80804664
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_memoryProtection_err_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_memoryProtection_err"
    VALUE
    0x80804666
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA02OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA02OC"
    VALUE
    0x80804668
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA02Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA02Unintended"
    VALUE
    0x8080466A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA03OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA03OC"
    VALUE
    0x8080466C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA03Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA03Unintended"
    VALUE
    0x8080466E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA04OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA04OC"
    VALUE
    0x80804670
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA04Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA04Unintended"
    VALUE
    0x80804672
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA05OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA05OC"
    VALUE
    0x80804674
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA05Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA05Unintended"
    VALUE
    0x80804676
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA07OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA07OC"
    VALUE
    0x80804678
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA07Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA07Unintended"
    VALUE
    0x8080467A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA08OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA08OC"
    VALUE
    0x8080467C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA08Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA08Unintended"
    VALUE
    0x8080467E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA09OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA09OC"
    VALUE
    0x80804680
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA09Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA09Unintended"
    VALUE
    0x80804682
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA10OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA10OC"
    VALUE
    0x80804684
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA10Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA10Unintended"
    VALUE
    0x80804686
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA17OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA17OC"
    VALUE
    0x80804688
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA17Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA17Unintended"
    VALUE
    0x8080468A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA18OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA18OC"
    VALUE
    0x8080468C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA18Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA18Unintended"
    VALUE
    0x8080468E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA19OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA19OC"
    VALUE
    0x80804690
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA19Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA19Unintended"
    VALUE
    0x80804692
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA20OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA20OC"
    VALUE
    0x80804694
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA20Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA20Unintended"
    VALUE
    0x80804696
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA31OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA31OC"
    VALUE
    0x80804698
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA31Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA31Unintended"
    VALUE
    0x8080469A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA32OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA32OC"
    VALUE
    0x8080469C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA32Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA32Unintended"
    VALUE
    0x8080469E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA33OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA33OC"
    VALUE
    0x808046A0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA33Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA33Unintended"
    VALUE
    0x808046A2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA34OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA34OC"
    VALUE
    0x808046A4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA34Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA34Unintended"
    VALUE
    0x808046A6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA35OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA35OC"
    VALUE
    0x808046A8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA35Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA35Unintended"
    VALUE
    0x808046AA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA46OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA46OC"
    VALUE
    0x808046AC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA46Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA46Unintended"
    VALUE
    0x808046AE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA47OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA47OC"
    VALUE
    0x808046B0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA47Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA47Unintended"
    VALUE
    0x808046B2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA48OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA48OC"
    VALUE
    0x808046B4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA48Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA48Unintended"
    VALUE
    0x808046B6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA51OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA51OC"
    VALUE
    0x808046B8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA51Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA51Unintended"
    VALUE
    0x808046BA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA52OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA52OC"
    VALUE
    0x808046BC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA52Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA52Unintended"
    VALUE
    0x808046BE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA53OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA53OC"
    VALUE
    0x808046C0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA53Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA53Unintended"
    VALUE
    0x808046C2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA54OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA54OC"
    VALUE
    0x808046C4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA54Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA54Unintended"
    VALUE
    0x808046C6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outAov_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outAov"
    VALUE
    0x808046C8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outAovCfg_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outAovCfg"
    VALUE
    0x808046CA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outAovCfgPI_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outAovCfgPI"
    VALUE
    0x808046CC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outAovGetStatus_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outAovGetStatus"
    VALUE
    0x808046CE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outAovGetVoltage_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outAovGetVoltage"
    VALUE
    0x808046D0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outAovResetError_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outAovResetError"
    VALUE
    0x808046D2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outDo_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outDo"
    VALUE
    0x808046D4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outDoCfgPwrLs_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outDoCfgPwrLs"
    VALUE
    0x808046D6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outDoDisable_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outDoDisable"
    VALUE
    0x808046D8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outDoGetCurrent_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outDoGetCurrent"
    VALUE
    0x808046DA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outDoGetStatus_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outDoGetStatus"
    VALUE
    0x808046DC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outDoResetError_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outDoResetError"
    VALUE
    0x808046DE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK07OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK07OC"
    VALUE
    0x808046E0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK07Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK07Unintended"
    VALUE
    0x808046E2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK08OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK08OC"
    VALUE
    0x808046E4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK08Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK08Unintended"
    VALUE
    0x808046E6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK09OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK09OC"
    VALUE
    0x808046E8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK09Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK09Unintended"
    VALUE
    0x808046EA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK12OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK12OC"
    VALUE
    0x808046EC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK12Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK12Unintended"
    VALUE
    0x808046EE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK13OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK13OC"
    VALUE
    0x808046F0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK13Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK13Unintended"
    VALUE
    0x808046F2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK14OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK14OC"
    VALUE
    0x808046F4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK14Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK14Unintended"
    VALUE
    0x808046F6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK15OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK15OC"
    VALUE
    0x808046F8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK15Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK15Unintended"
    VALUE
    0x808046FA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK16OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK16OC"
    VALUE
    0x808046FC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK16Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK16Unintended"
    VALUE
    0x808046FE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK17OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK17OC"
    VALUE
    0x80804700
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK17Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK17Unintended"
    VALUE
    0x80804702
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK29OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK29OC"
    VALUE
    0x80804704
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK29Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK29Unintended"
    VALUE
    0x80804706
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK51OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK51OC"
    VALUE
    0x80804708
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK51Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK51Unintended"
    VALUE
    0x8080470A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK73OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK73OC"
    VALUE
    0x8080470C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK73Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK73Unintended"
    VALUE
    0x8080470E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outPo_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outPo"
    VALUE
    0x80804710
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outPoCfg_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outPoCfg"
    VALUE
    0x80804712
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outPoCfgPeriod_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outPoCfgPeriod"
    VALUE
    0x80804714
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outPoCfgPwrLs_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outPoCfgPwrLs"
    VALUE
    0x80804716
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outPoDisable_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outPoDisable"
    VALUE
    0x80804718
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outPoGetCurrent_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outPoGetCurrent"
    VALUE
    0x8080471A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outPoGetStatus_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outPoGetStatus"
    VALUE
    0x8080471C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outPoResetError_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outPoResetError"
    VALUE
    0x8080471E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outPoc_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outPoc"
    VALUE
    0x80804720
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outPocCfg_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outPocCfg"
    VALUE
    0x80804722
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outPocCfgDither_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outPocCfgDither"
    VALUE
    0x80804724
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outPocCfgPI_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outPocCfgPI"
    VALUE
    0x80804726
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outPod_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outPod"
    VALUE
    0x80804728
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outPodCfg_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outPodCfg"
    VALUE
    0x8080472A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outPodCfgPeriod_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outPodCfgPeriod"
    VALUE
    0x8080472C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_rsmFfiApiCallErr_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_rsmFfiApiCallErr"
    VALUE
    0x8080472E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safout_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safout"
    VALUE
    0x80804730
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutCfg_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutCfg"
    VALUE
    0x80804732
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl1_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl1"
    VALUE
    0x80804734
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl10_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl10"
    VALUE
    0x80804736
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl10Dev_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl10Dev"
    VALUE
    0x80804738
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl10OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl10OR"
    VALUE
    0x8080473A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl11_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl11"
    VALUE
    0x8080473C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl11Dev_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl11Dev"
    VALUE
    0x8080473E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl11OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl11OR"
    VALUE
    0x80804740
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl12_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl12"
    VALUE
    0x80804742
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl12Dev_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl12Dev"
    VALUE
    0x80804744
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl12OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl12OR"
    VALUE
    0x80804746
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl13_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl13"
    VALUE
    0x80804748
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl13Dev_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl13Dev"
    VALUE
    0x8080474A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl13OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl13OR"
    VALUE
    0x8080474C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl14_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl14"
    VALUE
    0x8080474E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl14Dev_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl14Dev"
    VALUE
    0x80804750
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl14OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl14OR"
    VALUE
    0x80804752
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl15_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl15"
    VALUE
    0x80804754
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl15Dev_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl15Dev"
    VALUE
    0x80804756
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl15OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl15OR"
    VALUE
    0x80804758
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl16_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl16"
    VALUE
    0x8080475A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl16Dev_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl16Dev"
    VALUE
    0x8080475C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl16OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl16OR"
    VALUE
    0x8080475E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl17_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl17"
    VALUE
    0x80804760
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl17Dev_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl17Dev"
    VALUE
    0x80804762
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl17OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl17OR"
    VALUE
    0x80804764
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl18_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl18"
    VALUE
    0x80804766
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl18Dev_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl18Dev"
    VALUE
    0x80804768
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl18OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl18OR"
    VALUE
    0x8080476A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl1Dev_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl1Dev"
    VALUE
    0x8080476C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl1OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl1OR"
    VALUE
    0x8080476E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl2_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl2"
    VALUE
    0x80804770
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl2Dev_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl2Dev"
    VALUE
    0x80804772
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl2OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl2OR"
    VALUE
    0x80804774
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl3_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl3"
    VALUE
    0x80804776
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl3Dev_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl3Dev"
    VALUE
    0x80804778
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl3OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl3OR"
    VALUE
    0x8080477A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl4_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl4"
    VALUE
    0x8080477C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl4Dev_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl4Dev"
    VALUE
    0x8080477E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl4OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl4OR"
    VALUE
    0x80804780
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl5_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl5"
    VALUE
    0x80804782
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl5Dev_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl5Dev"
    VALUE
    0x80804784
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl5OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl5OR"
    VALUE
    0x80804786
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl6_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl6"
    VALUE
    0x80804788
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl6Dev_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl6Dev"
    VALUE
    0x8080478A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl6OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl6OR"
    VALUE
    0x8080478C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl7_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl7"
    VALUE
    0x8080478E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl7Dev_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl7Dev"
    VALUE
    0x80804790
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl7OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl7OR"
    VALUE
    0x80804792
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl8_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl8"
    VALUE
    0x80804794
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl8Dev_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl8Dev"
    VALUE
    0x80804796
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl8OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl8OR"
    VALUE
    0x80804798
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl9_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl9"
    VALUE
    0x8080479A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl9Dev_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl9Dev"
    VALUE
    0x8080479C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl9OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl9OR"
    VALUE
    0x8080479E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutDevError_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutDevError"
    VALUE
    0x808047A0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutGetStatus_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutGetStatus"
    VALUE
    0x808047A2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutIgnoreError_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutIgnoreError"
    VALUE
    0x808047A4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutResetError_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutResetError"
    VALUE
    0x808047A6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutUnlock_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutUnlock"
    VALUE
    0x808047A8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safout_cfgDiag_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safout_cfgDiag"
    VALUE
    0x808047AA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_secAccessDenied_RC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_secAccessDenied_RC"
    VALUE
    0x808047AC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_secAccessDenied_WDBI_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_secAccessDenied_WDBI"
    VALUE
    0x808047AE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_secEvalRespKey_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_secEvalRespKey"
    VALUE
    0x808047B0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_secFlashingFailure_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_secFlashingFailure"
    VALUE
    0x808047B2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_secGetLevel_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_secGetLevel"
    VALUE
    0x808047B4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_secGetRnd_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_secGetRnd"
    VALUE
    0x808047B6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_secGetSeed_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_secGetSeed"
    VALUE
    0x808047B8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_secInvalidPassword_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_secInvalidPassword"
    VALUE
    0x808047BA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_secIsRequestAllowed_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_secIsRequestAllowed"
    VALUE
    0x808047BC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_secResetLevel_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_secResetLevel"
    VALUE
    0x808047BE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_secSaveSecret_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_secSaveSecret"
    VALUE
    0x808047C0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_secSetLevel_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_secSetLevel"
    VALUE
    0x808047C2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_sysAit_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_sysAit"
    VALUE
    0x808047C4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_sysAiv_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_sysAiv"
    VALUE
    0x808047C6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_sysDi_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_sysDi"
    VALUE
    0x808047C8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_sysDo_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_sysDo"
    VALUE
    0x808047CA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_sysGetVss_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_sysGetVss"
    VALUE
    0x808047CC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_sysInit_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_sysInit"
    VALUE
    0x808047CE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_sysOperHrIntegrityErr_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_sysOperHrIntegrityErr"
    VALUE
    0x808047D0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_sysOperHrsSaturated_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_sysOperHrsSaturated"
    VALUE
    0x808047D2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_sysSetVss_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_sysSetVss"
    VALUE
    0x808047D4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_sys_coreload_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_sys_coreload"
    VALUE
    0x808047D6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_sys_taskload_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_sys_taskload"
    VALUE
    0x808047D8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_OV_VSS1_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_OV_VSS1"
    VALUE
    0x808047DA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_OV_VSS2_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_OV_VSS2"
    VALUE
    0x808047DC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_UV_VSS1_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_UV_VSS1"
    VALUE
    0x808047DE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_UV_VSS2_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_UV_VSS2"
    VALUE
    0x808047E0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_CANSM_E_BUS_OFF_NETWORK_0_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_CANSM_E_BUS_OFF_NETWORK_0"
    VALUE
    0x808047E2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_CANSM_E_BUS_OFF_NETWORK_1_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_CANSM_E_BUS_OFF_NETWORK_1"
    VALUE
    0x808047E4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_CANSM_E_BUS_OFF_NETWORK_2_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_CANSM_E_BUS_OFF_NETWORK_2"
    VALUE
    0x808047E6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_CANSM_E_BUS_OFF_NETWORK_3_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_CANSM_E_BUS_OFF_NETWORK_3"
    VALUE
    0x808047E8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_CANTRCV_E_NO_TRCV_CONTROL_0_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_CANTRCV_E_NO_TRCV_CONTROL_0"
    VALUE
    0x808047EA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_CAN_E_TIMEOUT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_CAN_E_TIMEOUT"
    VALUE
    0x808047EC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_COMM_E_NET_START_IND_CHANNEL_0_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_COMM_E_NET_START_IND_CHANNEL_0"
    VALUE
    0x808047EE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_COMM_E_NET_START_IND_CHANNEL_1_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_COMM_E_NET_START_IND_CHANNEL_1"
    VALUE
    0x808047F0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_COMM_E_NET_START_IND_CHANNEL_2_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_COMM_E_NET_START_IND_CHANNEL_2"
    VALUE
    0x808047F2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_COMM_E_NET_START_IND_CHANNEL_3_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_COMM_E_NET_START_IND_CHANNEL_3"
    VALUE
    0x808047F4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_COMM_E_NET_START_IND_CHANNEL_4_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_COMM_E_NET_START_IND_CHANNEL_4"
    VALUE
    0x808047F6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_COMM_E_NET_START_IND_CHANNEL_5_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_COMM_E_NET_START_IND_CHANNEL_5"
    VALUE
    0x808047F8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_LIN_E_TIMEOUT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_LIN_E_TIMEOUT"
    VALUE
    0x808047FA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rba_MultiStackTrace_Threshold_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rba_MultiStackTrace_Threshold"
    VALUE
    0x808047FC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_ETH_E_ACCESS_0_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_ETH_E_ACCESS_0"
    VALUE
    0x808047FE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_RBA_IOEXTLIB_KEEPALIVE_DRV_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_RBA_IOEXTLIB_KEEPALIVE_DRV"
    VALUE
    0x80804800
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_RBA_IOEXTLIB_KEEPALIVE_INI_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_RBA_IOEXTLIB_KEEPALIVE_INI"
    VALUE
    0x80804802
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rba_MRly_Diag_Stk_Event_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rba_MRly_Diag_Stk_Event"
    VALUE
    0x80804804
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rba_MemDiagExtd_MemReadSngErr_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rba_MemDiagExtd_MemReadSngErr"
    VALUE
    0x80804806
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rba_MemDiag_MemReadErr_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rba_MemDiag_MemReadErr"
    VALUE
    0x80804808
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rba_MemDiag_MemWrErr_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rba_MemDiag_MemWrErr"
    VALUE
    0x8080480A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rba_SyC_IrrSwOffTrigEngRun_Event_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rba_SyC_IrrSwOffTrigEngRun_Event"
    VALUE
    0x8080480C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rba_T15_Diag_ComInVld_Event_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rba_T15_Diag_ComInVld_Event"
    VALUE
    0x8080480E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rba_T15_Diag_ComOff_HwOn_Event_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rba_T15_Diag_ComOff_HwOn_Event"
    VALUE
    0x80804810
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rba_T15_Diag_ComOn_HwOff_Event_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rba_T15_Diag_ComOn_HwOff_Event"
    VALUE
    0x80804812
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM0_0_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_0"
    VALUE
    0x80804814
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM0_1_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_1"
    VALUE
    0x80804816
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM0_10_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_10"
    VALUE
    0x80804818
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM0_11_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_11"
    VALUE
    0x8080481A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM0_13_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_13"
    VALUE
    0x8080481C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM0_14_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_14"
    VALUE
    0x8080481E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM0_2_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_2"
    VALUE
    0x80804820
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM0_22_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_22"
    VALUE
    0x80804822
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM0_23_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_23"
    VALUE
    0x80804824
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM0_4_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_4"
    VALUE
    0x80804826
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM0_5_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_5"
    VALUE
    0x80804828
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM0_7_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_7"
    VALUE
    0x8080482A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM0_8_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_8"
    VALUE
    0x8080482C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM10_16_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM10_16"
    VALUE
    0x8080482E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM10_17_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM10_17"
    VALUE
    0x80804830
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM10_21_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM10_21"
    VALUE
    0x80804832
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM11_0_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_0"
    VALUE
    0x80804834
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM11_1_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_1"
    VALUE
    0x80804836
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM11_2_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_2"
    VALUE
    0x80804838
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM11_3_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_3"
    VALUE
    0x8080483A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM11_4_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_4"
    VALUE
    0x8080483C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM11_5_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_5"
    VALUE
    0x8080483E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM11_8_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_8"
    VALUE
    0x80804840
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM11_9_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_9"
    VALUE
    0x80804842
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM1_0_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_0"
    VALUE
    0x80804844
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM1_1_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_1"
    VALUE
    0x80804846
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM1_10_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_10"
    VALUE
    0x80804848
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM1_11_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_11"
    VALUE
    0x8080484A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM1_13_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_13"
    VALUE
    0x8080484C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM1_14_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_14"
    VALUE
    0x8080484E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM1_2_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_2"
    VALUE
    0x80804850
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM1_22_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_22"
    VALUE
    0x80804852
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM1_23_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_23"
    VALUE
    0x80804854
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM1_4_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_4"
    VALUE
    0x80804856
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM1_5_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_5"
    VALUE
    0x80804858
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM1_7_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_7"
    VALUE
    0x8080485A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM1_8_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_8"
    VALUE
    0x8080485C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM21_0_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM21_0"
    VALUE
    0x8080485E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM21_16_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM21_16"
    VALUE
    0x80804860
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM21_3_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM21_3"
    VALUE
    0x80804862
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM2_1_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_1"
    VALUE
    0x80804864
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM2_10_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_10"
    VALUE
    0x80804866
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM2_11_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_11"
    VALUE
    0x80804868
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM2_13_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_13"
    VALUE
    0x8080486A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM2_14_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_14"
    VALUE
    0x8080486C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM2_2_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_2"
    VALUE
    0x8080486E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM2_22_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_22"
    VALUE
    0x80804870
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM2_23_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_23"
    VALUE
    0x80804872
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM2_4_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_4"
    VALUE
    0x80804874
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM2_5_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_5"
    VALUE
    0x80804876
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM2_7_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_7"
    VALUE
    0x80804878
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM2_8_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_8"
    VALUE
    0x8080487A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM3_1_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_1"
    VALUE
    0x8080487C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM3_10_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_10"
    VALUE
    0x8080487E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM3_11_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_11"
    VALUE
    0x80804880
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM3_13_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_13"
    VALUE
    0x80804882
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM3_14_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_14"
    VALUE
    0x80804884
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM3_2_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_2"
    VALUE
    0x80804886
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM3_22_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_22"
    VALUE
    0x80804888
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM3_23_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_23"
    VALUE
    0x8080488A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM3_4_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_4"
    VALUE
    0x8080488C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM3_5_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_5"
    VALUE
    0x8080488E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM3_7_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_7"
    VALUE
    0x80804890
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM3_8_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_8"
    VALUE
    0x80804892
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM6_0_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_0"
    VALUE
    0x80804894
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM6_11_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_11"
    VALUE
    0x80804896
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM6_12_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_12"
    VALUE
    0x80804898
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM6_14_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_14"
    VALUE
    0x8080489A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM6_15_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_15"
    VALUE
    0x8080489C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM6_17_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_17"
    VALUE
    0x8080489E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM6_18_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_18"
    VALUE
    0x808048A0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM6_2_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_2"
    VALUE
    0x808048A2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM6_20_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_20"
    VALUE
    0x808048A4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM6_21_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_21"
    VALUE
    0x808048A6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM6_25_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_25"
    VALUE
    0x808048A8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM6_4_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_4"
    VALUE
    0x808048AA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM6_5_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_5"
    VALUE
    0x808048AC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM6_7_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_7"
    VALUE
    0x808048AE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM6_8_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_8"
    VALUE
    0x808048B0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM7_1_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_1"
    VALUE
    0x808048B2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM7_12_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_12"
    VALUE
    0x808048B4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM7_13_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_13"
    VALUE
    0x808048B6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM7_14_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_14"
    VALUE
    0x808048B8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM7_15_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_15"
    VALUE
    0x808048BA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM7_16_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_16"
    VALUE
    0x808048BC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM7_17_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_17"
    VALUE
    0x808048BE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM7_2_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_2"
    VALUE
    0x808048C0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM7_20_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_20"
    VALUE
    0x808048C2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM7_25_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_25"
    VALUE
    0x808048C4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM7_26_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_26"
    VALUE
    0x808048C6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM7_28_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_28"
    VALUE
    0x808048C8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM7_29_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_29"
    VALUE
    0x808048CA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM7_30_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_30"
    VALUE
    0x808048CC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM7_31_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_31"
    VALUE
    0x808048CE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM8_0_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_0"
    VALUE
    0x808048D0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM8_1_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_1"
    VALUE
    0x808048D2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM8_10_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_10"
    VALUE
    0x808048D4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM8_11_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_11"
    VALUE
    0x808048D6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM8_12_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_12"
    VALUE
    0x808048D8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM8_13_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_13"
    VALUE
    0x808048DA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM8_16_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_16"
    VALUE
    0x808048DC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM8_18_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_18"
    VALUE
    0x808048DE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM8_2_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_2"
    VALUE
    0x808048E0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM8_3_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_3"
    VALUE
    0x808048E2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM8_30_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_30"
    VALUE
    0x808048E4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM8_31_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_31"
    VALUE
    0x808048E6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM8_4_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_4"
    VALUE
    0x808048E8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM9_0_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM9_0"
    VALUE
    0x808048EA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM9_1_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM9_1"
    VALUE
    0x808048EC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM9_15_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM9_15"
    VALUE
    0x808048EE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM9_3_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM9_3"
    VALUE
    0x808048F0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MoCSOPICO_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MoCSOPICO"
    VALUE
    0x808048F2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MoFVarPostBldSel_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MoFVarPostBldSel"
    VALUE
    0x808048F4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MoSysCtrlReIni_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MoSysCtrlReIni"
    VALUE
    0x808048F6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MoXEMMHwLTMCUFW_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MoXEMMHwLTMCUFW"
    VALUE
    0x808048F8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MoXEMMHwLTMonBIST_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MoXEMMHwLTMonBIST"
    VALUE
    0x808048FA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MoXEMMHwLTRegMonTest_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MoXEMMHwLTRegMonTest"
    VALUE
    0x808048FC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MoXEMMHwLTStbySMUAlvTest_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MoXEMMHwLTStbySMUAlvTest"
    VALUE
    0x808048FE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MoXEMMHwLTTempSens_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MoXEMMHwLTTempSens"
    VALUE
    0x80804900
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MoXEMMHwLTUCBCfg_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MoXEMMHwLTUCBCfg"
    VALUE
    0x80804902
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_OCWDAABEActv_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_OCWDAABEActv"
    VALUE
    0x80804904
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_OCWDACom_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_OCWDACom"
    VALUE
    0x80804906
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_OCWDAErrPin_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_OCWDAErrPin"
    VALUE
    0x80804908
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_SWReset_0_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_SWReset_0"
    VALUE
    0x8080490A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_SWReset_1_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_SWReset_1"
    VALUE
    0x8080490C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_SWReset_2_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_SWReset_2"
    VALUE
    0x8080490E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDebFault1_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDebFault1"
    VALUE
    0x80804910
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_Unused_C
    "J1939SPN specific trouble code / "
    VALUE
    0x80804918
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    READ_ONLY

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_TimeInRowDebFault_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_TimeInRowDebFault"
    VALUE
    0x8080491C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_EventInRowDebFault_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_EventInRowDebFault"
    VALUE
    0x80804920
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_DevLibBattUHi_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_DevLibBattUHi"
    VALUE
    0x80804924
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_DevLibBattULo_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_DevLibBattULo"
    VALUE
    0x80804928
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_TimeUpDownDebFault_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_TimeUpDownDebFault"
    VALUE
    0x8080492C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA13OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA13OR"
    VALUE
    0x80804930
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA13SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA13SCB"
    VALUE
    0x80804934
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA13SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA13SCG"
    VALUE
    0x80804938
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA14OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA14OR"
    VALUE
    0x8080493C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA14SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA14SCB"
    VALUE
    0x80804940
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA14SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA14SCG"
    VALUE
    0x80804944
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA21OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA21OR"
    VALUE
    0x80804948
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA21SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA21SCB"
    VALUE
    0x8080494C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA21SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA21SCG"
    VALUE
    0x80804950
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA22OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA22OR"
    VALUE
    0x80804954
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA22SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA22SCB"
    VALUE
    0x80804958
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA22SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA22SCG"
    VALUE
    0x8080495C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA23OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA23OR"
    VALUE
    0x80804960
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA23SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA23SCB"
    VALUE
    0x80804964
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA23SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA23SCG"
    VALUE
    0x80804968
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA24OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA24OR"
    VALUE
    0x8080496C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA24SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA24SCB"
    VALUE
    0x80804970
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA24SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA24SCG"
    VALUE
    0x80804974
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA25OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA25OR"
    VALUE
    0x80804978
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA25SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA25SCB"
    VALUE
    0x8080497C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA25SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA25SCG"
    VALUE
    0x80804980
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA26OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA26OR"
    VALUE
    0x80804984
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA26SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA26SCB"
    VALUE
    0x80804988
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA26SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA26SCG"
    VALUE
    0x8080498C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA27OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA27OR"
    VALUE
    0x80804990
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA27SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA27SCB"
    VALUE
    0x80804994
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA27SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA27SCG"
    VALUE
    0x80804998
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA28OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA28OR"
    VALUE
    0x8080499C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA28SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA28SCB"
    VALUE
    0x808049A0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA28SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA28SCG"
    VALUE
    0x808049A4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA29OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA29OR"
    VALUE
    0x808049A8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA29SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA29SCB"
    VALUE
    0x808049AC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA29SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA29SCG"
    VALUE
    0x808049B0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA36AicSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA36AicSCB"
    VALUE
    0x808049B4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA36AicSCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA36AicSCG"
    VALUE
    0x808049B8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA36OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA36OR"
    VALUE
    0x808049BC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA36SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA36SCB"
    VALUE
    0x808049C0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA36SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA36SCG"
    VALUE
    0x808049C4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA36ShuntSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA36ShuntSCB"
    VALUE
    0x808049C8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA37AicSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA37AicSCB"
    VALUE
    0x808049CC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA37AicSCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA37AicSCG"
    VALUE
    0x808049D0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA37OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA37OR"
    VALUE
    0x808049D4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA37SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA37SCB"
    VALUE
    0x808049D8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA37SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA37SCG"
    VALUE
    0x808049DC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA37ShuntSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA37ShuntSCB"
    VALUE
    0x808049E0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA38AicSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA38AicSCB"
    VALUE
    0x808049E4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA38AicSCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA38AicSCG"
    VALUE
    0x808049E8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA38OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA38OR"
    VALUE
    0x808049EC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA38SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA38SCB"
    VALUE
    0x808049F0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA38SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA38SCG"
    VALUE
    0x808049F4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA38ShuntSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA38ShuntSCB"
    VALUE
    0x808049F8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA39AicSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA39AicSCB"
    VALUE
    0x808049FC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA39AicSCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA39AicSCG"
    VALUE
    0x80804A00
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA39OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA39OR"
    VALUE
    0x80804A04
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA39SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA39SCB"
    VALUE
    0x80804A08
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA39SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA39SCG"
    VALUE
    0x80804A0C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA39ShuntSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA39ShuntSCB"
    VALUE
    0x80804A10
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA40OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA40OR"
    VALUE
    0x80804A14
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA40SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA40SCB"
    VALUE
    0x80804A18
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA40SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA40SCG"
    VALUE
    0x80804A1C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA41OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA41OR"
    VALUE
    0x80804A20
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA41SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA41SCB"
    VALUE
    0x80804A24
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA41SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA41SCG"
    VALUE
    0x80804A28
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA42OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA42OR"
    VALUE
    0x80804A2C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA42SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA42SCB"
    VALUE
    0x80804A30
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA42SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA42SCG"
    VALUE
    0x80804A34
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA43AicSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA43AicSCB"
    VALUE
    0x80804A38
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA43AicSCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA43AicSCG"
    VALUE
    0x80804A3C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA43OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA43OR"
    VALUE
    0x80804A40
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA43SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA43SCB"
    VALUE
    0x80804A44
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA43SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA43SCG"
    VALUE
    0x80804A48
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA43ShuntSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA43ShuntSCB"
    VALUE
    0x80804A4C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA44OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA44OL"
    VALUE
    0x80804A50
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA44SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA44SCB"
    VALUE
    0x80804A54
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA44SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA44SCG"
    VALUE
    0x80804A58
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA57OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA57OR"
    VALUE
    0x80804A5C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA57SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA57SCB"
    VALUE
    0x80804A60
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA57SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA57SCG"
    VALUE
    0x80804A64
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA59OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA59OL"
    VALUE
    0x80804A68
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA59SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA59SCB"
    VALUE
    0x80804A6C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA59SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA59SCG"
    VALUE
    0x80804A70
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK10OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK10OR"
    VALUE
    0x80804A74
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK10SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK10SCB"
    VALUE
    0x80804A78
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK10SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK10SCG"
    VALUE
    0x80804A7C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK11OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK11OR"
    VALUE
    0x80804A80
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK11SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK11SCB"
    VALUE
    0x80804A84
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK11SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK11SCG"
    VALUE
    0x80804A88
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK30AicSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK30AicSCB"
    VALUE
    0x80804A8C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK30AicSCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK30AicSCG"
    VALUE
    0x80804A90
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK30OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK30OR"
    VALUE
    0x80804A94
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK30SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK30SCB"
    VALUE
    0x80804A98
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK30SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK30SCG"
    VALUE
    0x80804A9C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK30ShuntSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK30ShuntSCB"
    VALUE
    0x80804AA0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK31OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK31OR"
    VALUE
    0x80804AA4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK31SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK31SCB"
    VALUE
    0x80804AA8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK31SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK31SCG"
    VALUE
    0x80804AAC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK32OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK32OR"
    VALUE
    0x80804AB0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK32SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK32SCB"
    VALUE
    0x80804AB4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK32SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK32SCG"
    VALUE
    0x80804AB8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK33OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK33OR"
    VALUE
    0x80804ABC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK33SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK33SCB"
    VALUE
    0x80804AC0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK33SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK33SCG"
    VALUE
    0x80804AC4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK34OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK34OR"
    VALUE
    0x80804AC8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK34SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK34SCB"
    VALUE
    0x80804ACC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK34SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK34SCG"
    VALUE
    0x80804AD0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK35OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK35OR"
    VALUE
    0x80804AD4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK35SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK35SCB"
    VALUE
    0x80804AD8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK35SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK35SCG"
    VALUE
    0x80804ADC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK36OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK36OR"
    VALUE
    0x80804AE0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK36SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK36SCB"
    VALUE
    0x80804AE4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK36SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK36SCG"
    VALUE
    0x80804AE8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK37AicSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK37AicSCB"
    VALUE
    0x80804AEC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK37AicSCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK37AicSCG"
    VALUE
    0x80804AF0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK37OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK37OR"
    VALUE
    0x80804AF4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK37SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK37SCB"
    VALUE
    0x80804AF8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK37SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK37SCG"
    VALUE
    0x80804AFC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK37ShuntSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK37ShuntSCB"
    VALUE
    0x80804B00
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK38AicSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK38AicSCB"
    VALUE
    0x80804B04
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK38AicSCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK38AicSCG"
    VALUE
    0x80804B08
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK38OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK38OR"
    VALUE
    0x80804B0C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK38SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK38SCB"
    VALUE
    0x80804B10
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK38SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK38SCG"
    VALUE
    0x80804B14
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK38ShuntSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK38ShuntSCB"
    VALUE
    0x80804B18
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK39AicSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK39AicSCB"
    VALUE
    0x80804B1C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK39AicSCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK39AicSCG"
    VALUE
    0x80804B20
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK39OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK39OR"
    VALUE
    0x80804B24
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK39SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK39SCB"
    VALUE
    0x80804B28
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK39SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK39SCG"
    VALUE
    0x80804B2C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK39ShuntSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK39ShuntSCB"
    VALUE
    0x80804B30
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK40AicSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK40AicSCB"
    VALUE
    0x80804B34
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK40AicSCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK40AicSCG"
    VALUE
    0x80804B38
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK40OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK40OR"
    VALUE
    0x80804B3C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK40SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK40SCB"
    VALUE
    0x80804B40
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK40SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK40SCG"
    VALUE
    0x80804B44
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK40ShuntSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK40ShuntSCB"
    VALUE
    0x80804B48
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK41AicSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK41AicSCB"
    VALUE
    0x80804B4C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK41AicSCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK41AicSCG"
    VALUE
    0x80804B50
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK41OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK41OR"
    VALUE
    0x80804B54
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK41SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK41SCB"
    VALUE
    0x80804B58
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK41SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK41SCG"
    VALUE
    0x80804B5C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK41ShuntSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK41ShuntSCB"
    VALUE
    0x80804B60
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK42AicSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK42AicSCB"
    VALUE
    0x80804B64
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK42AicSCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK42AicSCG"
    VALUE
    0x80804B68
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK42OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK42OR"
    VALUE
    0x80804B6C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK42SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK42SCB"
    VALUE
    0x80804B70
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK42SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK42SCG"
    VALUE
    0x80804B74
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK42ShuntSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK42ShuntSCB"
    VALUE
    0x80804B78
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK43OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK43OR"
    VALUE
    0x80804B7C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK43SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK43SCB"
    VALUE
    0x80804B80
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK43SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK43SCG"
    VALUE
    0x80804B84
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK44AicSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK44AicSCB"
    VALUE
    0x80804B88
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK44AicSCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK44AicSCG"
    VALUE
    0x80804B8C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK44OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK44OR"
    VALUE
    0x80804B90
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK44SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK44SCB"
    VALUE
    0x80804B94
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK44SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK44SCG"
    VALUE
    0x80804B98
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK44ShuntSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK44ShuntSCB"
    VALUE
    0x80804B9C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK45AicSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK45AicSCB"
    VALUE
    0x80804BA0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK45AicSCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK45AicSCG"
    VALUE
    0x80804BA4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK45OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK45OR"
    VALUE
    0x80804BA8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK45SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK45SCB"
    VALUE
    0x80804BAC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK45SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK45SCG"
    VALUE
    0x80804BB0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK45ShuntSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK45ShuntSCB"
    VALUE
    0x80804BB4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK52OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK52OR"
    VALUE
    0x80804BB8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK52SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK52SCB"
    VALUE
    0x80804BBC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK52SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK52SCG"
    VALUE
    0x80804BC0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK53OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK53OR"
    VALUE
    0x80804BC4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK53SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK53SCB"
    VALUE
    0x80804BC8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK53SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK53SCG"
    VALUE
    0x80804BCC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK54AicSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK54AicSCB"
    VALUE
    0x80804BD0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK54AicSCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK54AicSCG"
    VALUE
    0x80804BD4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK54OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK54OR"
    VALUE
    0x80804BD8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK54SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK54SCB"
    VALUE
    0x80804BDC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK54SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK54SCG"
    VALUE
    0x80804BE0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK54ShuntSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK54ShuntSCB"
    VALUE
    0x80804BE4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK55AicSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK55AicSCB"
    VALUE
    0x80804BE8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK55AicSCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK55AicSCG"
    VALUE
    0x80804BEC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK55OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK55OR"
    VALUE
    0x80804BF0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK55SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK55SCB"
    VALUE
    0x80804BF4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK55SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK55SCG"
    VALUE
    0x80804BF8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK55ShuntSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK55ShuntSCB"
    VALUE
    0x80804BFC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK56OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK56OR"
    VALUE
    0x80804C00
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK56SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK56SCB"
    VALUE
    0x80804C04
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK56SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK56SCG"
    VALUE
    0x80804C08
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK57OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK57OR"
    VALUE
    0x80804C0C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK57SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK57SCB"
    VALUE
    0x80804C10
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK57SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK57SCG"
    VALUE
    0x80804C14
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK58OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK58OR"
    VALUE
    0x80804C18
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK58SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK58SCB"
    VALUE
    0x80804C1C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK58SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK58SCG"
    VALUE
    0x80804C20
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK59OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK59OR"
    VALUE
    0x80804C24
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK59SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK59SCB"
    VALUE
    0x80804C28
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK59SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK59SCG"
    VALUE
    0x80804C2C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK60OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK60OR"
    VALUE
    0x80804C30
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK60SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK60SCB"
    VALUE
    0x80804C34
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK60SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK60SCG"
    VALUE
    0x80804C38
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK61AicSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK61AicSCB"
    VALUE
    0x80804C3C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK61AicSCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK61AicSCG"
    VALUE
    0x80804C40
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK61OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK61OR"
    VALUE
    0x80804C44
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK61SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK61SCB"
    VALUE
    0x80804C48
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK61SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK61SCG"
    VALUE
    0x80804C4C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK61ShuntSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK61ShuntSCB"
    VALUE
    0x80804C50
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK62OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK62OR"
    VALUE
    0x80804C54
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK62SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK62SCB"
    VALUE
    0x80804C58
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK62SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK62SCG"
    VALUE
    0x80804C5C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK63AicSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK63AicSCB"
    VALUE
    0x80804C60
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK63AicSCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK63AicSCG"
    VALUE
    0x80804C64
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK63OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK63OR"
    VALUE
    0x80804C68
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK63SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK63SCB"
    VALUE
    0x80804C6C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK63SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK63SCG"
    VALUE
    0x80804C70
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK63ShuntSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK63ShuntSCB"
    VALUE
    0x80804C74
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK64AicSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK64AicSCB"
    VALUE
    0x80804C78
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK64AicSCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK64AicSCG"
    VALUE
    0x80804C7C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK64OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK64OR"
    VALUE
    0x80804C80
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK64SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK64SCB"
    VALUE
    0x80804C84
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK64SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK64SCG"
    VALUE
    0x80804C88
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK64ShuntSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK64ShuntSCB"
    VALUE
    0x80804C8C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK65AicSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK65AicSCB"
    VALUE
    0x80804C90
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK65AicSCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK65AicSCG"
    VALUE
    0x80804C94
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK65OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK65OR"
    VALUE
    0x80804C98
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK65SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK65SCB"
    VALUE
    0x80804C9C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK65SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK65SCG"
    VALUE
    0x80804CA0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK65ShuntSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK65ShuntSCB"
    VALUE
    0x80804CA4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK74OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK74OR"
    VALUE
    0x80804CA8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK74SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK74SCB"
    VALUE
    0x80804CAC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK74SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK74SCG"
    VALUE
    0x80804CB0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK75OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK75OR"
    VALUE
    0x80804CB4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK75SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK75SCB"
    VALUE
    0x80804CB8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK75SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK75SCG"
    VALUE
    0x80804CBC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK76OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK76OR"
    VALUE
    0x80804CC0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK76SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK76SCB"
    VALUE
    0x80804CC4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK76SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK76SCG"
    VALUE
    0x80804CC8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK77OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK77OR"
    VALUE
    0x80804CCC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK77SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK77SCB"
    VALUE
    0x80804CD0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK77SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK77SCG"
    VALUE
    0x80804CD4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK78OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK78OR"
    VALUE
    0x80804CD8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK78SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK78SCB"
    VALUE
    0x80804CDC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK78SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK78SCG"
    VALUE
    0x80804CE0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_DvUBAT_FWs_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_DvUBAT_FWs"
    VALUE
    0x80804CE4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_OVErr_VPR6_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_OVErr_VPR6"
    VALUE
    0x80804CE8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_OVWarn_VPR6_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_OVWarn_VPR6"
    VALUE
    0x80804CEC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3"
    VALUE
    0x80804CF0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2"
    VALUE
    0x80804CF4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_OV_UBAT_MON_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_OV_UBAT_MON"
    VALUE
    0x80804CF8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_OV_UBRM24_FLEXIN_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_OV_UBRM24_FLEXIN"
    VALUE
    0x80804CFC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_OV_UBRM24_LOADS_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_OV_UBRM24_LOADS"
    VALUE
    0x80804D00
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_OV_UBRM24_MON_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_OV_UBRM24_MON"
    VALUE
    0x80804D04
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_OV_VDD5_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_OV_VDD5"
    VALUE
    0x80804D08
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_OV_VDD5_IN_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_OV_VDD5_IN"
    VALUE
    0x80804D0C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_OV_VPR6_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_OV_VPR6"
    VALUE
    0x80804D10
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_OV_VSS3_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_OV_VSS3"
    VALUE
    0x80804D14
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_OV_VSS4_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_OV_VSS4"
    VALUE
    0x80804D18
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_Temp1_HTErr_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_Temp1_HTErr"
    VALUE
    0x80804D1C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_Temp1_HTWarn_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_Temp1_HTWarn"
    VALUE
    0x80804D20
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_Temp2_HTErr_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_Temp2_HTErr"
    VALUE
    0x80804D24
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_Temp2_HTWarn_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_Temp2_HTWarn"
    VALUE
    0x80804D28
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3"
    VALUE
    0x80804D2C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2"
    VALUE
    0x80804D30
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_UV_VDD5_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_UV_VDD5"
    VALUE
    0x80804D34
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_UV_VDD5_IN_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_UV_VDD5_IN"
    VALUE
    0x80804D38
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_UV_VPR6_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_UV_VPR6"
    VALUE
    0x80804D3C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_UV_VSS3_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_UV_VSS3"
    VALUE
    0x80804D40
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_UV_VSS4_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_UV_VSS4"
    VALUE
    0x80804D44
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA01OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA01OL"
    VALUE
    0x80804D48
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA01OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA01OT"
    VALUE
    0x80804D4C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA01SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA01SCB"
    VALUE
    0x80804D50
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA01SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA01SCG"
    VALUE
    0x80804D54
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA02OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA02OL"
    VALUE
    0x80804D58
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA02OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA02OR"
    VALUE
    0x80804D5C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA02OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA02OT"
    VALUE
    0x80804D60
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA02SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA02SCB"
    VALUE
    0x80804D64
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA02SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA02SCG"
    VALUE
    0x80804D68
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA03OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA03OL"
    VALUE
    0x80804D6C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA03OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA03OT"
    VALUE
    0x80804D70
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA03SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA03SCB"
    VALUE
    0x80804D74
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA03SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA03SCG"
    VALUE
    0x80804D78
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA04OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA04OL"
    VALUE
    0x80804D7C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA04OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA04OT"
    VALUE
    0x80804D80
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA04SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA04SCB"
    VALUE
    0x80804D84
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA04SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA04SCG"
    VALUE
    0x80804D88
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA05OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA05OL"
    VALUE
    0x80804D8C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA05OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA05OR"
    VALUE
    0x80804D90
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA05OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA05OT"
    VALUE
    0x80804D94
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA05SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA05SCB"
    VALUE
    0x80804D98
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA05SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA05SCG"
    VALUE
    0x80804D9C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA06OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA06OL"
    VALUE
    0x80804DA0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA06OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA06OR"
    VALUE
    0x80804DA4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA06OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA06OT"
    VALUE
    0x80804DA8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA06SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA06SCB"
    VALUE
    0x80804DAC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA06SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA06SCG"
    VALUE
    0x80804DB0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA07OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA07OL"
    VALUE
    0x80804DB4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA07OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA07OT"
    VALUE
    0x80804DB8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA07SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA07SCB"
    VALUE
    0x80804DBC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA07SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA07SCG"
    VALUE
    0x80804DC0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA08OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA08OL"
    VALUE
    0x80804DC4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA08OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA08OT"
    VALUE
    0x80804DC8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA08SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA08SCB"
    VALUE
    0x80804DCC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA08SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA08SCG"
    VALUE
    0x80804DD0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA09OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA09OL"
    VALUE
    0x80804DD4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA09OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA09OR"
    VALUE
    0x80804DD8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA09OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA09OT"
    VALUE
    0x80804DDC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA09SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA09SCB"
    VALUE
    0x80804DE0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA09SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA09SCG"
    VALUE
    0x80804DE4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA10OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA10OL"
    VALUE
    0x80804DE8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA10OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA10OT"
    VALUE
    0x80804DEC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA10SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA10SCB"
    VALUE
    0x80804DF0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA10SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA10SCG"
    VALUE
    0x80804DF4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA11OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA11OL"
    VALUE
    0x80804DF8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA11OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA11OT"
    VALUE
    0x80804DFC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA11SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA11SCB"
    VALUE
    0x80804E00
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA11SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA11SCG"
    VALUE
    0x80804E04
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA12OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA12OR"
    VALUE
    0x80804E08
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA12SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA12SCB"
    VALUE
    0x80804E0C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA12SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA12SCG"
    VALUE
    0x80804E10
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA16OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA16OL"
    VALUE
    0x80804E14
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA16OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA16OT"
    VALUE
    0x80804E18
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA16SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA16SCB"
    VALUE
    0x80804E1C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA16SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA16SCG"
    VALUE
    0x80804E20
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA17OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA17OL"
    VALUE
    0x80804E24
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA17OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA17OR"
    VALUE
    0x80804E28
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA17OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA17OT"
    VALUE
    0x80804E2C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA17SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA17SCB"
    VALUE
    0x80804E30
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA17SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA17SCG"
    VALUE
    0x80804E34
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA18OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA18OL"
    VALUE
    0x80804E38
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA18OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA18OT"
    VALUE
    0x80804E3C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA18SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA18SCB"
    VALUE
    0x80804E40
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA18SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA18SCG"
    VALUE
    0x80804E44
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA19OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA19OL"
    VALUE
    0x80804E48
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA19OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA19OR"
    VALUE
    0x80804E4C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA19OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA19OT"
    VALUE
    0x80804E50
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA19SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA19SCB"
    VALUE
    0x80804E54
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA19SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA19SCG"
    VALUE
    0x80804E58
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA20OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA20OL"
    VALUE
    0x80804E5C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA20OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA20OR"
    VALUE
    0x80804E60
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA20OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA20OT"
    VALUE
    0x80804E64
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA20SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA20SCB"
    VALUE
    0x80804E68
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA20SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA20SCG"
    VALUE
    0x80804E6C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA31OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA31OL"
    VALUE
    0x80804E70
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA31OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA31OR"
    VALUE
    0x80804E74
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA31OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA31OT"
    VALUE
    0x80804E78
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA31SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA31SCB"
    VALUE
    0x80804E7C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA31SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA31SCG"
    VALUE
    0x80804E80
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA32OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA32OL"
    VALUE
    0x80804E84
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA32OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA32OR"
    VALUE
    0x80804E88
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA32OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA32OT"
    VALUE
    0x80804E8C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA32SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA32SCB"
    VALUE
    0x80804E90
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA32SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA32SCG"
    VALUE
    0x80804E94
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA33OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA33OL"
    VALUE
    0x80804E98
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA33OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA33OR"
    VALUE
    0x80804E9C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA33OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA33OT"
    VALUE
    0x80804EA0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA33SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA33SCB"
    VALUE
    0x80804EA4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA33SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA33SCG"
    VALUE
    0x80804EA8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA34OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA34OL"
    VALUE
    0x80804EAC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA34OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA34OR"
    VALUE
    0x80804EB0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA34OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA34OT"
    VALUE
    0x80804EB4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA34SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA34SCB"
    VALUE
    0x80804EB8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA34SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA34SCG"
    VALUE
    0x80804EBC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA35OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA35OL"
    VALUE
    0x80804EC0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA35OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA35OR"
    VALUE
    0x80804EC4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA35OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA35OT"
    VALUE
    0x80804EC8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA35SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA35SCB"
    VALUE
    0x80804ECC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA35SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA35SCG"
    VALUE
    0x80804ED0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA46OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA46OL"
    VALUE
    0x80804ED4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA46OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA46OR"
    VALUE
    0x80804ED8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA46OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA46OT"
    VALUE
    0x80804EDC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA46SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA46SCB"
    VALUE
    0x80804EE0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA46SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA46SCG"
    VALUE
    0x80804EE4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA47OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA47OL"
    VALUE
    0x80804EE8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA47OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA47OR"
    VALUE
    0x80804EEC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA47OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA47OT"
    VALUE
    0x80804EF0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA47SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA47SCB"
    VALUE
    0x80804EF4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA47SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA47SCG"
    VALUE
    0x80804EF8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA48OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA48OL"
    VALUE
    0x80804EFC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA48OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA48OR"
    VALUE
    0x80804F00
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA48OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA48OT"
    VALUE
    0x80804F04
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA48SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA48SCB"
    VALUE
    0x80804F08
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA48SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA48SCG"
    VALUE
    0x80804F0C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA49OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA49OL"
    VALUE
    0x80804F10
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA49OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA49OT"
    VALUE
    0x80804F14
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA49SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA49SCB"
    VALUE
    0x80804F18
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA49SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA49SCG"
    VALUE
    0x80804F1C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA50OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA50OL"
    VALUE
    0x80804F20
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA50OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA50OT"
    VALUE
    0x80804F24
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA50SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA50SCB"
    VALUE
    0x80804F28
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA50SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA50SCG"
    VALUE
    0x80804F2C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA51OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA51OL"
    VALUE
    0x80804F30
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA51OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA51OR"
    VALUE
    0x80804F34
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA51OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA51OT"
    VALUE
    0x80804F38
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA51SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA51SCB"
    VALUE
    0x80804F3C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA51SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA51SCG"
    VALUE
    0x80804F40
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA52OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA52OL"
    VALUE
    0x80804F44
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA52OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA52OR"
    VALUE
    0x80804F48
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA52OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA52OT"
    VALUE
    0x80804F4C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA52SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA52SCB"
    VALUE
    0x80804F50
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA52SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA52SCG"
    VALUE
    0x80804F54
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA53OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA53OL"
    VALUE
    0x80804F58
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA53OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA53OR"
    VALUE
    0x80804F5C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA53OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA53OT"
    VALUE
    0x80804F60
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA53SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA53SCB"
    VALUE
    0x80804F64
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA53SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA53SCG"
    VALUE
    0x80804F68
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA54OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA54OL"
    VALUE
    0x80804F6C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA54OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA54OR"
    VALUE
    0x80804F70
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA54OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA54OT"
    VALUE
    0x80804F74
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA54SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA54SCB"
    VALUE
    0x80804F78
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA54SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA54SCG"
    VALUE
    0x80804F7C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA55OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA55OL"
    VALUE
    0x80804F80
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA55OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA55OT"
    VALUE
    0x80804F84
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA55SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA55SCB"
    VALUE
    0x80804F88
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA55SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA55SCG"
    VALUE
    0x80804F8C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA56OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA56OL"
    VALUE
    0x80804F90
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA56OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA56OT"
    VALUE
    0x80804F94
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA56SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA56SCB"
    VALUE
    0x80804F98
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA56SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA56SCG"
    VALUE
    0x80804F9C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA58OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA58OL"
    VALUE
    0x80804FA0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA58OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA58OT"
    VALUE
    0x80804FA4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA58SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA58SCB"
    VALUE
    0x80804FA8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA58SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA58SCG"
    VALUE
    0x80804FAC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK07OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK07OL"
    VALUE
    0x80804FB0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK07OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK07OR"
    VALUE
    0x80804FB4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK07OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK07OT"
    VALUE
    0x80804FB8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK07SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK07SCB"
    VALUE
    0x80804FBC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK07SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK07SCG"
    VALUE
    0x80804FC0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK08OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK08OL"
    VALUE
    0x80804FC4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK08OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK08OR"
    VALUE
    0x80804FC8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK08OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK08OT"
    VALUE
    0x80804FCC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK08SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK08SCB"
    VALUE
    0x80804FD0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK08SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK08SCG"
    VALUE
    0x80804FD4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK09OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK09OL"
    VALUE
    0x80804FD8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK09OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK09OR"
    VALUE
    0x80804FDC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK09OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK09OT"
    VALUE
    0x80804FE0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK09SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK09SCB"
    VALUE
    0x80804FE4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK09SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK09SCG"
    VALUE
    0x80804FE8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK12OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK12OL"
    VALUE
    0x80804FEC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK12OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK12OT"
    VALUE
    0x80804FF0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK12SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK12SCB"
    VALUE
    0x80804FF4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK12SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK12SCG"
    VALUE
    0x80804FF8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK13OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK13OL"
    VALUE
    0x80804FFC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK13OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK13OT"
    VALUE
    0x80805000
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK13SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK13SCB"
    VALUE
    0x80805004
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK13SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK13SCG"
    VALUE
    0x80805008
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK14OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK14OL"
    VALUE
    0x8080500C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK14OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK14OR"
    VALUE
    0x80805010
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK14OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK14OT"
    VALUE
    0x80805014
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK14SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK14SCB"
    VALUE
    0x80805018
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK14SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK14SCG"
    VALUE
    0x8080501C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK15OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK15OL"
    VALUE
    0x80805020
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK15OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK15OR"
    VALUE
    0x80805024
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK15OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK15OT"
    VALUE
    0x80805028
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK15SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK15SCB"
    VALUE
    0x8080502C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK15SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK15SCG"
    VALUE
    0x80805030
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK16OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK16OL"
    VALUE
    0x80805034
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK16OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK16OR"
    VALUE
    0x80805038
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK16OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK16OT"
    VALUE
    0x8080503C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK16SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK16SCB"
    VALUE
    0x80805040
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK16SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK16SCG"
    VALUE
    0x80805044
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK17OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK17OL"
    VALUE
    0x80805048
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK17OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK17OR"
    VALUE
    0x8080504C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK17OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK17OT"
    VALUE
    0x80805050
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK17SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK17SCB"
    VALUE
    0x80805054
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK17SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK17SCG"
    VALUE
    0x80805058
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK25OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK25OR"
    VALUE
    0x8080505C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK25SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK25SCB"
    VALUE
    0x80805060
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK25SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK25SCG"
    VALUE
    0x80805064
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK29OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK29OL"
    VALUE
    0x80805068
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK29OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK29OR"
    VALUE
    0x8080506C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK29OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK29OT"
    VALUE
    0x80805070
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK29SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK29SCB"
    VALUE
    0x80805074
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK29SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK29SCG"
    VALUE
    0x80805078
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK51OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK51OL"
    VALUE
    0x8080507C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK51OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK51OT"
    VALUE
    0x80805080
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK51SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK51SCB"
    VALUE
    0x80805084
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK51SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK51SCG"
    VALUE
    0x80805088
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK62OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK62OR"
    VALUE
    0x8080508C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK62SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK62SCB"
    VALUE
    0x80805090
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK62SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK62SCG"
    VALUE
    0x80805094
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK73OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK73OL"
    VALUE
    0x80805098
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK73OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK73OR"
    VALUE
    0x8080509C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK73OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK73OT"
    VALUE
    0x808050A0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK73SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK73SCB"
    VALUE
    0x808050A4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK73SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK73SCG"
    VALUE
    0x808050A8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK80OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK80OL"
    VALUE
    0x808050AC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK80OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK80OT"
    VALUE
    0x808050B0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK80SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK80SCB"
    VALUE
    0x808050B4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK80SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK80SCG"
    VALUE
    0x808050B8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK81OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK81OL"
    VALUE
    0x808050BC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK81OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK81OT"
    VALUE
    0x808050C0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK81SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK81SCB"
    VALUE
    0x808050C4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK81SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK81SCG"
    VALUE
    0x808050C8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK82OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK82OL"
    VALUE
    0x808050CC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK82OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK82OT"
    VALUE
    0x808050D0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK82SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK82SCB"
    VALUE
    0x808050D4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK82SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK82SCG"
    VALUE
    0x808050D8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK83OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK83OL"
    VALUE
    0x808050DC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK83OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK83OT"
    VALUE
    0x808050E0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK83SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK83SCB"
    VALUE
    0x808050E4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK83SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK83SCG"
    VALUE
    0x808050E8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK84OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK84OL"
    VALUE
    0x808050EC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK84OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK84OT"
    VALUE
    0x808050F0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK84SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK84SCB"
    VALUE
    0x808050F4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK84SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK84SCG"
    VALUE
    0x808050F8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK85OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK85OL"
    VALUE
    0x808050FC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK85OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK85OT"
    VALUE
    0x80805100
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK85SCB_C
