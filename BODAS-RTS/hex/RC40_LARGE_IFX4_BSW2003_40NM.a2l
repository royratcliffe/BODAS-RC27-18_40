
    DFES_DTCSAEFMI.DFC_rbr_outK15OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK15OC"
    VALUE
    0x80805BBB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK15Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK15Unintended"
    VALUE
    0x80805BBC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK16OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK16OC"
    VALUE
    0x80805BBD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK16Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK16Unintended"
    VALUE
    0x80805BBE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK17OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK17OC"
    VALUE
    0x80805BBF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK17Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK17Unintended"
    VALUE
    0x80805BC0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK29OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK29OC"
    VALUE
    0x80805BC1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK29Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK29Unintended"
    VALUE
    0x80805BC2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK51OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK51OC"
    VALUE
    0x80805BC3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK51Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK51Unintended"
    VALUE
    0x80805BC4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK73OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK73OC"
    VALUE
    0x80805BC5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK73Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK73Unintended"
    VALUE
    0x80805BC6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outPo_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outPo"
    VALUE
    0x80805BC7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outPoCfg_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outPoCfg"
    VALUE
    0x80805BC8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outPoCfgPeriod_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outPoCfgPeriod"
    VALUE
    0x80805BC9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outPoCfgPwrLs_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outPoCfgPwrLs"
    VALUE
    0x80805BCA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outPoDisable_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outPoDisable"
    VALUE
    0x80805BCB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outPoGetCurrent_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outPoGetCurrent"
    VALUE
    0x80805BCC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outPoGetStatus_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outPoGetStatus"
    VALUE
    0x80805BCD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outPoResetError_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outPoResetError"
    VALUE
    0x80805BCE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outPoc_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outPoc"
    VALUE
    0x80805BCF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outPocCfg_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outPocCfg"
    VALUE
    0x80805BD0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outPocCfgDither_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outPocCfgDither"
    VALUE
    0x80805BD1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outPocCfgPI_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outPocCfgPI"
    VALUE
    0x80805BD2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outPod_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outPod"
    VALUE
    0x80805BD3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outPodCfg_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outPodCfg"
    VALUE
    0x80805BD4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outPodCfgPeriod_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outPodCfgPeriod"
    VALUE
    0x80805BD5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_rsmFfiApiCallErr_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_rsmFfiApiCallErr"
    VALUE
    0x80805BD6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safout_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safout"
    VALUE
    0x80805BD7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutCfg_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutCfg"
    VALUE
    0x80805BD8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl1_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl1"
    VALUE
    0x80805BD9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl10_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl10"
    VALUE
    0x80805BDA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl10Dev_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl10Dev"
    VALUE
    0x80805BDB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl10OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl10OR"
    VALUE
    0x80805BDC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl11_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl11"
    VALUE
    0x80805BDD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl11Dev_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl11Dev"
    VALUE
    0x80805BDE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl11OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl11OR"
    VALUE
    0x80805BDF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl12_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl12"
    VALUE
    0x80805BE0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl12Dev_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl12Dev"
    VALUE
    0x80805BE1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl12OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl12OR"
    VALUE
    0x80805BE2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl13_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl13"
    VALUE
    0x80805BE3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl13Dev_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl13Dev"
    VALUE
    0x80805BE4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl13OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl13OR"
    VALUE
    0x80805BE5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl14_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl14"
    VALUE
    0x80805BE6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl14Dev_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl14Dev"
    VALUE
    0x80805BE7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl14OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl14OR"
    VALUE
    0x80805BE8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl15_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl15"
    VALUE
    0x80805BE9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl15Dev_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl15Dev"
    VALUE
    0x80805BEA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl15OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl15OR"
    VALUE
    0x80805BEB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl16_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl16"
    VALUE
    0x80805BEC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl16Dev_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl16Dev"
    VALUE
    0x80805BED
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl16OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl16OR"
    VALUE
    0x80805BEE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl17_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl17"
    VALUE
    0x80805BEF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl17Dev_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl17Dev"
    VALUE
    0x80805BF0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl17OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl17OR"
    VALUE
    0x80805BF1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl18_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl18"
    VALUE
    0x80805BF2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl18Dev_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl18Dev"
    VALUE
    0x80805BF3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl18OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl18OR"
    VALUE
    0x80805BF4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl1Dev_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl1Dev"
    VALUE
    0x80805BF5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl1OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl1OR"
    VALUE
    0x80805BF6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl2_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl2"
    VALUE
    0x80805BF7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl2Dev_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl2Dev"
    VALUE
    0x80805BF8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl2OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl2OR"
    VALUE
    0x80805BF9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl3_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl3"
    VALUE
    0x80805BFA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl3Dev_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl3Dev"
    VALUE
    0x80805BFB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl3OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl3OR"
    VALUE
    0x80805BFC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl4_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl4"
    VALUE
    0x80805BFD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl4Dev_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl4Dev"
    VALUE
    0x80805BFE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl4OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl4OR"
    VALUE
    0x80805BFF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl5_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl5"
    VALUE
    0x80805C00
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl5Dev_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl5Dev"
    VALUE
    0x80805C01
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl5OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl5OR"
    VALUE
    0x80805C02
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl6_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl6"
    VALUE
    0x80805C03
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl6Dev_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl6Dev"
    VALUE
    0x80805C04
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl6OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl6OR"
    VALUE
    0x80805C05
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl7_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl7"
    VALUE
    0x80805C06
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl7Dev_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl7Dev"
    VALUE
    0x80805C07
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl7OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl7OR"
    VALUE
    0x80805C08
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl8_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl8"
    VALUE
    0x80805C09
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl8Dev_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl8Dev"
    VALUE
    0x80805C0A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl8OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl8OR"
    VALUE
    0x80805C0B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl9_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl9"
    VALUE
    0x80805C0C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl9Dev_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl9Dev"
    VALUE
    0x80805C0D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl9OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl9OR"
    VALUE
    0x80805C0E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutDevError_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutDevError"
    VALUE
    0x80805C0F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutGetStatus_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutGetStatus"
    VALUE
    0x80805C10
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutIgnoreError_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutIgnoreError"
    VALUE
    0x80805C11
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutResetError_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutResetError"
    VALUE
    0x80805C12
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutUnlock_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutUnlock"
    VALUE
    0x80805C13
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safout_cfgDiag_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safout_cfgDiag"
    VALUE
    0x80805C14
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_secAccessDenied_RC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_secAccessDenied_RC"
    VALUE
    0x80805C15
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_secAccessDenied_WDBI_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_secAccessDenied_WDBI"
    VALUE
    0x80805C16
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_secEvalRespKey_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_secEvalRespKey"
    VALUE
    0x80805C17
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_secFlashingFailure_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_secFlashingFailure"
    VALUE
    0x80805C18
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_secGetLevel_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_secGetLevel"
    VALUE
    0x80805C19
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_secGetRnd_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_secGetRnd"
    VALUE
    0x80805C1A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_secGetSeed_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_secGetSeed"
    VALUE
    0x80805C1B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_secInvalidPassword_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_secInvalidPassword"
    VALUE
    0x80805C1C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_secIsRequestAllowed_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_secIsRequestAllowed"
    VALUE
    0x80805C1D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_secResetLevel_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_secResetLevel"
    VALUE
    0x80805C1E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_secSaveSecret_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_secSaveSecret"
    VALUE
    0x80805C1F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_secSetLevel_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_secSetLevel"
    VALUE
    0x80805C20
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_sysAit_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_sysAit"
    VALUE
    0x80805C21
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_sysAiv_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_sysAiv"
    VALUE
    0x80805C22
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_sysDi_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_sysDi"
    VALUE
    0x80805C23
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_sysDo_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_sysDo"
    VALUE
    0x80805C24
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_sysGetVss_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_sysGetVss"
    VALUE
    0x80805C25
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_sysInit_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_sysInit"
    VALUE
    0x80805C26
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_sysOperHrIntegrityErr_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_sysOperHrIntegrityErr"
    VALUE
    0x80805C27
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_sysOperHrsSaturated_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_sysOperHrsSaturated"
    VALUE
    0x80805C28
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_sysSetVss_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_sysSetVss"
    VALUE
    0x80805C29
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_sys_coreload_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_sys_coreload"
    VALUE
    0x80805C2A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_sys_taskload_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_sys_taskload"
    VALUE
    0x80805C2B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_OV_VSS1_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_OV_VSS1"
    VALUE
    0x80805C2C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_OV_VSS2_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_OV_VSS2"
    VALUE
    0x80805C2D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_UV_VSS1_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_UV_VSS1"
    VALUE
    0x80805C2E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_UV_VSS2_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_UV_VSS2"
    VALUE
    0x80805C2F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_CANSM_E_BUS_OFF_NETWORK_0_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_CANSM_E_BUS_OFF_NETWORK_0"
    VALUE
    0x80805C30
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_CANSM_E_BUS_OFF_NETWORK_1_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_CANSM_E_BUS_OFF_NETWORK_1"
    VALUE
    0x80805C31
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_CANSM_E_BUS_OFF_NETWORK_2_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_CANSM_E_BUS_OFF_NETWORK_2"
    VALUE
    0x80805C32
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_CANSM_E_BUS_OFF_NETWORK_3_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_CANSM_E_BUS_OFF_NETWORK_3"
    VALUE
    0x80805C33
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_CANTRCV_E_NO_TRCV_CONTROL_0_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_CANTRCV_E_NO_TRCV_CONTROL_0"
    VALUE
    0x80805C34
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_CAN_E_TIMEOUT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_CAN_E_TIMEOUT"
    VALUE
    0x80805C35
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_COMM_E_NET_START_IND_CHANNEL_0_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_COMM_E_NET_START_IND_CHANNEL_0"
    VALUE
    0x80805C36
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_COMM_E_NET_START_IND_CHANNEL_1_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_COMM_E_NET_START_IND_CHANNEL_1"
    VALUE
    0x80805C37
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_COMM_E_NET_START_IND_CHANNEL_2_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_COMM_E_NET_START_IND_CHANNEL_2"
    VALUE
    0x80805C38
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_COMM_E_NET_START_IND_CHANNEL_3_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_COMM_E_NET_START_IND_CHANNEL_3"
    VALUE
    0x80805C39
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_COMM_E_NET_START_IND_CHANNEL_4_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_COMM_E_NET_START_IND_CHANNEL_4"
    VALUE
    0x80805C3A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_COMM_E_NET_START_IND_CHANNEL_5_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_COMM_E_NET_START_IND_CHANNEL_5"
    VALUE
    0x80805C3B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_LIN_E_TIMEOUT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_LIN_E_TIMEOUT"
    VALUE
    0x80805C3C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rba_MultiStackTrace_Threshold_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rba_MultiStackTrace_Threshold"
    VALUE
    0x80805C3D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_ETH_E_ACCESS_0_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_ETH_E_ACCESS_0"
    VALUE
    0x80805C3E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_RBA_IOEXTLIB_KEEPALIVE_DRV_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_RBA_IOEXTLIB_KEEPALIVE_DRV"
    VALUE
    0x80805C3F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_RBA_IOEXTLIB_KEEPALIVE_INI_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_RBA_IOEXTLIB_KEEPALIVE_INI"
    VALUE
    0x80805C40
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rba_MRly_Diag_Stk_Event_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rba_MRly_Diag_Stk_Event"
    VALUE
    0x80805C41
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rba_MemDiagExtd_MemReadSngErr_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rba_MemDiagExtd_MemReadSngErr"
    VALUE
    0x80805C42
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rba_MemDiag_MemReadErr_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rba_MemDiag_MemReadErr"
    VALUE
    0x80805C43
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rba_MemDiag_MemWrErr_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rba_MemDiag_MemWrErr"
    VALUE
    0x80805C44
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rba_SyC_IrrSwOffTrigEngRun_Event_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rba_SyC_IrrSwOffTrigEngRun_Event"
    VALUE
    0x80805C45
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rba_T15_Diag_ComInVld_Event_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rba_T15_Diag_ComInVld_Event"
    VALUE
    0x80805C46
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rba_T15_Diag_ComOff_HwOn_Event_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rba_T15_Diag_ComOff_HwOn_Event"
    VALUE
    0x80805C47
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rba_T15_Diag_ComOn_HwOff_Event_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rba_T15_Diag_ComOn_HwOff_Event"
    VALUE
    0x80805C48
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM0_0_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_0"
    VALUE
    0x80805C49
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM0_1_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_1"
    VALUE
    0x80805C4A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM0_10_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_10"
    VALUE
    0x80805C4B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM0_11_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_11"
    VALUE
    0x80805C4C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM0_13_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_13"
    VALUE
    0x80805C4D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM0_14_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_14"
    VALUE
    0x80805C4E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM0_2_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_2"
    VALUE
    0x80805C4F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM0_22_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_22"
    VALUE
    0x80805C50
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM0_23_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_23"
    VALUE
    0x80805C51
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM0_4_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_4"
    VALUE
    0x80805C52
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM0_5_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_5"
    VALUE
    0x80805C53
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM0_7_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_7"
    VALUE
    0x80805C54
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM0_8_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_8"
    VALUE
    0x80805C55
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM10_16_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM10_16"
    VALUE
    0x80805C56
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM10_17_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM10_17"
    VALUE
    0x80805C57
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM10_21_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM10_21"
    VALUE
    0x80805C58
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM11_0_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_0"
    VALUE
    0x80805C59
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM11_1_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_1"
    VALUE
    0x80805C5A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM11_2_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_2"
    VALUE
    0x80805C5B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM11_3_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_3"
    VALUE
    0x80805C5C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM11_4_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_4"
    VALUE
    0x80805C5D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM11_5_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_5"
    VALUE
    0x80805C5E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM11_8_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_8"
    VALUE
    0x80805C5F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM11_9_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_9"
    VALUE
    0x80805C60
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM1_0_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_0"
    VALUE
    0x80805C61
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM1_1_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_1"
    VALUE
    0x80805C62
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM1_10_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_10"
    VALUE
    0x80805C63
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM1_11_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_11"
    VALUE
    0x80805C64
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM1_13_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_13"
    VALUE
    0x80805C65
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM1_14_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_14"
    VALUE
    0x80805C66
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM1_2_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_2"
    VALUE
    0x80805C67
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM1_22_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_22"
    VALUE
    0x80805C68
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM1_23_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_23"
    VALUE
    0x80805C69
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM1_4_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_4"
    VALUE
    0x80805C6A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM1_5_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_5"
    VALUE
    0x80805C6B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM1_7_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_7"
    VALUE
    0x80805C6C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM1_8_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_8"
    VALUE
    0x80805C6D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM21_0_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM21_0"
    VALUE
    0x80805C6E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM21_16_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM21_16"
    VALUE
    0x80805C6F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM21_3_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM21_3"
    VALUE
    0x80805C70
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM2_1_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_1"
    VALUE
    0x80805C71
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM2_10_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_10"
    VALUE
    0x80805C72
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM2_11_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_11"
    VALUE
    0x80805C73
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM2_13_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_13"
    VALUE
    0x80805C74
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM2_14_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_14"
    VALUE
    0x80805C75
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM2_2_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_2"
    VALUE
    0x80805C76
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM2_22_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_22"
    VALUE
    0x80805C77
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM2_23_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_23"
    VALUE
    0x80805C78
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM2_4_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_4"
    VALUE
    0x80805C79
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM2_5_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_5"
    VALUE
    0x80805C7A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM2_7_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_7"
    VALUE
    0x80805C7B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM2_8_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_8"
    VALUE
    0x80805C7C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM3_1_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_1"
    VALUE
    0x80805C7D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM3_10_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_10"
    VALUE
    0x80805C7E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM3_11_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_11"
    VALUE
    0x80805C7F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM3_13_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_13"
    VALUE
    0x80805C80
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM3_14_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_14"
    VALUE
    0x80805C81
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM3_2_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_2"
    VALUE
    0x80805C82
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM3_22_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_22"
    VALUE
    0x80805C83
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM3_23_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_23"
    VALUE
    0x80805C84
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM3_4_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_4"
    VALUE
    0x80805C85
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM3_5_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_5"
    VALUE
    0x80805C86
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM3_7_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_7"
    VALUE
    0x80805C87
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM3_8_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_8"
    VALUE
    0x80805C88
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM6_0_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_0"
    VALUE
    0x80805C89
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM6_11_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_11"
    VALUE
    0x80805C8A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM6_12_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_12"
    VALUE
    0x80805C8B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM6_14_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_14"
    VALUE
    0x80805C8C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM6_15_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_15"
    VALUE
    0x80805C8D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM6_17_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_17"
    VALUE
    0x80805C8E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM6_18_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_18"
    VALUE
    0x80805C8F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM6_2_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_2"
    VALUE
    0x80805C90
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM6_20_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_20"
    VALUE
    0x80805C91
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM6_21_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_21"
    VALUE
    0x80805C92
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM6_25_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_25"
    VALUE
    0x80805C93
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM6_4_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_4"
    VALUE
    0x80805C94
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM6_5_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_5"
    VALUE
    0x80805C95
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM6_7_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_7"
    VALUE
    0x80805C96
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM6_8_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_8"
    VALUE
    0x80805C97
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM7_1_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_1"
    VALUE
    0x80805C98
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM7_12_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_12"
    VALUE
    0x80805C99
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM7_13_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_13"
    VALUE
    0x80805C9A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM7_14_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_14"
    VALUE
    0x80805C9B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM7_15_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_15"
    VALUE
    0x80805C9C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM7_16_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_16"
    VALUE
    0x80805C9D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM7_17_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_17"
    VALUE
    0x80805C9E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM7_2_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_2"
    VALUE
    0x80805C9F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM7_20_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_20"
    VALUE
    0x80805CA0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM7_25_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_25"
    VALUE
    0x80805CA1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM7_26_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_26"
    VALUE
    0x80805CA2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM7_28_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_28"
    VALUE
    0x80805CA3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM7_29_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_29"
    VALUE
    0x80805CA4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM7_30_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_30"
    VALUE
    0x80805CA5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM7_31_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_31"
    VALUE
    0x80805CA6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM8_0_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_0"
    VALUE
    0x80805CA7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM8_1_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_1"
    VALUE
    0x80805CA8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM8_10_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_10"
    VALUE
    0x80805CA9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM8_11_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_11"
    VALUE
    0x80805CAA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM8_12_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_12"
    VALUE
    0x80805CAB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM8_13_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_13"
    VALUE
    0x80805CAC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM8_16_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_16"
    VALUE
    0x80805CAD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM8_18_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_18"
    VALUE
    0x80805CAE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM8_2_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_2"
    VALUE
    0x80805CAF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM8_3_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_3"
    VALUE
    0x80805CB0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM8_30_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_30"
    VALUE
    0x80805CB1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM8_31_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_31"
    VALUE
    0x80805CB2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM8_4_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_4"
    VALUE
    0x80805CB3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM9_0_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM9_0"
    VALUE
    0x80805CB4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM9_1_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM9_1"
    VALUE
    0x80805CB5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM9_15_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM9_15"
    VALUE
    0x80805CB6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM9_3_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM9_3"
    VALUE
    0x80805CB7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MoCSOPICO_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MoCSOPICO"
    VALUE
    0x80805CB8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MoFVarPostBldSel_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MoFVarPostBldSel"
    VALUE
    0x80805CB9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MoSysCtrlReIni_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MoSysCtrlReIni"
    VALUE
    0x80805CBA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MoXEMMHwLTMCUFW_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MoXEMMHwLTMCUFW"
    VALUE
    0x80805CBB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MoXEMMHwLTMonBIST_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MoXEMMHwLTMonBIST"
    VALUE
    0x80805CBC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MoXEMMHwLTRegMonTest_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MoXEMMHwLTRegMonTest"
    VALUE
    0x80805CBD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MoXEMMHwLTStbySMUAlvTest_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MoXEMMHwLTStbySMUAlvTest"
    VALUE
    0x80805CBE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MoXEMMHwLTTempSens_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MoXEMMHwLTTempSens"
    VALUE
    0x80805CBF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MoXEMMHwLTUCBCfg_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MoXEMMHwLTUCBCfg"
    VALUE
    0x80805CC0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_OCWDAABEActv_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_OCWDAABEActv"
    VALUE
    0x80805CC1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_OCWDACom_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_OCWDACom"
    VALUE
    0x80805CC2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_OCWDAErrPin_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_OCWDAErrPin"
    VALUE
    0x80805CC3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_SWReset_0_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_SWReset_0"
    VALUE
    0x80805CC4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_SWReset_1_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_SWReset_1"
    VALUE
    0x80805CC5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_SWReset_2_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_SWReset_2"
    VALUE
    0x80805CC6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDebFault1_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDebFault1"
    VALUE
    0x80805CC7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Env.xSet1_CA
    "set of signals per environment data / Signal selection for environment dataset 1"
    VAL_BLK
    0x80806898
    ValA_Wu16
    112.000000000
    Signals_IntSigNumVerb
    0.00
    112.000000000

    FORMAT "%13.9"
    
    MATRIX_DIM 6 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Env.xSet2_CA
    "set of signals per environment data / Signal selection for environment dataset 2"
    VAL_BLK
    0x808068A4
    ValA_Wu16
    112.000000000
    Signals_IntSigNumVerb
    0.00
    112.000000000

    FORMAT "%13.9"
    
    MATRIX_DIM 6 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Env.xSet3_CA
    "set of signals per environment data / Signal selection for environment dataset 3"
    VAL_BLK
    0x808068B0
    ValA_Wu16
    112.000000000
    Signals_IntSigNumVerb
    0.00
    112.000000000

    FORMAT "%13.9"
    
    MATRIX_DIM 6 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Env.xSet4_CA
    "set of signals per environment data / Signal selection for environment dataset 4"
    VAL_BLK
    0x808068BC
    ValA_Wu16
    112.000000000
    Signals_IntSigNumVerb
    0.00
    112.000000000

    FORMAT "%13.9"
    
    MATRIX_DIM 6 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Env.xSet5_CA
    "set of signals per environment data / Signal selection for environment dataset 5"
    VAL_BLK
    0x808068C8
    ValA_Wu16
    112.000000000
    Signals_IntSigNumVerb
    0.00
    112.000000000

    FORMAT "%13.9"
    
    MATRIX_DIM 6 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_Unused_C
    "used environment signals / "
    VALUE
    0x80805CC8
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    READ_ONLY

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_TimeInRowDebFault_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_TimeInRowDebFault"
    VALUE
    0x80805CC9
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_EventInRowDebFault_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_EventInRowDebFault"
    VALUE
    0x80805CCA
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_DevLibBattUHi_C
    "used environment signals / Reference to used environment condition set for check DFC_DevLibBattUHi"
    VALUE
    0x80805CCB
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_DevLibBattULo_C
    "used environment signals / Reference to used environment condition set for check DFC_DevLibBattULo"
    VALUE
    0x80805CCC
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_TimeUpDownDebFault_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_TimeUpDownDebFault"
    VALUE
    0x80805CCD
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA13OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA13OR"
    VALUE
    0x80805CCE
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA13SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA13SCB"
    VALUE
    0x80805CCF
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA13SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA13SCG"
    VALUE
    0x80805CD0
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA14OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA14OR"
    VALUE
    0x80805CD1
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA14SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA14SCB"
    VALUE
    0x80805CD2
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA14SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA14SCG"
    VALUE
    0x80805CD3
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA21OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA21OR"
    VALUE
    0x80805CD4
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA21SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA21SCB"
    VALUE
    0x80805CD5
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA21SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA21SCG"
    VALUE
    0x80805CD6
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA22OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA22OR"
    VALUE
    0x80805CD7
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA22SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA22SCB"
    VALUE
    0x80805CD8
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA22SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA22SCG"
    VALUE
    0x80805CD9
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA23OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA23OR"
    VALUE
    0x80805CDA
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA23SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA23SCB"
    VALUE
    0x80805CDB
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA23SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA23SCG"
    VALUE
    0x80805CDC
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA24OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA24OR"
    VALUE
    0x80805CDD
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA24SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA24SCB"
    VALUE
    0x80805CDE
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA24SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA24SCG"
    VALUE
    0x80805CDF
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA25OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA25OR"
    VALUE
    0x80805CE0
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA25SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA25SCB"
    VALUE
    0x80805CE1
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA25SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA25SCG"
    VALUE
    0x80805CE2
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA26OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA26OR"
    VALUE
    0x80805CE3
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA26SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA26SCB"
    VALUE
    0x80805CE4
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA26SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA26SCG"
    VALUE
    0x80805CE5
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA27OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA27OR"
    VALUE
    0x80805CE6
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA27SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA27SCB"
    VALUE
    0x80805CE7
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA27SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA27SCG"
    VALUE
    0x80805CE8
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA28OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA28OR"
    VALUE
    0x80805CE9
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA28SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA28SCB"
    VALUE
    0x80805CEA
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA28SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA28SCG"
    VALUE
    0x80805CEB
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA29OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA29OR"
    VALUE
    0x80805CEC
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA29SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA29SCB"
    VALUE
    0x80805CED
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA29SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA29SCG"
    VALUE
    0x80805CEE
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA36AicSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA36AicSCB"
    VALUE
    0x80805CEF
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA36AicSCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA36AicSCG"
    VALUE
    0x80805CF0
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA36OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA36OR"
    VALUE
    0x80805CF1
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA36SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA36SCB"
    VALUE
    0x80805CF2
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA36SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA36SCG"
    VALUE
    0x80805CF3
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA36ShuntSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA36ShuntSCB"
    VALUE
    0x80805CF4
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA37AicSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA37AicSCB"
    VALUE
    0x80805CF5
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA37AicSCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA37AicSCG"
    VALUE
    0x80805CF6
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA37OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA37OR"
    VALUE
    0x80805CF7
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA37SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA37SCB"
    VALUE
    0x80805CF8
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA37SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA37SCG"
    VALUE
    0x80805CF9
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA37ShuntSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA37ShuntSCB"
    VALUE
    0x80805CFA
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA38AicSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA38AicSCB"
    VALUE
    0x80805CFB
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA38AicSCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA38AicSCG"
    VALUE
    0x80805CFC
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA38OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA38OR"
    VALUE
    0x80805CFD
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA38SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA38SCB"
    VALUE
    0x80805CFE
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA38SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA38SCG"
    VALUE
    0x80805CFF
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA38ShuntSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA38ShuntSCB"
    VALUE
    0x80805D00
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA39AicSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA39AicSCB"
    VALUE
    0x80805D01
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA39AicSCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA39AicSCG"
    VALUE
    0x80805D02
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA39OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA39OR"
    VALUE
    0x80805D03
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA39SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA39SCB"
    VALUE
    0x80805D04
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA39SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA39SCG"
    VALUE
    0x80805D05
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA39ShuntSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA39ShuntSCB"
    VALUE
    0x80805D06
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA40OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA40OR"
    VALUE
    0x80805D07
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA40SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA40SCB"
    VALUE
    0x80805D08
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA40SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA40SCG"
    VALUE
    0x80805D09
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA41OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA41OR"
    VALUE
    0x80805D0A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA41SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA41SCB"
    VALUE
    0x80805D0B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA41SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA41SCG"
    VALUE
    0x80805D0C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA42OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA42OR"
    VALUE
    0x80805D0D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA42SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA42SCB"
    VALUE
    0x80805D0E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA42SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA42SCG"
    VALUE
    0x80805D0F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA43AicSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA43AicSCB"
    VALUE
    0x80805D10
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA43AicSCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA43AicSCG"
    VALUE
    0x80805D11
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA43OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA43OR"
    VALUE
    0x80805D12
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA43SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA43SCB"
    VALUE
    0x80805D13
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA43SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA43SCG"
    VALUE
    0x80805D14
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA43ShuntSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA43ShuntSCB"
    VALUE
    0x80805D15
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA44OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA44OL"
    VALUE
    0x80805D16
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA44SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA44SCB"
    VALUE
    0x80805D17
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA44SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA44SCG"
    VALUE
    0x80805D18
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA57OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA57OR"
    VALUE
    0x80805D19
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA57SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA57SCB"
    VALUE
    0x80805D1A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA57SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA57SCG"
    VALUE
    0x80805D1B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA59OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA59OL"
    VALUE
    0x80805D1C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA59SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA59SCB"
    VALUE
    0x80805D1D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA59SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA59SCG"
    VALUE
    0x80805D1E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK10OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK10OR"
    VALUE
    0x80805D1F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK10SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK10SCB"
    VALUE
    0x80805D20
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK10SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK10SCG"
    VALUE
    0x80805D21
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK11OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK11OR"
    VALUE
    0x80805D22
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK11SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK11SCB"
    VALUE
    0x80805D23
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK11SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK11SCG"
    VALUE
    0x80805D24
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK30AicSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK30AicSCB"
    VALUE
    0x80805D25
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK30AicSCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK30AicSCG"
    VALUE
    0x80805D26
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK30OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK30OR"
    VALUE
    0x80805D27
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK30SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK30SCB"
    VALUE
    0x80805D28
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK30SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK30SCG"
    VALUE
    0x80805D29
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK30ShuntSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK30ShuntSCB"
    VALUE
    0x80805D2A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK31OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK31OR"
    VALUE
    0x80805D2B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK31SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK31SCB"
    VALUE
    0x80805D2C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK31SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK31SCG"
    VALUE
    0x80805D2D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK32OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK32OR"
    VALUE
    0x80805D2E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK32SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK32SCB"
    VALUE
    0x80805D2F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK32SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK32SCG"
    VALUE
    0x80805D30
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK33OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK33OR"
    VALUE
    0x80805D31
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK33SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK33SCB"
    VALUE
    0x80805D32
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK33SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK33SCG"
    VALUE
    0x80805D33
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK34OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK34OR"
    VALUE
    0x80805D34
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK34SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK34SCB"
    VALUE
    0x80805D35
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK34SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK34SCG"
    VALUE
    0x80805D36
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK35OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK35OR"
    VALUE
    0x80805D37
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK35SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK35SCB"
    VALUE
    0x80805D38
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK35SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK35SCG"
    VALUE
    0x80805D39
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK36OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK36OR"
    VALUE
    0x80805D3A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK36SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK36SCB"
    VALUE
    0x80805D3B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK36SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK36SCG"
    VALUE
    0x80805D3C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK37AicSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK37AicSCB"
    VALUE
    0x80805D3D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK37AicSCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK37AicSCG"
    VALUE
    0x80805D3E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK37OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK37OR"
    VALUE
    0x80805D3F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK37SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK37SCB"
    VALUE
    0x80805D40
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK37SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK37SCG"
    VALUE
    0x80805D41
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK37ShuntSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK37ShuntSCB"
    VALUE
    0x80805D42
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK38AicSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK38AicSCB"
    VALUE
    0x80805D43
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK38AicSCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK38AicSCG"
    VALUE
    0x80805D44
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK38OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK38OR"
    VALUE
    0x80805D45
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK38SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK38SCB"
    VALUE
    0x80805D46
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK38SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK38SCG"
    VALUE
    0x80805D47
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK38ShuntSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK38ShuntSCB"
    VALUE
    0x80805D48
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK39AicSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK39AicSCB"
    VALUE
    0x80805D49
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK39AicSCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK39AicSCG"
    VALUE
    0x80805D4A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK39OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK39OR"
    VALUE
    0x80805D4B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK39SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK39SCB"
    VALUE
    0x80805D4C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK39SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK39SCG"
    VALUE
    0x80805D4D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK39ShuntSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK39ShuntSCB"
    VALUE
    0x80805D4E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK40AicSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK40AicSCB"
    VALUE
    0x80805D4F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK40AicSCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK40AicSCG"
    VALUE
    0x80805D50
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK40OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK40OR"
    VALUE
    0x80805D51
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK40SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK40SCB"
    VALUE
    0x80805D52
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK40SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK40SCG"
    VALUE
    0x80805D53
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK40ShuntSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK40ShuntSCB"
    VALUE
    0x80805D54
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK41AicSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK41AicSCB"
    VALUE
    0x80805D55
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK41AicSCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK41AicSCG"
    VALUE
    0x80805D56
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK41OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK41OR"
    VALUE
    0x80805D57
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK41SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK41SCB"
    VALUE
    0x80805D58
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK41SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK41SCG"
    VALUE
    0x80805D59
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK41ShuntSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK41ShuntSCB"
    VALUE
    0x80805D5A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK42AicSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK42AicSCB"
    VALUE
    0x80805D5B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK42AicSCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK42AicSCG"
    VALUE
    0x80805D5C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK42OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK42OR"
    VALUE
    0x80805D5D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK42SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK42SCB"
    VALUE
    0x80805D5E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK42SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK42SCG"
    VALUE
    0x80805D5F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK42ShuntSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK42ShuntSCB"
    VALUE
    0x80805D60
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK43OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK43OR"
    VALUE
    0x80805D61
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK43SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK43SCB"
    VALUE
    0x80805D62
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK43SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK43SCG"
    VALUE
    0x80805D63
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK44AicSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK44AicSCB"
    VALUE
    0x80805D64
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK44AicSCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK44AicSCG"
    VALUE
    0x80805D65
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK44OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK44OR"
    VALUE
    0x80805D66
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK44SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK44SCB"
    VALUE
    0x80805D67
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK44SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK44SCG"
    VALUE
    0x80805D68
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK44ShuntSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK44ShuntSCB"
    VALUE
    0x80805D69
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK45AicSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK45AicSCB"
    VALUE
    0x80805D6A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK45AicSCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK45AicSCG"
    VALUE
    0x80805D6B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK45OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK45OR"
    VALUE
    0x80805D6C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK45SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK45SCB"
    VALUE
    0x80805D6D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK45SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK45SCG"
    VALUE
    0x80805D6E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK45ShuntSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK45ShuntSCB"
    VALUE
    0x80805D6F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK52OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK52OR"
    VALUE
    0x80805D70
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK52SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK52SCB"
    VALUE
    0x80805D71
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK52SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK52SCG"
    VALUE
    0x80805D72
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK53OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK53OR"
    VALUE
    0x80805D73
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK53SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK53SCB"
    VALUE
    0x80805D74
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK53SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK53SCG"
    VALUE
    0x80805D75
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK54AicSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK54AicSCB"
    VALUE
    0x80805D76
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK54AicSCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK54AicSCG"
    VALUE
    0x80805D77
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK54OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK54OR"
    VALUE
    0x80805D78
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK54SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK54SCB"
    VALUE
    0x80805D79
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK54SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK54SCG"
    VALUE
    0x80805D7A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK54ShuntSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK54ShuntSCB"
    VALUE
    0x80805D7B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK55AicSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK55AicSCB"
    VALUE
    0x80805D7C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK55AicSCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK55AicSCG"
    VALUE
    0x80805D7D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK55OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK55OR"
    VALUE
    0x80805D7E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK55SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK55SCB"
    VALUE
    0x80805D7F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK55SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK55SCG"
    VALUE
    0x80805D80
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK55ShuntSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK55ShuntSCB"
    VALUE
    0x80805D81
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK56OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK56OR"
    VALUE
    0x80805D82
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK56SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK56SCB"
    VALUE
    0x80805D83
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK56SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK56SCG"
    VALUE
    0x80805D84
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK57OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK57OR"
    VALUE
    0x80805D85
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK57SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK57SCB"
    VALUE
    0x80805D86
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK57SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK57SCG"
    VALUE
    0x80805D87
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK58OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK58OR"
    VALUE
    0x80805D88
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK58SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK58SCB"
    VALUE
    0x80805D89
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK58SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK58SCG"
    VALUE
    0x80805D8A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK59OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK59OR"
    VALUE
    0x80805D8B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK59SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK59SCB"
    VALUE
    0x80805D8C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK59SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK59SCG"
    VALUE
    0x80805D8D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK60OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK60OR"
    VALUE
    0x80805D8E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK60SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK60SCB"
    VALUE
    0x80805D8F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK60SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK60SCG"
    VALUE
    0x80805D90
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK61AicSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK61AicSCB"
    VALUE
    0x80805D91
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK61AicSCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK61AicSCG"
    VALUE
    0x80805D92
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK61OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK61OR"
    VALUE
    0x80805D93
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK61SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK61SCB"
    VALUE
    0x80805D94
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK61SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK61SCG"
    VALUE
    0x80805D95
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK61ShuntSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK61ShuntSCB"
    VALUE
    0x80805D96
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK62OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK62OR"
    VALUE
    0x80805D97
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK62SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK62SCB"
    VALUE
    0x80805D98
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK62SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK62SCG"
    VALUE
    0x80805D99
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK63AicSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK63AicSCB"
    VALUE
    0x80805D9A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK63AicSCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK63AicSCG"
    VALUE
    0x80805D9B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK63OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK63OR"
    VALUE
    0x80805D9C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK63SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK63SCB"
    VALUE
    0x80805D9D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK63SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK63SCG"
    VALUE
    0x80805D9E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK63ShuntSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK63ShuntSCB"
    VALUE
    0x80805D9F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK64AicSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK64AicSCB"
    VALUE
    0x80805DA0
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK64AicSCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK64AicSCG"
    VALUE
    0x80805DA1
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK64OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK64OR"
    VALUE
    0x80805DA2
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK64SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK64SCB"
    VALUE
    0x80805DA3
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK64SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK64SCG"
    VALUE
    0x80805DA4
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK64ShuntSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK64ShuntSCB"
    VALUE
    0x80805DA5
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK65AicSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK65AicSCB"
    VALUE
    0x80805DA6
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK65AicSCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK65AicSCG"
    VALUE
    0x80805DA7
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK65OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK65OR"
    VALUE
    0x80805DA8
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK65SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK65SCB"
    VALUE
    0x80805DA9
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK65SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK65SCG"
    VALUE
    0x80805DAA
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK65ShuntSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK65ShuntSCB"
    VALUE
    0x80805DAB
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK74OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK74OR"
    VALUE
    0x80805DAC
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK74SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK74SCB"
    VALUE
    0x80805DAD
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK74SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK74SCG"
    VALUE
    0x80805DAE
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK75OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK75OR"
    VALUE
    0x80805DAF
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK75SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK75SCB"
    VALUE
    0x80805DB0
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK75SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK75SCG"
    VALUE
    0x80805DB1
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK76OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK76OR"
    VALUE
    0x80805DB2
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK76SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK76SCB"
    VALUE
    0x80805DB3
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK76SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK76SCG"
    VALUE
    0x80805DB4
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK77OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK77OR"
    VALUE
    0x80805DB5
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK77SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK77SCB"
    VALUE
    0x80805DB6
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK77SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK77SCG"
    VALUE
    0x80805DB7
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK78OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK78OR"
    VALUE
    0x80805DB8
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK78SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK78SCB"
    VALUE
    0x80805DB9
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK78SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK78SCG"
    VALUE
    0x80805DBA
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_DvUBAT_FWs_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_DvUBAT_FWs"
    VALUE
    0x80805DBB
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_OVErr_VPR6_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_OVErr_VPR6"
    VALUE
    0x80805DBC
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_OVWarn_VPR6_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_OVWarn_VPR6"
    VALUE
    0x80805DBD
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3"
    VALUE
    0x80805DBE
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2"
    VALUE
    0x80805DBF
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_OV_UBAT_MON_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_OV_UBAT_MON"
    VALUE
    0x80805DC0
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_OV_UBRM24_FLEXIN_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_OV_UBRM24_FLEXIN"
    VALUE
    0x80805DC1
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_OV_UBRM24_LOADS_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_OV_UBRM24_LOADS"
    VALUE
    0x80805DC2
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_OV_UBRM24_MON_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_OV_UBRM24_MON"
    VALUE
    0x80805DC3
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_OV_VDD5_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_OV_VDD5"
    VALUE
    0x80805DC4
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_OV_VDD5_IN_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_OV_VDD5_IN"
    VALUE
    0x80805DC5
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_OV_VPR6_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_OV_VPR6"
    VALUE
    0x80805DC6
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_OV_VSS3_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_OV_VSS3"
    VALUE
    0x80805DC7
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_OV_VSS4_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_OV_VSS4"
    VALUE
    0x80805DC8
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_Temp1_HTErr_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_Temp1_HTErr"
    VALUE
    0x80805DC9
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_Temp1_HTWarn_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_Temp1_HTWarn"
    VALUE
    0x80805DCA
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_Temp2_HTErr_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_Temp2_HTErr"
    VALUE
    0x80805DCB
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_Temp2_HTWarn_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_Temp2_HTWarn"
    VALUE
    0x80805DCC
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3"
    VALUE
    0x80805DCD
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2"
    VALUE
    0x80805DCE
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_UV_VDD5_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_UV_VDD5"
    VALUE
    0x80805DCF
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_UV_VDD5_IN_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_UV_VDD5_IN"
    VALUE
    0x80805DD0
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_UV_VPR6_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_UV_VPR6"
    VALUE
    0x80805DD1
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_UV_VSS3_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_UV_VSS3"
    VALUE
    0x80805DD2
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_UV_VSS4_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_UV_VSS4"
    VALUE
    0x80805DD3
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA01OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA01OL"
    VALUE
    0x80805DD4
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA01OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA01OT"
    VALUE
    0x80805DD5
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA01SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA01SCB"
    VALUE
    0x80805DD6
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA01SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA01SCG"
    VALUE
    0x80805DD7
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA02OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA02OL"
    VALUE
    0x80805DD8
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA02OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA02OR"
    VALUE
    0x80805DD9
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA02OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA02OT"
    VALUE
    0x80805DDA
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA02SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA02SCB"
    VALUE
    0x80805DDB
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA02SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA02SCG"
    VALUE
    0x80805DDC
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA03OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA03OL"
    VALUE
    0x80805DDD
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA03OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA03OT"
    VALUE
    0x80805DDE
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA03SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA03SCB"
    VALUE
    0x80805DDF
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA03SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA03SCG"
    VALUE
    0x80805DE0
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA04OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA04OL"
    VALUE
    0x80805DE1
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA04OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA04OT"
    VALUE
    0x80805DE2
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA04SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA04SCB"
    VALUE
    0x80805DE3
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA04SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA04SCG"
    VALUE
    0x80805DE4
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA05OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA05OL"
    VALUE
    0x80805DE5
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA05OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA05OR"
    VALUE
    0x80805DE6
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA05OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA05OT"
    VALUE
    0x80805DE7
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA05SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA05SCB"
    VALUE
    0x80805DE8
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA05SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA05SCG"
    VALUE
    0x80805DE9
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA06OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA06OL"
    VALUE
    0x80805DEA
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA06OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA06OR"
    VALUE
    0x80805DEB
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA06OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA06OT"
    VALUE
    0x80805DEC
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA06SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA06SCB"
    VALUE
    0x80805DED
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA06SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA06SCG"
    VALUE
    0x80805DEE
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA07OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA07OL"
    VALUE
    0x80805DEF
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA07OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA07OT"
    VALUE
    0x80805DF0
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA07SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA07SCB"
    VALUE
    0x80805DF1
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA07SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA07SCG"
    VALUE
    0x80805DF2
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA08OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA08OL"
    VALUE
    0x80805DF3
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA08OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA08OT"
    VALUE
    0x80805DF4
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA08SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA08SCB"
    VALUE
    0x80805DF5
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA08SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA08SCG"
    VALUE
    0x80805DF6
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA09OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA09OL"
    VALUE
    0x80805DF7
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA09OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA09OR"
    VALUE
    0x80805DF8
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA09OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA09OT"
    VALUE
    0x80805DF9
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA09SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA09SCB"
    VALUE
    0x80805DFA
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA09SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA09SCG"
    VALUE
    0x80805DFB
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA10OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA10OL"
    VALUE
    0x80805DFC
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA10OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA10OT"
    VALUE
    0x80805DFD
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA10SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA10SCB"
    VALUE
    0x80805DFE
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA10SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA10SCG"
    VALUE
    0x80805DFF
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA11OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA11OL"
    VALUE
    0x80805E00
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA11OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA11OT"
    VALUE
    0x80805E01
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA11SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA11SCB"
    VALUE
    0x80805E02
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA11SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA11SCG"
    VALUE
    0x80805E03
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA12OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA12OR"
    VALUE
    0x80805E04
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA12SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA12SCB"
    VALUE
    0x80805E05
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA12SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA12SCG"
    VALUE
    0x80805E06
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA16OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA16OL"
    VALUE
    0x80805E07
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA16OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA16OT"
    VALUE
    0x80805E08
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA16SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA16SCB"
    VALUE
    0x80805E09
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA16SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA16SCG"
    VALUE
    0x80805E0A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA17OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA17OL"
    VALUE
    0x80805E0B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA17OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA17OR"
    VALUE
    0x80805E0C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA17OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA17OT"
    VALUE
    0x80805E0D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA17SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA17SCB"
    VALUE
    0x80805E0E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA17SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA17SCG"
    VALUE
    0x80805E0F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA18OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA18OL"
    VALUE
    0x80805E10
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA18OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA18OT"
    VALUE
    0x80805E11
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA18SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA18SCB"
    VALUE
    0x80805E12
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA18SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA18SCG"
    VALUE
    0x80805E13
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA19OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA19OL"
    VALUE
    0x80805E14
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA19OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA19OR"
    VALUE
    0x80805E15
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA19OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA19OT"
    VALUE
    0x80805E16
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA19SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA19SCB"
    VALUE
    0x80805E17
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA19SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA19SCG"
    VALUE
    0x80805E18
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA20OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA20OL"
    VALUE
    0x80805E19
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA20OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA20OR"
    VALUE
    0x80805E1A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA20OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA20OT"
    VALUE
    0x80805E1B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA20SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA20SCB"
    VALUE
    0x80805E1C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA20SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA20SCG"
    VALUE
    0x80805E1D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA31OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA31OL"
    VALUE
    0x80805E1E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA31OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA31OR"
    VALUE
    0x80805E1F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA31OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA31OT"
    VALUE
    0x80805E20
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA31SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA31SCB"
    VALUE
    0x80805E21
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA31SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA31SCG"
    VALUE
    0x80805E22
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA32OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA32OL"
    VALUE
    0x80805E23
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA32OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA32OR"
    VALUE
    0x80805E24
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA32OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA32OT"
    VALUE
    0x80805E25
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA32SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA32SCB"
    VALUE
    0x80805E26
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA32SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA32SCG"
    VALUE
    0x80805E27
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA33OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA33OL"
    VALUE
    0x80805E28
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA33OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA33OR"
    VALUE
    0x80805E29
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA33OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA33OT"
    VALUE
    0x80805E2A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA33SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA33SCB"
    VALUE
    0x80805E2B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA33SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA33SCG"
    VALUE
    0x80805E2C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA34OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA34OL"
    VALUE
    0x80805E2D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA34OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA34OR"
    VALUE
    0x80805E2E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA34OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA34OT"
    VALUE
    0x80805E2F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA34SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA34SCB"
    VALUE
    0x80805E30
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA34SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA34SCG"
    VALUE
    0x80805E31
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA35OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA35OL"
    VALUE
    0x80805E32
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA35OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA35OR"
    VALUE
    0x80805E33
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA35OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA35OT"
    VALUE
    0x80805E34
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA35SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA35SCB"
    VALUE
    0x80805E35
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA35SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA35SCG"
    VALUE
    0x80805E36
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA46OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA46OL"
    VALUE
    0x80805E37
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA46OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA46OR"
    VALUE
    0x80805E38
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA46OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA46OT"
    VALUE
    0x80805E39
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA46SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA46SCB"
    VALUE
    0x80805E3A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA46SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA46SCG"
    VALUE
    0x80805E3B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA47OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA47OL"
    VALUE
    0x80805E3C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA47OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA47OR"
    VALUE
    0x80805E3D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA47OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA47OT"
    VALUE
    0x80805E3E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA47SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA47SCB"
    VALUE
    0x80805E3F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA47SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA47SCG"
    VALUE
    0x80805E40
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA48OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA48OL"
    VALUE
    0x80805E41
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA48OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA48OR"
    VALUE
    0x80805E42
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA48OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA48OT"
    VALUE
    0x80805E43
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA48SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA48SCB"
    VALUE
    0x80805E44
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA48SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA48SCG"
    VALUE
    0x80805E45
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA49OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA49OL"
    VALUE
    0x80805E46
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA49OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA49OT"
    VALUE
    0x80805E47
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA49SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA49SCB"
    VALUE
    0x80805E48
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA49SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA49SCG"
    VALUE
    0x80805E49
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA50OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA50OL"
    VALUE
    0x80805E4A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA50OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA50OT"
    VALUE
    0x80805E4B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA50SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA50SCB"
    VALUE
    0x80805E4C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA50SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA50SCG"
    VALUE
    0x80805E4D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA51OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA51OL"
    VALUE
    0x80805E4E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA51OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA51OR"
    VALUE
    0x80805E4F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA51OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA51OT"
    VALUE
    0x80805E50
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA51SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA51SCB"
    VALUE
    0x80805E51
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA51SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA51SCG"
    VALUE
    0x80805E52
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA52OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA52OL"
    VALUE
    0x80805E53
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA52OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA52OR"
    VALUE
    0x80805E54
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA52OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA52OT"
    VALUE
    0x80805E55
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA52SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA52SCB"
    VALUE
    0x80805E56
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA52SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA52SCG"
    VALUE
    0x80805E57
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA53OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA53OL"
    VALUE
    0x80805E58
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA53OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA53OR"
    VALUE
    0x80805E59
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA53OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA53OT"
    VALUE
    0x80805E5A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA53SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA53SCB"
    VALUE
    0x80805E5B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA53SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA53SCG"
    VALUE
    0x80805E5C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA54OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA54OL"
    VALUE
    0x80805E5D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA54OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA54OR"
    VALUE
    0x80805E5E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA54OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA54OT"
    VALUE
    0x80805E5F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA54SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA54SCB"
    VALUE
    0x80805E60
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA54SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA54SCG"
    VALUE
    0x80805E61
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA55OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA55OL"
    VALUE
    0x80805E62
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA55OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA55OT"
    VALUE
    0x80805E63
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA55SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA55SCB"
    VALUE
    0x80805E64
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA55SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA55SCG"
    VALUE
    0x80805E65
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA56OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA56OL"
    VALUE
    0x80805E66
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA56OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA56OT"
    VALUE
    0x80805E67
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA56SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA56SCB"
    VALUE
    0x80805E68
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA56SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA56SCG"
    VALUE
    0x80805E69
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA58OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA58OL"
    VALUE
    0x80805E6A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA58OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA58OT"
    VALUE
    0x80805E6B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA58SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA58SCB"
    VALUE
    0x80805E6C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA58SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA58SCG"
    VALUE
    0x80805E6D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK07OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK07OL"
    VALUE
    0x80805E6E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK07OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK07OR"
    VALUE
    0x80805E6F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK07OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK07OT"
    VALUE
    0x80805E70
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK07SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK07SCB"
    VALUE
    0x80805E71
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK07SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK07SCG"
    VALUE
    0x80805E72
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK08OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK08OL"
    VALUE
    0x80805E73
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK08OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK08OR"
    VALUE
    0x80805E74
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK08OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK08OT"
    VALUE
    0x80805E75
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK08SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK08SCB"
    VALUE
    0x80805E76
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK08SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK08SCG"
    VALUE
    0x80805E77
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK09OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK09OL"
    VALUE
    0x80805E78
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK09OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK09OR"
    VALUE
    0x80805E79
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK09OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK09OT"
    VALUE
    0x80805E7A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK09SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK09SCB"
    VALUE
    0x80805E7B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK09SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK09SCG"
    VALUE
    0x80805E7C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK12OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK12OL"
    VALUE
    0x80805E7D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK12OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK12OT"
    VALUE
    0x80805E7E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK12SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK12SCB"
    VALUE
    0x80805E7F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK12SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK12SCG"
    VALUE
    0x80805E80
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK13OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK13OL"
    VALUE
    0x80805E81
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK13OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK13OT"
    VALUE
    0x80805E82
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK13SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK13SCB"
    VALUE
    0x80805E83
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK13SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK13SCG"
    VALUE
    0x80805E84
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK14OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK14OL"
    VALUE
    0x80805E85
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK14OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK14OR"
    VALUE
    0x80805E86
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK14OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK14OT"
    VALUE
    0x80805E87
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK14SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK14SCB"
    VALUE
    0x80805E88
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK14SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK14SCG"
    VALUE
    0x80805E89
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK15OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK15OL"
    VALUE
    0x80805E8A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK15OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK15OR"
    VALUE
    0x80805E8B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK15OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK15OT"
    VALUE
    0x80805E8C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK15SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK15SCB"
    VALUE
    0x80805E8D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK15SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK15SCG"
    VALUE
    0x80805E8E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK16OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK16OL"
    VALUE
    0x80805E8F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK16OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK16OR"
    VALUE
    0x80805E90
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK16OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK16OT"
    VALUE
    0x80805E91
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK16SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK16SCB"
    VALUE
    0x80805E92
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK16SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK16SCG"
    VALUE
    0x80805E93
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK17OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK17OL"
    VALUE
    0x80805E94
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK17OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK17OR"
    VALUE
    0x80805E95
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK17OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK17OT"
    VALUE
    0x80805E96
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK17SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK17SCB"
    VALUE
    0x80805E97
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK17SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK17SCG"
    VALUE
    0x80805E98
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK25OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK25OR"
    VALUE
    0x80805E99
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK25SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK25SCB"
    VALUE
    0x80805E9A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK25SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK25SCG"
    VALUE
    0x80805E9B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK29OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK29OL"
    VALUE
    0x80805E9C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK29OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK29OR"
    VALUE
    0x80805E9D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK29OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK29OT"
    VALUE
    0x80805E9E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK29SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK29SCB"
    VALUE
    0x80805E9F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK29SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK29SCG"
    VALUE
    0x80805EA0
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK51OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK51OL"
    VALUE
    0x80805EA1
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK51OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK51OT"
    VALUE
    0x80805EA2
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK51SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK51SCB"
    VALUE
    0x80805EA3
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK51SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK51SCG"
    VALUE
    0x80805EA4
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK62OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK62OR"
    VALUE
    0x80805EA5
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK62SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK62SCB"
    VALUE
    0x80805EA6
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK62SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK62SCG"
    VALUE
    0x80805EA7
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK73OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK73OL"
    VALUE
    0x80805EA8
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK73OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK73OR"
    VALUE
    0x80805EA9
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK73OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK73OT"
    VALUE
    0x80805EAA
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK73SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK73SCB"
    VALUE
    0x80805EAB
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK73SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK73SCG"
    VALUE
    0x80805EAC
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK80OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK80OL"
    VALUE
    0x80805EAD
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK80OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK80OT"
    VALUE
    0x80805EAE
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK80SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK80SCB"
    VALUE
    0x80805EAF
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK80SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK80SCG"
    VALUE
    0x80805EB0
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK81OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK81OL"
    VALUE
    0x80805EB1
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK81OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK81OT"
    VALUE
    0x80805EB2
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK81SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK81SCB"
    VALUE
    0x80805EB3
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK81SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK81SCG"
    VALUE
    0x80805EB4
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK82OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK82OL"
    VALUE
    0x80805EB5
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK82OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK82OT"
    VALUE
    0x80805EB6
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK82SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK82SCB"
    VALUE
    0x80805EB7
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK82SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK82SCG"
    VALUE
    0x80805EB8
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK83OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK83OL"
    VALUE
    0x80805EB9
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK83OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK83OT"
    VALUE
    0x80805EBA
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK83SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK83SCB"
    VALUE
    0x80805EBB
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK83SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK83SCG"
    VALUE
    0x80805EBC
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK84OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK84OL"
    VALUE
    0x80805EBD
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK84OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK84OT"
    VALUE
    0x80805EBE
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK84SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK84SCB"
    VALUE
    0x80805EBF
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK84SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK84SCG"
    VALUE
    0x80805EC0
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK85OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK85OL"
    VALUE
    0x80805EC1
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK85OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK85OT"
    VALUE
    0x80805EC2
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK85SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK85SCB"
    VALUE
    0x80805EC3
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK85SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK85SCG"
    VALUE
    0x80805EC4
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK86OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK86OL"
    VALUE
    0x80805EC5
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK86OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK86OT"
    VALUE
    0x80805EC6
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK86SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK86SCB"
    VALUE
    0x80805EC7
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK86SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK86SCG"
    VALUE
    0x80805EC8
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK87OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK87OL"
    VALUE
    0x80805EC9
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK87OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK87OT"
    VALUE
    0x80805ECA
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK87SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK87SCB"
    VALUE
    0x80805ECB
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK87SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK87SCG"
    VALUE
    0x80805ECC
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_EventUpDownDebFault_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_EventUpDownDebFault"
    VALUE
    0x80805ECD
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_DSMDummy_C
    "used environment signals / Reference to used environment condition set for check DFC_DSMDummy"
    VALUE
    0x80805ECE
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canGetDataNoBuf_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canGetDataNoBuf"
    VALUE
    0x80805ECF
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canGetDataParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canGetDataParam"
    VALUE
    0x80805ED0
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canGetDataboxNoInit_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canGetDataboxNoInit"
    VALUE
    0x80805ED1
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canGetDataboxParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canGetDataboxParam"
    VALUE
    0x80805ED2
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canGetRxBufStatusParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canGetRxBufStatusParam"
    VALUE
    0x80805ED3
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canGetStatusParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canGetStatusParam"
    VALUE
    0x80805ED4
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canGetTxBufStatusParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canGetTxBufStatusParam"
    VALUE
    0x80805ED5
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canInitParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canInitParam"
    VALUE
    0x80805ED6
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canInitRxDataboxOverlap_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canInitRxDataboxOverlap"
    VALUE
    0x80805ED7
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canInitRxDataboxParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canInitRxDataboxParam"
    VALUE
    0x80805ED8
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canInitTxDataboxParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canInitTxDataboxParam"
    VALUE
    0x80805ED9
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canIpduGroupControl_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canIpduGroupControl"
    VALUE
    0x80805EDA
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canIsDataboxFreeNoInit_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canIsDataboxFreeNoInit"
    VALUE
    0x80805EDB
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canIsDataboxFreeParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canIsDataboxFreeParam"
    VALUE
    0x80805EDC
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canIsTxEmptyParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canIsTxEmptyParam"
    VALUE
    0x80805EDD
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canRegBusOffCallbInvState_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canRegBusOffCallbInvState"
    VALUE
    0x80805EDE
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canRegBusOffCallbParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canRegBusOffCallbParam"
    VALUE
    0x80805EDF
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canRegRxBufInvState_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canRegRxBufInvState"
    VALUE
    0x80805EE0
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canRegRxBufOverlap_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canRegRxBufOverlap"
    VALUE
    0x80805EE1
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canRegRxBufParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canRegRxBufParam"
    VALUE
    0x80805EE2
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canRegRxCallbInvState_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canRegRxCallbInvState"
    VALUE
    0x80805EE3
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canRegRxCallbParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canRegRxCallbParam"
    VALUE
    0x80805EE4
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canRegRxDataboxInvNumb_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canRegRxDataboxInvNumb"
    VALUE
    0x80805EE5
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canRegRxDataboxInvState_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canRegRxDataboxInvState"
    VALUE
    0x80805EE6
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canRegRxDataboxOverlap_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canRegRxDataboxOverlap"
    VALUE
    0x80805EE7
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canRegRxDataboxParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canRegRxDataboxParam"
    VALUE
    0x80805EE8
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canRegTxBufInvState_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canRegTxBufInvState"
    VALUE
    0x80805EE9
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canRegTxBufOverlap_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canRegTxBufOverlap"
    VALUE
    0x80805EEA
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canRegTxBufParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canRegTxBufParam"
    VALUE
    0x80805EEB
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canRegTxDataboxInvNumb_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canRegTxDataboxInvNumb"
    VALUE
    0x80805EEC
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canRegTxDataboxInvState_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canRegTxDataboxInvState"
    VALUE
    0x80805EED
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canRegTxDataboxOverlap_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canRegTxDataboxOverlap"
    VALUE
    0x80805EEE
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canRegTxDataboxParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canRegTxDataboxParam"
    VALUE
    0x80805EEF
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canResetTxBufParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canResetTxBufParam"
    VALUE
    0x80805EF0
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canSendDataBufOvfl_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canSendDataBufOvfl"
    VALUE
    0x80805EF1
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canSendDataParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canSendDataParam"
    VALUE
    0x80805EF2
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canSendDataboxNoInit_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canSendDataboxNoInit"
    VALUE
    0x80805EF3
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canSendDataboxParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canSendDataboxParam"
    VALUE
    0x80805EF4
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canSetTxCycleParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canSetTxCycleParam"
    VALUE
    0x80805EF5
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canStartParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canStartParam"
    VALUE
    0x80805EF6
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canStopParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canStopParam"
    VALUE
    0x80805EF7
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_can_ClearIpduGroup_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_can_ClearIpduGroup"
    VALUE
    0x80805EF8
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_can_ReceiveSignal_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_can_ReceiveSignal"
    VALUE
    0x80805EF9
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_can_SendSignal_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_can_SendSignal"
    VALUE
    0x80805EFA
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_can_SetIpduGroup_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_can_SetIpduGroup"
    VALUE
    0x80805EFB
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_dsmDTCJ1939_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_dsmDTCJ1939"
    VALUE
    0x80805EFC
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_dsmDelDTCJ1939_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_dsmDelDTCJ1939"
    VALUE
    0x80805EFD
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_dsmDelErrors_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_dsmDelErrors"
    VALUE
    0x80805EFE
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_dsmGetDFES_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_dsmGetDFES"
    VALUE
    0x80805EFF
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_dsmGetDTCJ1939_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_dsmGetDTCJ1939"
    VALUE
    0x80805F00
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_dsmGetErrors_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_dsmGetErrors"
    VALUE
    0x80805F01
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_dsmGetNumErrors_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_dsmGetNumErrors"
    VALUE
    0x80805F02
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_dsmInitQueueOverflow_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_dsmInitQueueOverflow"
    VALUE
    0x80805F03
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_dsmNumDTCJ1939_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_dsmNumDTCJ1939"
    VALUE
    0x80805F04
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_dsmTesterror_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_dsmTesterror"
    VALUE
    0x80805F05
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_dsmUpdateDebError_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_dsmUpdateDebError"
    VALUE
    0x80805F06
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_dsmUpdateError_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_dsmUpdateError"
    VALUE
    0x80805F07
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_dsmgetDFCStatus_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_dsmgetDFCStatus"
    VALUE
    0x80805F08
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_dsmtestErrorDFC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_dsmtestErrorDFC"
    VALUE
    0x80805F09
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inAi_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inAi"
    VALUE
    0x80805F0A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inAic_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inAic"
    VALUE
    0x80805F0B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inAicCfg_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inAicCfg"
    VALUE
    0x80805F0C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inAicGetStatus_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inAicGetStatus"
    VALUE
    0x80805F0D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inAid_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inAid"
    VALUE
    0x80805F0E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inAidCfg_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inAidCfg"
    VALUE
    0x80805F0F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inAiv_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inAiv"
    VALUE
    0x80805F10
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inAivCfg_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inAivCfg"
    VALUE
    0x80805F11
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inAivGetStatus_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inAivGetStatus"
    VALUE
    0x80805F12
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inDi_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inDi"
    VALUE
    0x80805F13
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inFi_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inFi"
    VALUE
    0x80805F14
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inFiCfg_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inFiCfg"
    VALUE
    0x80805F15
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inFiGetStatus_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inFiGetStatus"
    VALUE
    0x80805F16
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inFi_Buffered_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inFi_Buffered"
    VALUE
    0x80805F17
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inPhase_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inPhase"
    VALUE
    0x80805F18
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inPhaseGetStatus_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inPhaseGetStatus"
    VALUE
    0x80805F19
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inPhaseResetCounter_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inPhaseResetCounter"
    VALUE
    0x80805F1A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inRi_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inRi"
    VALUE
    0x80805F1B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inRiCfg_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inRiCfg"
    VALUE
    0x80805F1C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inRiCfgTemp_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inRiCfgTemp"
    VALUE
    0x80805F1D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inRiGetStatus_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inRiGetStatus"
    VALUE
    0x80805F1E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inRiGetTemp_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inRiGetTemp"
    VALUE
    0x80805F1F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inSentCopyFDFifo_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inSentCopyFDFifo"
    VALUE
    0x80805F20
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inSentDisable_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inSentDisable"
    VALUE
    0x80805F21
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inSentEnable_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inSentEnable"
    VALUE
    0x80805F22
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inSentGetErrorStatus_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inSentGetErrorStatus"
    VALUE
    0x80805F23
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inSentGetFD_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inSentGetFD"
    VALUE
    0x80805F24
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inSentGetSD_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inSentGetSD"
    VALUE
    0x80805F25
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inSentGetSDDatabox_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inSentGetSDDatabox"
    VALUE
    0x80805F26
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inSentGetStatus_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inSentGetStatus"
    VALUE
    0x80805F27
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inSentInitSDDatabox_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inSentInitSDDatabox"
    VALUE
    0x80805F28
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inSentRegisterCopyFDFifo_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inSentRegisterCopyFDFifo"
    VALUE
    0x80805F29
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inSentRegisterFDFifo_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inSentRegisterFDFifo"
    VALUE
    0x80805F2A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inSentRegisterSDDataboxes_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inSentRegisterSDDataboxes"
    VALUE
    0x80805F2B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_isobusCanRxBufferOverflow_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_isobusCanRxBufferOverflow"
    VALUE
    0x80805F2C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_isobusGetCaAddrParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_isobusGetCaAddrParam"
    VALUE
    0x80805F2D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_isobusGetDiagnosticParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_isobusGetDiagnosticParam"
    VALUE
    0x80805F2E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_isobusGetRxDataboxStatusParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_isobusGetRxDataboxStatusParam"
    VALUE
    0x80805F2F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_isobusGetStatusParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_isobusGetStatusParam"
    VALUE
    0x80805F30
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_isobusInitCommCaMissing_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_isobusInitCommCaMissing"
    VALUE
    0x80805F31
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_isobusInitCommParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_isobusInitCommParam"
    VALUE
    0x80805F32
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_isobusInitCommState_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_isobusInitCommState"
    VALUE
    0x80805F33
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_isobusInitDiagnosticParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_isobusInitDiagnosticParam"
    VALUE
    0x80805F34
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_isobusInitFailureListParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_isobusInitFailureListParam"
    VALUE
    0x80805F35
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_isobusInitRxDataboxParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_isobusInitRxDataboxParam"
    VALUE
    0x80805F36
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_isobusInitTxDataboxParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_isobusInitTxDataboxParam"
    VALUE
    0x80805F37
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_isobusRegRxDataboxOverlap_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_isobusRegRxDataboxOverlap"
    VALUE
    0x80805F38
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_isobusRegRxDataboxParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_isobusRegRxDataboxParam"
    VALUE
    0x80805F39
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_isobusRegRxDataboxState_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_isobusRegRxDataboxState"
    VALUE
    0x80805F3A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_isobusRegTxDataboxOverlap_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_isobusRegTxDataboxOverlap"
    VALUE
    0x80805F3B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_isobusRegTxDataboxParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_isobusRegTxDataboxParam"
    VALUE
    0x80805F3C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_isobusRegTxDataboxState_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_isobusRegTxDataboxState"
    VALUE
    0x80805F3D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_isobusRegisterErrClrCallbackParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_isobusRegisterErrClrCallbackParam"
    VALUE
    0x80805F3E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_isobusRegisterInstancesOverlap_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_isobusRegisterInstancesOverlap"
    VALUE
    0x80805F3F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_isobusRegisterInstancesParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_isobusRegisterInstancesParam"
    VALUE
    0x80805F40
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_isobusRegisterInstancesState_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_isobusRegisterInstancesState"
    VALUE
    0x80805F41
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_isobusSendDataboxParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_isobusSendDataboxParam"
    VALUE
    0x80805F42
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_isobusSendRequestPGNParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_isobusSendRequestPGNParam"
    VALUE
    0x80805F43
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_isobusSetCaAddrCaUsed_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_isobusSetCaAddrCaUsed"
    VALUE
    0x80805F44
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_isobusSetCaAddrComm_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_isobusSetCaAddrComm"
    VALUE
    0x80805F45
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_isobusSetCaAddrInvCan_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_isobusSetCaAddrInvCan"
    VALUE
    0x80805F46
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_isobusSetCaAddrParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_isobusSetCaAddrParam"
    VALUE
    0x80805F47
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_isobusSetCaInfoParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_isobusSetCaInfoParam"
    VALUE
    0x80805F48
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_isobusSetCaNameParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_isobusSetCaNameParam"
    VALUE
    0x80805F49
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_isobusSftyCanTxErr_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_isobusSftyCanTxErr"
    VALUE
    0x80805F4A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_lin_ReceiveSignal_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_lin_ReceiveSignal"
    VALUE
    0x80805F4B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_lin_SendSignal_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_lin_SendSignal"
    VALUE
    0x80805F4C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_lin_getStatus_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_lin_getStatus"
    VALUE
    0x80805F4D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_lin_gotoSleep_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_lin_gotoSleep"
    VALUE
    0x80805F4E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_lin_scheduleRequest_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_lin_scheduleRequest"
    VALUE
    0x80805F4F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_lin_wakeUp_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_lin_wakeUp"
    VALUE
    0x80805F50
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_memFlsCfgShr_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_memFlsCfgShr"
    VALUE
    0x80805F51
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_memGetStatus_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_memGetStatus"
    VALUE
    0x80805F52
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_memMarkBlock_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_memMarkBlock"
    VALUE
    0x80805F53
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_memReadApi1Error_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_memReadApi1Error"
    VALUE
    0x80805F54
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_memReadApi2Error_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_memReadApi2Error"
    VALUE
    0x80805F55
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_memReadBlock_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_memReadBlock"
    VALUE
    0x80805F56
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_memReadCalibInputError_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_memReadCalibInputError"
    VALUE
    0x80805F57
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_memReadCalibOuputError_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_memReadCalibOuputError"
    VALUE
    0x80805F58
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_memReadSystemError_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_memReadSystemError"
    VALUE
    0x80805F59
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_memWriteBlock_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_memWriteBlock"
    VALUE
    0x80805F5A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_moOV_FirstConstADC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_moOV_FirstConstADC"
    VALUE
    0x80805F5B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_moOV_SecondConstADC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_moOV_SecondConstADC"
    VALUE
    0x80805F5C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_moUV_FirstConstADC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_moUV_FirstConstADC"
    VALUE
    0x80805F5D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_moUV_SecondConstADC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_moUV_SecondConstADC"
    VALUE
    0x80805F5E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_INH_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_INH"
    VALUE
    0x80805F5F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_INHLatch_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_INHLatch"
    VALUE
    0x80805F60
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_adcPDD_fail_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_adcPDD_fail"
    VALUE
    0x80805F61
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_memoryProtection_err_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_memoryProtection_err"
    VALUE
    0x80805F62
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA02OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA02OC"
    VALUE
    0x80805F63
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA02Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA02Unintended"
    VALUE
    0x80805F64
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA03OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA03OC"
    VALUE
    0x80805F65
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA03Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA03Unintended"
    VALUE
    0x80805F66
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA04OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA04OC"
    VALUE
    0x80805F67
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA04Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA04Unintended"
    VALUE
    0x80805F68
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA05OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA05OC"
    VALUE
    0x80805F69
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA05Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA05Unintended"
    VALUE
    0x80805F6A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA07OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA07OC"
    VALUE
    0x80805F6B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA07Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA07Unintended"
    VALUE
    0x80805F6C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA08OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA08OC"
    VALUE
    0x80805F6D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA08Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA08Unintended"
    VALUE
    0x80805F6E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA09OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA09OC"
    VALUE
    0x80805F6F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA09Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA09Unintended"
    VALUE
    0x80805F70
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA10OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA10OC"
    VALUE
    0x80805F71
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA10Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA10Unintended"
    VALUE
    0x80805F72
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA17OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA17OC"
    VALUE
    0x80805F73
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA17Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA17Unintended"
    VALUE
    0x80805F74
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA18OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA18OC"
    VALUE
    0x80805F75
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA18Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA18Unintended"
    VALUE
    0x80805F76
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA19OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA19OC"
    VALUE
    0x80805F77
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA19Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA19Unintended"
    VALUE
    0x80805F78
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA20OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA20OC"
    VALUE
    0x80805F79
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA20Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA20Unintended"
    VALUE
    0x80805F7A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA31OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA31OC"
    VALUE
    0x80805F7B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA31Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA31Unintended"
    VALUE
    0x80805F7C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA32OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA32OC"
    VALUE
    0x80805F7D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA32Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA32Unintended"
    VALUE
    0x80805F7E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA33OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA33OC"
    VALUE
    0x80805F7F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA33Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA33Unintended"
    VALUE
    0x80805F80
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA34OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA34OC"
    VALUE
    0x80805F81
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA34Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA34Unintended"
    VALUE
    0x80805F82
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA35OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA35OC"
    VALUE
    0x80805F83
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA35Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA35Unintended"
    VALUE
    0x80805F84
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA46OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA46OC"
    VALUE
    0x80805F85
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA46Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA46Unintended"
    VALUE
    0x80805F86
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA47OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA47OC"
    VALUE
    0x80805F87
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA47Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA47Unintended"
    VALUE
    0x80805F88
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA48OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA48OC"
    VALUE
    0x80805F89
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA48Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA48Unintended"
    VALUE
    0x80805F8A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA51OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA51OC"
    VALUE
    0x80805F8B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA51Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA51Unintended"
    VALUE
    0x80805F8C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA52OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA52OC"
    VALUE
    0x80805F8D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA52Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA52Unintended"
    VALUE
    0x80805F8E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA53OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA53OC"
    VALUE
    0x80805F8F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA53Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA53Unintended"
    VALUE
    0x80805F90
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA54OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA54OC"
    VALUE
    0x80805F91
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA54Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA54Unintended"
    VALUE
    0x80805F92
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outAov_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outAov"
    VALUE
    0x80805F93
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outAovCfg_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outAovCfg"
    VALUE
    0x80805F94
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outAovCfgPI_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outAovCfgPI"
    VALUE
    0x80805F95
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outAovGetStatus_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outAovGetStatus"
    VALUE
    0x80805F96
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outAovGetVoltage_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outAovGetVoltage"
    VALUE
    0x80805F97
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outAovResetError_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outAovResetError"
    VALUE
    0x80805F98
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outDo_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outDo"
    VALUE
    0x80805F99
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outDoCfgPwrLs_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outDoCfgPwrLs"
    VALUE
    0x80805F9A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outDoDisable_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outDoDisable"
    VALUE
    0x80805F9B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outDoGetCurrent_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outDoGetCurrent"
    VALUE
    0x80805F9C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outDoGetStatus_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outDoGetStatus"
    VALUE
    0x80805F9D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outDoResetError_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outDoResetError"
    VALUE
    0x80805F9E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK07OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK07OC"
    VALUE
    0x80805F9F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK07Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK07Unintended"
    VALUE
    0x80805FA0
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK08OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK08OC"
    VALUE
    0x80805FA1
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK08Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK08Unintended"
    VALUE
    0x80805FA2
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK09OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK09OC"
    VALUE
    0x80805FA3
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK09Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK09Unintended"
    VALUE
    0x80805FA4
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK12OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK12OC"
    VALUE
    0x80805FA5
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK12Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK12Unintended"
    VALUE
    0x80805FA6
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK13OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK13OC"
    VALUE
    0x80805FA7
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK13Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK13Unintended"
    VALUE
    0x80805FA8
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK14OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK14OC"
    VALUE
    0x80805FA9
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK14Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK14Unintended"
    VALUE
    0x80805FAA
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK15OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK15OC"
    VALUE
    0x80805FAB
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK15Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK15Unintended"
    VALUE
    0x80805FAC
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK16OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK16OC"
    VALUE
    0x80805FAD
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK16Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK16Unintended"
    VALUE
    0x80805FAE
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK17OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK17OC"
    VALUE
    0x80805FAF
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK17Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK17Unintended"
    VALUE
    0x80805FB0
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK29OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK29OC"
    VALUE
    0x80805FB1
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK29Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK29Unintended"
    VALUE
    0x80805FB2
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK51OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK51OC"
    VALUE
    0x80805FB3
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK51Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK51Unintended"
    VALUE
    0x80805FB4
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK73OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK73OC"
    VALUE
    0x80805FB5
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK73Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK73Unintended"
    VALUE
    0x80805FB6
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outPo_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outPo"
    VALUE
    0x80805FB7
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outPoCfg_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outPoCfg"
    VALUE
    0x80805FB8
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outPoCfgPeriod_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outPoCfgPeriod"
    VALUE
    0x80805FB9
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outPoCfgPwrLs_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outPoCfgPwrLs"
    VALUE
    0x80805FBA
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outPoDisable_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outPoDisable"
    VALUE
    0x80805FBB
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outPoGetCurrent_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outPoGetCurrent"
    VALUE
    0x80805FBC
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outPoGetStatus_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outPoGetStatus"
    VALUE
    0x80805FBD
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outPoResetError_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outPoResetError"
    VALUE
    0x80805FBE
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outPoc_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outPoc"
    VALUE
    0x80805FBF
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outPocCfg_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outPocCfg"
    VALUE
    0x80805FC0
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outPocCfgDither_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outPocCfgDither"
    VALUE
    0x80805FC1
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outPocCfgPI_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outPocCfgPI"
    VALUE
    0x80805FC2
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outPod_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outPod"
    VALUE
    0x80805FC3
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outPodCfg_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outPodCfg"
    VALUE
    0x80805FC4
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outPodCfgPeriod_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outPodCfgPeriod"
    VALUE
    0x80805FC5
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_rsmFfiApiCallErr_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_rsmFfiApiCallErr"
    VALUE
    0x80805FC6
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safout_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safout"
    VALUE
    0x80805FC7
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutCfg_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutCfg"
    VALUE
    0x80805FC8
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl1_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl1"
    VALUE
    0x80805FC9
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl10_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl10"
    VALUE
    0x80805FCA
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl10Dev_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl10Dev"
    VALUE
    0x80805FCB
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl10OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl10OR"
    VALUE
    0x80805FCC
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl11_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl11"
    VALUE
    0x80805FCD
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl11Dev_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl11Dev"
    VALUE
    0x80805FCE
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl11OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl11OR"
    VALUE
    0x80805FCF
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl12_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl12"
    VALUE
    0x80805FD0
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl12Dev_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl12Dev"
    VALUE
    0x80805FD1
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl12OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl12OR"
    VALUE
    0x80805FD2
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl13_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl13"
    VALUE
    0x80805FD3
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl13Dev_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl13Dev"
    VALUE
    0x80805FD4
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl13OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl13OR"
    VALUE
    0x80805FD5
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl14_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl14"
    VALUE
    0x80805FD6
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl14Dev_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl14Dev"
    VALUE
    0x80805FD7
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl14OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl14OR"
    VALUE
    0x80805FD8
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl15_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl15"
    VALUE
    0x80805FD9
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl15Dev_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl15Dev"
    VALUE
    0x80805FDA
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl15OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl15OR"
    VALUE
    0x80805FDB
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl16_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl16"
    VALUE
    0x80805FDC
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl16Dev_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl16Dev"
    VALUE
    0x80805FDD
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl16OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl16OR"
    VALUE
    0x80805FDE
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl17_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl17"
    VALUE
    0x80805FDF
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl17Dev_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl17Dev"
    VALUE
    0x80805FE0
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl17OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl17OR"
    VALUE
    0x80805FE1
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl18_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl18"
    VALUE
    0x80805FE2
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl18Dev_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl18Dev"
    VALUE
    0x80805FE3
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl18OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl18OR"
    VALUE
    0x80805FE4
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl1Dev_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl1Dev"
    VALUE
    0x80805FE5
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl1OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl1OR"
    VALUE
    0x80805FE6
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl2_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl2"
    VALUE
    0x80805FE7
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl2Dev_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl2Dev"
    VALUE
    0x80805FE8
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl2OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl2OR"
    VALUE
    0x80805FE9
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl3_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl3"
    VALUE
    0x80805FEA
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl3Dev_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl3Dev"
    VALUE
    0x80805FEB
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl3OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl3OR"
    VALUE
    0x80805FEC
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl4_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl4"
    VALUE
    0x80805FED
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl4Dev_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl4Dev"
    VALUE
    0x80805FEE
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl4OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl4OR"
    VALUE
    0x80805FEF
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl5_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl5"
    VALUE
    0x80805FF0
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl5Dev_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl5Dev"
    VALUE
    0x80805FF1
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl5OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl5OR"
    VALUE
    0x80805FF2
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl6_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl6"
    VALUE
    0x80805FF3
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl6Dev_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl6Dev"
    VALUE
    0x80805FF4
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl6OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl6OR"
    VALUE
    0x80805FF5
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl7_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl7"
    VALUE
    0x80805FF6
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl7Dev_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl7Dev"
    VALUE
    0x80805FF7
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl7OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl7OR"
    VALUE
    0x80805FF8
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl8_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl8"
    VALUE
    0x80805FF9
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl8Dev_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl8Dev"
    VALUE
    0x80805FFA
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl8OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl8OR"
    VALUE
    0x80805FFB
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl9_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl9"
    VALUE
    0x80805FFC
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl9Dev_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl9Dev"
    VALUE
    0x80805FFD
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl9OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl9OR"
    VALUE
    0x80805FFE
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutDevError_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutDevError"
    VALUE
    0x80805FFF
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutGetStatus_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutGetStatus"
    VALUE
    0x80806000
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutIgnoreError_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutIgnoreError"
    VALUE
    0x80806001
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutResetError_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutResetError"
    VALUE
    0x80806002
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutUnlock_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutUnlock"
    VALUE
    0x80806003
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safout_cfgDiag_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safout_cfgDiag"
    VALUE
    0x80806004
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_secAccessDenied_RC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_secAccessDenied_RC"
    VALUE
    0x80806005
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_secAccessDenied_WDBI_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_secAccessDenied_WDBI"
    VALUE
    0x80806006
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_secEvalRespKey_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_secEvalRespKey"
    VALUE
    0x80806007
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_secFlashingFailure_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_secFlashingFailure"
    VALUE
    0x80806008
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_secGetLevel_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_secGetLevel"
    VALUE
    0x80806009
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_secGetRnd_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_secGetRnd"
    VALUE
    0x8080600A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_secGetSeed_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_secGetSeed"
    VALUE
    0x8080600B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_secInvalidPassword_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_secInvalidPassword"
    VALUE
    0x8080600C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_secIsRequestAllowed_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_secIsRequestAllowed"
    VALUE
    0x8080600D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_secResetLevel_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_secResetLevel"
    VALUE
    0x8080600E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_secSaveSecret_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_secSaveSecret"
    VALUE
    0x8080600F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_secSetLevel_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_secSetLevel"
    VALUE
    0x80806010
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_sysAit_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_sysAit"
    VALUE
    0x80806011
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_sysAiv_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_sysAiv"
    VALUE
    0x80806012
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_sysDi_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_sysDi"
    VALUE
    0x80806013
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_sysDo_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_sysDo"
    VALUE
    0x80806014
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_sysGetVss_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_sysGetVss"
    VALUE
    0x80806015
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_sysInit_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_sysInit"
    VALUE
    0x80806016
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_sysOperHrIntegrityErr_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_sysOperHrIntegrityErr"
    VALUE
    0x80806017
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_sysOperHrsSaturated_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_sysOperHrsSaturated"
    VALUE
    0x80806018
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_sysSetVss_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_sysSetVss"
    VALUE
    0x80806019
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_sys_coreload_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_sys_coreload"
    VALUE
    0x8080601A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_sys_taskload_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_sys_taskload"
    VALUE
    0x8080601B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_OV_VSS1_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_OV_VSS1"
    VALUE
    0x8080601C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_OV_VSS2_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_OV_VSS2"
    VALUE
    0x8080601D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_UV_VSS1_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_UV_VSS1"
    VALUE
    0x8080601E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_UV_VSS2_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_UV_VSS2"
    VALUE
    0x8080601F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_CANSM_E_BUS_OFF_NETWORK_0_C
    "used environment signals / Reference to used environment condition set for check DFC_CANSM_E_BUS_OFF_NETWORK_0"
    VALUE
    0x80806020
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_CANSM_E_BUS_OFF_NETWORK_1_C
    "used environment signals / Reference to used environment condition set for check DFC_CANSM_E_BUS_OFF_NETWORK_1"
    VALUE
    0x80806021
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_CANSM_E_BUS_OFF_NETWORK_2_C
    "used environment signals / Reference to used environment condition set for check DFC_CANSM_E_BUS_OFF_NETWORK_2"
    VALUE
    0x80806022
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_CANSM_E_BUS_OFF_NETWORK_3_C
    "used environment signals / Reference to used environment condition set for check DFC_CANSM_E_BUS_OFF_NETWORK_3"
    VALUE
    0x80806023
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_CANTRCV_E_NO_TRCV_CONTROL_0_C
    "used environment signals / Reference to used environment condition set for check DFC_CANTRCV_E_NO_TRCV_CONTROL_0"
    VALUE
    0x80806024
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_CAN_E_TIMEOUT_C
    "used environment signals / Reference to used environment condition set for check DFC_CAN_E_TIMEOUT"
    VALUE
    0x80806025
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_COMM_E_NET_START_IND_CHANNEL_0_C
    "used environment signals / Reference to used environment condition set for check DFC_COMM_E_NET_START_IND_CHANNEL_0"
    VALUE
    0x80806026
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_COMM_E_NET_START_IND_CHANNEL_1_C
    "used environment signals / Reference to used environment condition set for check DFC_COMM_E_NET_START_IND_CHANNEL_1"
    VALUE
    0x80806027
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_COMM_E_NET_START_IND_CHANNEL_2_C
    "used environment signals / Reference to used environment condition set for check DFC_COMM_E_NET_START_IND_CHANNEL_2"
    VALUE
    0x80806028
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_COMM_E_NET_START_IND_CHANNEL_3_C
    "used environment signals / Reference to used environment condition set for check DFC_COMM_E_NET_START_IND_CHANNEL_3"
    VALUE
    0x80806029
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_COMM_E_NET_START_IND_CHANNEL_4_C
    "used environment signals / Reference to used environment condition set for check DFC_COMM_E_NET_START_IND_CHANNEL_4"
    VALUE
    0x8080602A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_COMM_E_NET_START_IND_CHANNEL_5_C
    "used environment signals / Reference to used environment condition set for check DFC_COMM_E_NET_START_IND_CHANNEL_5"
    VALUE
    0x8080602B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_LIN_E_TIMEOUT_C
    "used environment signals / Reference to used environment condition set for check DFC_LIN_E_TIMEOUT"
    VALUE
    0x8080602C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rba_MultiStackTrace_Threshold_C
    "used environment signals / Reference to used environment condition set for check DFC_rba_MultiStackTrace_Threshold"
    VALUE
    0x8080602D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_ETH_E_ACCESS_0_C
    "used environment signals / Reference to used environment condition set for check DFC_ETH_E_ACCESS_0"
    VALUE
    0x8080602E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_RBA_IOEXTLIB_KEEPALIVE_DRV_C
    "used environment signals / Reference to used environment condition set for check DFC_RBA_IOEXTLIB_KEEPALIVE_DRV"
    VALUE
    0x8080602F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_RBA_IOEXTLIB_KEEPALIVE_INI_C
    "used environment signals / Reference to used environment condition set for check DFC_RBA_IOEXTLIB_KEEPALIVE_INI"
    VALUE
    0x80806030
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rba_MRly_Diag_Stk_Event_C
    "used environment signals / Reference to used environment condition set for check DFC_rba_MRly_Diag_Stk_Event"
    VALUE
    0x80806031
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rba_MemDiagExtd_MemReadSngErr_C
    "used environment signals / Reference to used environment condition set for check DFC_rba_MemDiagExtd_MemReadSngErr"
    VALUE
    0x80806032
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rba_MemDiag_MemReadErr_C
    "used environment signals / Reference to used environment condition set for check DFC_rba_MemDiag_MemReadErr"
    VALUE
    0x80806033
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rba_MemDiag_MemWrErr_C
    "used environment signals / Reference to used environment condition set for check DFC_rba_MemDiag_MemWrErr"
    VALUE
    0x80806034
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rba_SyC_IrrSwOffTrigEngRun_Event_C
    "used environment signals / Reference to used environment condition set for check DFC_rba_SyC_IrrSwOffTrigEngRun_Event"
    VALUE
    0x80806035
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rba_T15_Diag_ComInVld_Event_C
    "used environment signals / Reference to used environment condition set for check DFC_rba_T15_Diag_ComInVld_Event"
    VALUE
    0x80806036
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rba_T15_Diag_ComOff_HwOn_Event_C
    "used environment signals / Reference to used environment condition set for check DFC_rba_T15_Diag_ComOff_HwOn_Event"
    VALUE
    0x80806037
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rba_T15_Diag_ComOn_HwOff_Event_C
    "used environment signals / Reference to used environment condition set for check DFC_rba_T15_Diag_ComOn_HwOff_Event"
    VALUE
    0x80806038
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM0_0_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM0_0"
    VALUE
    0x80806039
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM0_1_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM0_1"
    VALUE
    0x8080603A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM0_10_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM0_10"
    VALUE
    0x8080603B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM0_11_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM0_11"
    VALUE
    0x8080603C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM0_13_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM0_13"
    VALUE
    0x8080603D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM0_14_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM0_14"
    VALUE
    0x8080603E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM0_2_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM0_2"
    VALUE
    0x8080603F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM0_22_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM0_22"
    VALUE
    0x80806040
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM0_23_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM0_23"
    VALUE
    0x80806041
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM0_4_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM0_4"
    VALUE
    0x80806042
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM0_5_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM0_5"
    VALUE
    0x80806043
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM0_7_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM0_7"
    VALUE
    0x80806044
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM0_8_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM0_8"
    VALUE
    0x80806045
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM10_16_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM10_16"
    VALUE
    0x80806046
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM10_17_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM10_17"
    VALUE
    0x80806047
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM10_21_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM10_21"
    VALUE
    0x80806048
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM11_0_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM11_0"
    VALUE
    0x80806049
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM11_1_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM11_1"
    VALUE
    0x8080604A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM11_2_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM11_2"
    VALUE
    0x8080604B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM11_3_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM11_3"
    VALUE
    0x8080604C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM11_4_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM11_4"
    VALUE
    0x8080604D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM11_5_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM11_5"
    VALUE
    0x8080604E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM11_8_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM11_8"
    VALUE
    0x8080604F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM11_9_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM11_9"
    VALUE
    0x80806050
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM1_0_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM1_0"
    VALUE
    0x80806051
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM1_1_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM1_1"
    VALUE
    0x80806052
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM1_10_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM1_10"
    VALUE
    0x80806053
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM1_11_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM1_11"
    VALUE
    0x80806054
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM1_13_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM1_13"
    VALUE
    0x80806055
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM1_14_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM1_14"
    VALUE
    0x80806056
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM1_2_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM1_2"
    VALUE
    0x80806057
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM1_22_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM1_22"
    VALUE
    0x80806058
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM1_23_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM1_23"
    VALUE
    0x80806059
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM1_4_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM1_4"
    VALUE
    0x8080605A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM1_5_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM1_5"
    VALUE
    0x8080605B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM1_7_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM1_7"
    VALUE
    0x8080605C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM1_8_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM1_8"
    VALUE
    0x8080605D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM21_0_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM21_0"
    VALUE
    0x8080605E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM21_16_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM21_16"
    VALUE
    0x8080605F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM21_3_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM21_3"
    VALUE
    0x80806060
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM2_1_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM2_1"
    VALUE
    0x80806061
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM2_10_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM2_10"
    VALUE
    0x80806062
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM2_11_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM2_11"
    VALUE
    0x80806063
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM2_13_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM2_13"
    VALUE
    0x80806064
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM2_14_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM2_14"
    VALUE
    0x80806065
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM2_2_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM2_2"
    VALUE
    0x80806066
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM2_22_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM2_22"
    VALUE
    0x80806067
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM2_23_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM2_23"
    VALUE
    0x80806068
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM2_4_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM2_4"
    VALUE
    0x80806069
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM2_5_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM2_5"
    VALUE
    0x8080606A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM2_7_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM2_7"
    VALUE
    0x8080606B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM2_8_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM2_8"
    VALUE
    0x8080606C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM3_1_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM3_1"
    VALUE
    0x8080606D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM3_10_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM3_10"
    VALUE
    0x8080606E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM3_11_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM3_11"
    VALUE
    0x8080606F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM3_13_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM3_13"
    VALUE
    0x80806070
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM3_14_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM3_14"
    VALUE
    0x80806071
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM3_2_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM3_2"
    VALUE
    0x80806072
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM3_22_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM3_22"
    VALUE
    0x80806073
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM3_23_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM3_23"
    VALUE
    0x80806074
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM3_4_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM3_4"
    VALUE
    0x80806075
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM3_5_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM3_5"
    VALUE
    0x80806076
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM3_7_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM3_7"
    VALUE
    0x80806077
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM3_8_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM3_8"
    VALUE
    0x80806078
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM6_0_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM6_0"
    VALUE
    0x80806079
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM6_11_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM6_11"
    VALUE
    0x8080607A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM6_12_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM6_12"
    VALUE
    0x8080607B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM6_14_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM6_14"
    VALUE
    0x8080607C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM6_15_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM6_15"
    VALUE
    0x8080607D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM6_17_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM6_17"
    VALUE
    0x8080607E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM6_18_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM6_18"
    VALUE
    0x8080607F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM6_2_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM6_2"
    VALUE
    0x80806080
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM6_20_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM6_20"
    VALUE
    0x80806081
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM6_21_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM6_21"
    VALUE
    0x80806082
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM6_25_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM6_25"
    VALUE
    0x80806083
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM6_4_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM6_4"
    VALUE
    0x80806084
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM6_5_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM6_5"
    VALUE
    0x80806085
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM6_7_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM6_7"
    VALUE
    0x80806086
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM6_8_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM6_8"
    VALUE
    0x80806087
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM7_1_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM7_1"
    VALUE
    0x80806088
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM7_12_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM7_12"
    VALUE
    0x80806089
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM7_13_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM7_13"
    VALUE
    0x8080608A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM7_14_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM7_14"
    VALUE
    0x8080608B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM7_15_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM7_15"
    VALUE
    0x8080608C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM7_16_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM7_16"
    VALUE
    0x8080608D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM7_17_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM7_17"
    VALUE
    0x8080608E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM7_2_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM7_2"
    VALUE
    0x8080608F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM7_20_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM7_20"
    VALUE
    0x80806090
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM7_25_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM7_25"
    VALUE
    0x80806091
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM7_26_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM7_26"
    VALUE
    0x80806092
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM7_28_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM7_28"
    VALUE
    0x80806093
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM7_29_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM7_29"
    VALUE
    0x80806094
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM7_30_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM7_30"
    VALUE
    0x80806095
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM7_31_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM7_31"
    VALUE
    0x80806096
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM8_0_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM8_0"
    VALUE
    0x80806097
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM8_1_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM8_1"
    VALUE
    0x80806098
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM8_10_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM8_10"
    VALUE
    0x80806099
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM8_11_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM8_11"
    VALUE
    0x8080609A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM8_12_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM8_12"
    VALUE
    0x8080609B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM8_13_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM8_13"
    VALUE
    0x8080609C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM8_16_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM8_16"
    VALUE
    0x8080609D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM8_18_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM8_18"
    VALUE
    0x8080609E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM8_2_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM8_2"
    VALUE
    0x8080609F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM8_3_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM8_3"
    VALUE
    0x808060A0
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM8_30_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM8_30"
    VALUE
    0x808060A1
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM8_31_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM8_31"
    VALUE
    0x808060A2
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM8_4_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM8_4"
    VALUE
    0x808060A3
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM9_0_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM9_0"
    VALUE
    0x808060A4
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM9_1_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM9_1"
    VALUE
    0x808060A5
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM9_15_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM9_15"
    VALUE
    0x808060A6
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM9_3_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM9_3"
    VALUE
    0x808060A7
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MoCSOPICO_C
    "used environment signals / Reference to used environment condition set for check DFC_MoCSOPICO"
    VALUE
    0x808060A8
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MoFVarPostBldSel_C
    "used environment signals / Reference to used environment condition set for check DFC_MoFVarPostBldSel"
    VALUE
    0x808060A9
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MoSysCtrlReIni_C
    "used environment signals / Reference to used environment condition set for check DFC_MoSysCtrlReIni"
    VALUE
    0x808060AA
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MoXEMMHwLTMCUFW_C
    "used environment signals / Reference to used environment condition set for check DFC_MoXEMMHwLTMCUFW"
    VALUE
    0x808060AB
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MoXEMMHwLTMonBIST_C
    "used environment signals / Reference to used environment condition set for check DFC_MoXEMMHwLTMonBIST"
    VALUE
    0x808060AC
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MoXEMMHwLTRegMonTest_C
    "used environment signals / Reference to used environment condition set for check DFC_MoXEMMHwLTRegMonTest"
    VALUE
    0x808060AD
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MoXEMMHwLTStbySMUAlvTest_C
    "used environment signals / Reference to used environment condition set for check DFC_MoXEMMHwLTStbySMUAlvTest"
    VALUE
    0x808060AE
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MoXEMMHwLTTempSens_C
    "used environment signals / Reference to used environment condition set for check DFC_MoXEMMHwLTTempSens"
    VALUE
    0x808060AF
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MoXEMMHwLTUCBCfg_C
    "used environment signals / Reference to used environment condition set for check DFC_MoXEMMHwLTUCBCfg"
    VALUE
    0x808060B0
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_OCWDAABEActv_C
    "used environment signals / Reference to used environment condition set for check DFC_OCWDAABEActv"
    VALUE
    0x808060B1
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_OCWDACom_C
    "used environment signals / Reference to used environment condition set for check DFC_OCWDACom"
    VALUE
    0x808060B2
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_OCWDAErrPin_C
    "used environment signals / Reference to used environment condition set for check DFC_OCWDAErrPin"
    VALUE
    0x808060B3
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_SWReset_0_C
    "used environment signals / Reference to used environment condition set for check DFC_SWReset_0"
    VALUE
    0x808060B4
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_SWReset_1_C
    "used environment signals / Reference to used environment condition set for check DFC_SWReset_1"
    VALUE
    0x808060B5
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_SWReset_2_C
    "used environment signals / Reference to used environment condition set for check DFC_SWReset_2"
    VALUE
    0x808060B6
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDebFault1_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDebFault1"
    VALUE
    0x808060B7
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_Unused_C
    "assigned fault type / "
    VALUE
    0x808060B8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    READ_ONLY

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_TimeInRowDebFault_C
    "assigned fault type / Fault type assignment for check DFC_bds_TimeInRowDebFault"
    VALUE
    0x808060B9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_EventInRowDebFault_C
    "assigned fault type / Fault type assignment for check DFC_bds_EventInRowDebFault"
    VALUE
    0x808060BA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_DevLibBattUHi_C
    "assigned fault type / Fault type assignment for check DFC_DevLibBattUHi"
    VALUE
    0x808060BB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_DevLibBattULo_C
    "assigned fault type / Fault type assignment for check DFC_DevLibBattULo"
    VALUE
    0x808060BC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_TimeUpDownDebFault_C
    "assigned fault type / Fault type assignment for check DFC_bds_TimeUpDownDebFault"
    VALUE
    0x808060BD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA13OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA13OR"
    VALUE
    0x808060BE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA13SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA13SCB"
    VALUE
    0x808060BF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA13SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA13SCG"
    VALUE
    0x808060C0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA14OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA14OR"
    VALUE
    0x808060C1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA14SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA14SCB"
    VALUE
    0x808060C2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA14SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA14SCG"
    VALUE
    0x808060C3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA21OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA21OR"
    VALUE
    0x808060C4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA21SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA21SCB"
    VALUE
    0x808060C5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA21SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA21SCG"
    VALUE
    0x808060C6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA22OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA22OR"
    VALUE
    0x808060C7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA22SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA22SCB"
    VALUE
    0x808060C8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA22SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA22SCG"
    VALUE
    0x808060C9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA23OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA23OR"
    VALUE
    0x808060CA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA23SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA23SCB"
    VALUE
    0x808060CB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA23SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA23SCG"
    VALUE
    0x808060CC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA24OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA24OR"
    VALUE
    0x808060CD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA24SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA24SCB"
    VALUE
    0x808060CE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA24SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA24SCG"
    VALUE
    0x808060CF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA25OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA25OR"
    VALUE
    0x808060D0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA25SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA25SCB"
    VALUE
    0x808060D1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA25SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA25SCG"
    VALUE
    0x808060D2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA26OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA26OR"
    VALUE
    0x808060D3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA26SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA26SCB"
    VALUE
    0x808060D4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA26SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA26SCG"
    VALUE
    0x808060D5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA27OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA27OR"
    VALUE
    0x808060D6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA27SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA27SCB"
    VALUE
    0x808060D7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA27SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA27SCG"
    VALUE
    0x808060D8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA28OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA28OR"
    VALUE
    0x808060D9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA28SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA28SCB"
    VALUE
    0x808060DA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA28SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA28SCG"
    VALUE
    0x808060DB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA29OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA29OR"
    VALUE
    0x808060DC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA29SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA29SCB"
    VALUE
    0x808060DD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA29SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA29SCG"
    VALUE
    0x808060DE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA36AicSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA36AicSCB"
    VALUE
    0x808060DF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA36AicSCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA36AicSCG"
    VALUE
    0x808060E0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA36OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA36OR"
    VALUE
    0x808060E1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA36SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA36SCB"
    VALUE
    0x808060E2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA36SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA36SCG"
    VALUE
    0x808060E3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA36ShuntSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA36ShuntSCB"
    VALUE
    0x808060E4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA37AicSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA37AicSCB"
    VALUE
    0x808060E5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA37AicSCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA37AicSCG"
    VALUE
    0x808060E6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA37OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA37OR"
    VALUE
    0x808060E7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA37SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA37SCB"
    VALUE
    0x808060E8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA37SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA37SCG"
    VALUE
    0x808060E9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA37ShuntSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA37ShuntSCB"
    VALUE
    0x808060EA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA38AicSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA38AicSCB"
    VALUE
    0x808060EB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA38AicSCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA38AicSCG"
    VALUE
    0x808060EC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA38OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA38OR"
    VALUE
    0x808060ED
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA38SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA38SCB"
    VALUE
    0x808060EE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA38SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA38SCG"
    VALUE
    0x808060EF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

