    DDRC_DurDeb.DFC_rbr_outA47OT_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA47OT"
    VALUE
    0x808004B0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA47OT_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA47OT"
    VALUE
    0x808004B2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA47SCB_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA47SCB"
    VALUE
    0x808004B4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA47SCB_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA47SCB"
    VALUE
    0x808004B6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA47SCG_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA47SCG"
    VALUE
    0x808004B8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA47SCG_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA47SCG"
    VALUE
    0x808004BA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA48OL_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA48OL"
    VALUE
    0x808004BC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA48OL_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA48OL"
    VALUE
    0x808004BE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA48OR_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA48OR"
    VALUE
    0x808004C0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA48OR_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA48OR"
    VALUE
    0x808004C2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA48OT_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA48OT"
    VALUE
    0x808004C4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA48OT_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA48OT"
    VALUE
    0x808004C6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA48SCB_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA48SCB"
    VALUE
    0x808004C8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA48SCB_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA48SCB"
    VALUE
    0x808004CA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA48SCG_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA48SCG"
    VALUE
    0x808004CC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA48SCG_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA48SCG"
    VALUE
    0x808004CE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA49OL_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA49OL"
    VALUE
    0x808004D0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA49OL_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA49OL"
    VALUE
    0x808004D2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA49OT_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA49OT"
    VALUE
    0x808004D4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA49OT_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA49OT"
    VALUE
    0x808004D6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA49SCB_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA49SCB"
    VALUE
    0x808004D8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA49SCB_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA49SCB"
    VALUE
    0x808004DA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA49SCG_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA49SCG"
    VALUE
    0x808004DC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA49SCG_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA49SCG"
    VALUE
    0x808004DE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA50OL_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA50OL"
    VALUE
    0x808004E0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA50OL_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA50OL"
    VALUE
    0x808004E2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA50OT_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA50OT"
    VALUE
    0x808004E4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA50OT_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA50OT"
    VALUE
    0x808004E6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA50SCB_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA50SCB"
    VALUE
    0x808004E8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA50SCB_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA50SCB"
    VALUE
    0x808004EA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA50SCG_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA50SCG"
    VALUE
    0x808004EC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA50SCG_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA50SCG"
    VALUE
    0x808004EE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA51OL_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA51OL"
    VALUE
    0x808004F0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA51OL_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA51OL"
    VALUE
    0x808004F2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA51OR_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA51OR"
    VALUE
    0x808004F4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA51OR_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA51OR"
    VALUE
    0x808004F6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA51OT_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA51OT"
    VALUE
    0x808004F8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA51OT_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA51OT"
    VALUE
    0x808004FA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA51SCB_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA51SCB"
    VALUE
    0x808004FC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA51SCB_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA51SCB"
    VALUE
    0x808004FE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA51SCG_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA51SCG"
    VALUE
    0x80800500
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA51SCG_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA51SCG"
    VALUE
    0x80800502
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA52OL_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA52OL"
    VALUE
    0x80800504
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA52OL_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA52OL"
    VALUE
    0x80800506
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA52OR_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA52OR"
    VALUE
    0x80800508
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA52OR_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA52OR"
    VALUE
    0x8080050A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA52OT_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA52OT"
    VALUE
    0x8080050C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA52OT_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA52OT"
    VALUE
    0x8080050E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA52SCB_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA52SCB"
    VALUE
    0x80800510
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA52SCB_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA52SCB"
    VALUE
    0x80800512
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA52SCG_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA52SCG"
    VALUE
    0x80800514
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA52SCG_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA52SCG"
    VALUE
    0x80800516
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA53OL_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA53OL"
    VALUE
    0x80800518
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA53OL_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA53OL"
    VALUE
    0x8080051A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA53OR_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA53OR"
    VALUE
    0x8080051C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA53OR_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA53OR"
    VALUE
    0x8080051E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA53OT_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA53OT"
    VALUE
    0x80800520
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA53OT_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA53OT"
    VALUE
    0x80800522
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA53SCB_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA53SCB"
    VALUE
    0x80800524
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA53SCB_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA53SCB"
    VALUE
    0x80800526
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA53SCG_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA53SCG"
    VALUE
    0x80800528
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA53SCG_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA53SCG"
    VALUE
    0x8080052A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA54OL_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA54OL"
    VALUE
    0x8080052C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA54OL_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA54OL"
    VALUE
    0x8080052E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA54OR_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA54OR"
    VALUE
    0x80800530
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA54OR_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA54OR"
    VALUE
    0x80800532
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA54OT_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA54OT"
    VALUE
    0x80800534
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA54OT_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA54OT"
    VALUE
    0x80800536
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA54SCB_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA54SCB"
    VALUE
    0x80800538
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA54SCB_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA54SCB"
    VALUE
    0x8080053A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA54SCG_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA54SCG"
    VALUE
    0x8080053C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA54SCG_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA54SCG"
    VALUE
    0x8080053E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA55OL_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA55OL"
    VALUE
    0x80800540
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA55OL_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA55OL"
    VALUE
    0x80800542
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA55OT_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA55OT"
    VALUE
    0x80800544
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA55OT_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA55OT"
    VALUE
    0x80800546
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA55SCB_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA55SCB"
    VALUE
    0x80800548
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA55SCB_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA55SCB"
    VALUE
    0x8080054A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA55SCG_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA55SCG"
    VALUE
    0x8080054C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA55SCG_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA55SCG"
    VALUE
    0x8080054E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA56OL_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA56OL"
    VALUE
    0x80800550
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA56OL_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA56OL"
    VALUE
    0x80800552
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA56OT_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA56OT"
    VALUE
    0x80800554
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA56OT_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA56OT"
    VALUE
    0x80800556
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA56SCB_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA56SCB"
    VALUE
    0x80800558
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA56SCB_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA56SCB"
    VALUE
    0x8080055A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA56SCG_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA56SCG"
    VALUE
    0x8080055C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA56SCG_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA56SCG"
    VALUE
    0x8080055E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA58OL_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA58OL"
    VALUE
    0x80800560
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA58OL_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA58OL"
    VALUE
    0x80800562
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA58OT_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA58OT"
    VALUE
    0x80800564
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA58OT_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA58OT"
    VALUE
    0x80800566
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA58SCB_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA58SCB"
    VALUE
    0x80800568
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA58SCB_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA58SCB"
    VALUE
    0x8080056A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA58SCG_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA58SCG"
    VALUE
    0x8080056C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA58SCG_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA58SCG"
    VALUE
    0x8080056E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outK14OR_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK14OR"
    VALUE
    0x80800570
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outK14OR_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK14OR"
    VALUE
    0x80800572
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outK15OR_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK15OR"
    VALUE
    0x80800574
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outK15OR_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK15OR"
    VALUE
    0x80800576
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outK16OR_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK16OR"
    VALUE
    0x80800578
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outK16OR_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK16OR"
    VALUE
    0x8080057A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outK17OL_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK17OL"
    VALUE
    0x8080057C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outK17OL_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK17OL"
    VALUE
    0x8080057E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outK17OR_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK17OR"
    VALUE
    0x80800580
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outK17OR_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK17OR"
    VALUE
    0x80800582
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outK17OT_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK17OT"
    VALUE
    0x80800584
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outK17OT_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK17OT"
    VALUE
    0x80800586
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outK17SCB_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK17SCB"
    VALUE
    0x80800588
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outK17SCB_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK17SCB"
    VALUE
    0x8080058A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outK17SCG_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK17SCG"
    VALUE
    0x8080058C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outK17SCG_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK17SCG"
    VALUE
    0x8080058E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DevLib_tiBattUHiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_DevLibBattUHi"
    VALUE
    0x80800590
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DevLib_tiBattUHiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_DevLibBattUHi"
    VALUE
    0x80800592
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DevLib_tiBattULoDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_DevLibBattULo"
    VALUE
    0x80800594
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DevLib_tiBattULoDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_DevLibBattULo"
    VALUE
    0x80800596
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.bds_dsm_TimeUpDownDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_TimeUpDownDebFault"
    VALUE
    0x80800598
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.bds_dsm_TimeUpDownDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_TimeUpDownDebFault"
    VALUE
    0x8080059A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tK44SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK44SCB"
    VALUE
    0x8080059C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tK44SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK44SCB"
    VALUE
    0x8080059E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA13ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA13OR"
    VALUE
    0x808005A0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA13ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA13OR"
    VALUE
    0x808005A2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA13SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA13SCB"
    VALUE
    0x808005A4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA13SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA13SCB"
    VALUE
    0x808005A6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA13SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA13SCG"
    VALUE
    0x808005A8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA13SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA13SCG"
    VALUE
    0x808005AA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA14ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA14OR"
    VALUE
    0x808005AC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA14ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA14OR"
    VALUE
    0x808005AE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA14SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA14SCB"
    VALUE
    0x808005B0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA14SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA14SCB"
    VALUE
    0x808005B2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA14SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA14SCG"
    VALUE
    0x808005B4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA14SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA14SCG"
    VALUE
    0x808005B6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA21ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA21OR"
    VALUE
    0x808005B8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA21ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA21OR"
    VALUE
    0x808005BA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA21SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA21SCB"
    VALUE
    0x808005BC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA21SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA21SCB"
    VALUE
    0x808005BE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA21SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA21SCG"
    VALUE
    0x808005C0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA21SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA21SCG"
    VALUE
    0x808005C2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA22ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA22OR"
    VALUE
    0x808005C4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA22ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA22OR"
    VALUE
    0x808005C6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA22SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA22SCB"
    VALUE
    0x808005C8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA22SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA22SCB"
    VALUE
    0x808005CA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA22SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA22SCG"
    VALUE
    0x808005CC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA22SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA22SCG"
    VALUE
    0x808005CE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA23ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA23OR"
    VALUE
    0x808005D0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA23ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA23OR"
    VALUE
    0x808005D2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA23SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA23SCB"
    VALUE
    0x808005D4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA23SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA23SCB"
    VALUE
    0x808005D6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA23SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA23SCG"
    VALUE
    0x808005D8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA23SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA23SCG"
    VALUE
    0x808005DA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA24ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA24OR"
    VALUE
    0x808005DC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA24ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA24OR"
    VALUE
    0x808005DE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA24SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA24SCB"
    VALUE
    0x808005E0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA24SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA24SCB"
    VALUE
    0x808005E2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA24SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA24SCG"
    VALUE
    0x808005E4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA24SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA24SCG"
    VALUE
    0x808005E6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA25ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA25OR"
    VALUE
    0x808005E8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA25ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA25OR"
    VALUE
    0x808005EA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA25SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA25SCB"
    VALUE
    0x808005EC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA25SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA25SCB"
    VALUE
    0x808005EE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA25SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA25SCG"
    VALUE
    0x808005F0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA25SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA25SCG"
    VALUE
    0x808005F2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA26ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA26OR"
    VALUE
    0x808005F4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA26ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA26OR"
    VALUE
    0x808005F6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA26SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA26SCB"
    VALUE
    0x808005F8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA26SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA26SCB"
    VALUE
    0x808005FA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA26SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA26SCG"
    VALUE
    0x808005FC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA26SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA26SCG"
    VALUE
    0x808005FE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA27ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA27OR"
    VALUE
    0x80800600
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA27ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA27OR"
    VALUE
    0x80800602
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA27SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA27SCB"
    VALUE
    0x80800604
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA27SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA27SCB"
    VALUE
    0x80800606
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA27SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA27SCG"
    VALUE
    0x80800608
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA27SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA27SCG"
    VALUE
    0x8080060A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA28ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA28OR"
    VALUE
    0x8080060C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA28ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA28OR"
    VALUE
    0x8080060E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA28SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA28SCB"
    VALUE
    0x80800610
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA28SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA28SCB"
    VALUE
    0x80800612
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA28SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA28SCG"
    VALUE
    0x80800614
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA28SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA28SCG"
    VALUE
    0x80800616
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA29ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA29OR"
    VALUE
    0x80800618
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA29ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA29OR"
    VALUE
    0x8080061A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA29SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA29SCB"
    VALUE
    0x8080061C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA29SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA29SCB"
    VALUE
    0x8080061E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA29SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA29SCG"
    VALUE
    0x80800620
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA29SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA29SCG"
    VALUE
    0x80800622
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA36AicSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA36AicSCB"
    VALUE
    0x80800624
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA36AicSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA36AicSCB"
    VALUE
    0x80800626
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA36AicSCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA36AicSCG"
    VALUE
    0x80800628
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA36AicSCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA36AicSCG"
    VALUE
    0x8080062A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA36ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA36OR"
    VALUE
    0x8080062C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA36ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA36OR"
    VALUE
    0x8080062E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA36SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA36SCB"
    VALUE
    0x80800630
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA36SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA36SCB"
    VALUE
    0x80800632
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA36SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA36SCG"
    VALUE
    0x80800634
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA36SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA36SCG"
    VALUE
    0x80800636
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA36ShuntSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA36ShuntSCB"
    VALUE
    0x80800638
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA36ShuntSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA36ShuntSCB"
    VALUE
    0x8080063A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA37AicSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA37AicSCB"
    VALUE
    0x8080063C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA37AicSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA37AicSCB"
    VALUE
    0x8080063E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA37AicSCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA37AicSCG"
    VALUE
    0x80800640
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA37AicSCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA37AicSCG"
    VALUE
    0x80800642
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA37ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA37OR"
    VALUE
    0x80800644
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA37ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA37OR"
    VALUE
    0x80800646
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA37SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA37SCB"
    VALUE
    0x80800648
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA37SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA37SCB"
    VALUE
    0x8080064A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA37SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA37SCG"
    VALUE
    0x8080064C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA37SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA37SCG"
    VALUE
    0x8080064E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA37ShuntSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA37ShuntSCB"
    VALUE
    0x80800650
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA37ShuntSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA37ShuntSCB"
    VALUE
    0x80800652
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA38AicSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA38AicSCB"
    VALUE
    0x80800654
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA38AicSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA38AicSCB"
    VALUE
    0x80800656
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA38AicSCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA38AicSCG"
    VALUE
    0x80800658
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA38AicSCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA38AicSCG"
    VALUE
    0x8080065A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA38ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA38OR"
    VALUE
    0x8080065C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA38ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA38OR"
    VALUE
    0x8080065E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA38SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA38SCB"
    VALUE
    0x80800660
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA38SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA38SCB"
    VALUE
    0x80800662
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA38SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA38SCG"
    VALUE
    0x80800664
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA38SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA38SCG"
    VALUE
    0x80800666
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA38ShuntSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA38ShuntSCB"
    VALUE
    0x80800668
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA38ShuntSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA38ShuntSCB"
    VALUE
    0x8080066A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA39AicSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA39AicSCB"
    VALUE
    0x8080066C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA39AicSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA39AicSCB"
    VALUE
    0x8080066E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA39AicSCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA39AicSCG"
    VALUE
    0x80800670
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA39AicSCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA39AicSCG"
    VALUE
    0x80800672
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA39ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA39OR"
    VALUE
    0x80800674
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA39ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA39OR"
    VALUE
    0x80800676
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA39SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA39SCB"
    VALUE
    0x80800678
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA39SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA39SCB"
    VALUE
    0x8080067A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA39SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA39SCG"
    VALUE
    0x8080067C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA39SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA39SCG"
    VALUE
    0x8080067E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA39ShuntSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA39ShuntSCB"
    VALUE
    0x80800680
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA39ShuntSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA39ShuntSCB"
    VALUE
    0x80800682
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA40ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA40OR"
    VALUE
    0x80800684
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA40ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA40OR"
    VALUE
    0x80800686
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA40SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA40SCB"
    VALUE
    0x80800688
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA40SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA40SCB"
    VALUE
    0x8080068A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA40SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA40SCG"
    VALUE
    0x8080068C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA40SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA40SCG"
    VALUE
    0x8080068E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA41ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA41OR"
    VALUE
    0x80800690
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA41ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA41OR"
    VALUE
    0x80800692
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA41SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA41SCB"
    VALUE
    0x80800694
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA41SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA41SCB"
    VALUE
    0x80800696
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA41SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA41SCG"
    VALUE
    0x80800698
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA41SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA41SCG"
    VALUE
    0x8080069A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA42ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA42OR"
    VALUE
    0x8080069C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA42ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA42OR"
    VALUE
    0x8080069E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA42SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA42SCB"
    VALUE
    0x808006A0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA42SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA42SCB"
    VALUE
    0x808006A2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA42SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA42SCG"
    VALUE
    0x808006A4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA42SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA42SCG"
    VALUE
    0x808006A6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA43AicSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA43AicSCB"
    VALUE
    0x808006A8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA43AicSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA43AicSCB"
    VALUE
    0x808006AA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA43AicSCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA43AicSCG"
    VALUE
    0x808006AC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA43AicSCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA43AicSCG"
    VALUE
    0x808006AE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA43ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA43OR"
    VALUE
    0x808006B0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA43ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA43OR"
    VALUE
    0x808006B2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA43SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA43SCB"
    VALUE
    0x808006B4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA43SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA43SCB"
    VALUE
    0x808006B6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA43SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA43SCG"
    VALUE
    0x808006B8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA43SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA43SCG"
    VALUE
    0x808006BA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA43ShuntSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA43ShuntSCB"
    VALUE
    0x808006BC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA43ShuntSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA43ShuntSCB"
    VALUE
    0x808006BE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA44OLDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA44OL"
    VALUE
    0x808006C0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA44OLDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA44OL"
    VALUE
    0x808006C2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA44SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA44SCB"
    VALUE
    0x808006C4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA44SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA44SCB"
    VALUE
    0x808006C6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA44SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA44SCG"
    VALUE
    0x808006C8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA44SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA44SCG"
    VALUE
    0x808006CA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA57ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA57OR"
    VALUE
    0x808006CC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA57ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA57OR"
    VALUE
    0x808006CE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA57SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA57SCB"
    VALUE
    0x808006D0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA57SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA57SCB"
    VALUE
    0x808006D2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA57SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA57SCG"
    VALUE
    0x808006D4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA57SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA57SCG"
    VALUE
    0x808006D6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA59OLDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA59OL"
    VALUE
    0x808006D8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA59OLDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA59OL"
    VALUE
    0x808006DA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA59SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA59SCB"
    VALUE
    0x808006DC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA59SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA59SCB"
    VALUE
    0x808006DE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA59SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA59SCG"
    VALUE
    0x808006E0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA59SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA59SCG"
    VALUE
    0x808006E2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK10ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK10OR"
    VALUE
    0x808006E4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK10ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK10OR"
    VALUE
    0x808006E6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK10SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK10SCB"
    VALUE
    0x808006E8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK10SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK10SCB"
    VALUE
    0x808006EA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK10SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK10SCG"
    VALUE
    0x808006EC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK10SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK10SCG"
    VALUE
    0x808006EE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK11ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK11OR"
    VALUE
    0x808006F0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK11ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK11OR"
    VALUE
    0x808006F2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK11SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK11SCB"
    VALUE
    0x808006F4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK11SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK11SCB"
    VALUE
    0x808006F6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK11SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK11SCG"
    VALUE
    0x808006F8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK11SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK11SCG"
    VALUE
    0x808006FA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK30AicSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK30AicSCB"
    VALUE
    0x808006FC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK30AicSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK30AicSCB"
    VALUE
    0x808006FE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK30AicSCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK30AicSCG"
    VALUE
    0x80800700
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK30AicSCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK30AicSCG"
    VALUE
    0x80800702
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK30ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK30OR"
    VALUE
    0x80800704
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK30ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK30OR"
    VALUE
    0x80800706
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK30SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK30SCB"
    VALUE
    0x80800708
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK30SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK30SCB"
    VALUE
    0x8080070A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK30SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK30SCG"
    VALUE
    0x8080070C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK30SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK30SCG"
    VALUE
    0x8080070E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK30ShuntSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK30ShuntSCB"
    VALUE
    0x80800710
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK30ShuntSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK30ShuntSCB"
    VALUE
    0x80800712
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK31ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK31OR"
    VALUE
    0x80800714
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK31ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK31OR"
    VALUE
    0x80800716
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK31SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK31SCB"
    VALUE
    0x80800718
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK31SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK31SCB"
    VALUE
    0x8080071A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK31SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK31SCG"
    VALUE
    0x8080071C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK31SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK31SCG"
    VALUE
    0x8080071E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK32ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK32OR"
    VALUE
    0x80800720
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK32ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK32OR"
    VALUE
    0x80800722
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK32SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK32SCB"
    VALUE
    0x80800724
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK32SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK32SCB"
    VALUE
    0x80800726
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK32SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK32SCG"
    VALUE
    0x80800728
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK32SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK32SCG"
    VALUE
    0x8080072A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK33ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK33OR"
    VALUE
    0x8080072C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK33ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK33OR"
    VALUE
    0x8080072E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK33SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK33SCB"
    VALUE
    0x80800730
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK33SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK33SCB"
    VALUE
    0x80800732
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK33SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK33SCG"
    VALUE
    0x80800734
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK33SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK33SCG"
    VALUE
    0x80800736
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK34ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK34OR"
    VALUE
    0x80800738
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK34ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK34OR"
    VALUE
    0x8080073A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK34SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK34SCB"
    VALUE
    0x8080073C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK34SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK34SCB"
    VALUE
    0x8080073E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK34SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK34SCG"
    VALUE
    0x80800740
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK34SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK34SCG"
    VALUE
    0x80800742
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK35ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK35OR"
    VALUE
    0x80800744
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK35ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK35OR"
    VALUE
    0x80800746
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK35SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK35SCB"
    VALUE
    0x80800748
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK35SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK35SCB"
    VALUE
    0x8080074A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK35SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK35SCG"
    VALUE
    0x8080074C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK35SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK35SCG"
    VALUE
    0x8080074E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK36ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK36OR"
    VALUE
    0x80800750
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK36ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK36OR"
    VALUE
    0x80800752
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK36SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK36SCB"
    VALUE
    0x80800754
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK36SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK36SCB"
    VALUE
    0x80800756
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK36SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK36SCG"
    VALUE
    0x80800758
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK36SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK36SCG"
    VALUE
    0x8080075A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK37AicSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK37AicSCB"
    VALUE
    0x8080075C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK37AicSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK37AicSCB"
    VALUE
    0x8080075E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK37AicSCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK37AicSCG"
    VALUE
    0x80800760
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK37AicSCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK37AicSCG"
    VALUE
    0x80800762
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK37ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK37OR"
    VALUE
    0x80800764
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK37ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK37OR"
    VALUE
    0x80800766
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK37SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK37SCB"
    VALUE
    0x80800768
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK37SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK37SCB"
    VALUE
    0x8080076A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK37SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK37SCG"
    VALUE
    0x8080076C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK37SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK37SCG"
    VALUE
    0x8080076E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK37ShuntSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK37ShuntSCB"
    VALUE
    0x80800770
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK37ShuntSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK37ShuntSCB"
    VALUE
    0x80800772
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK38AicSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK38AicSCB"
    VALUE
    0x80800774
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK38AicSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK38AicSCB"
    VALUE
    0x80800776
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK38AicSCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK38AicSCG"
    VALUE
    0x80800778
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK38AicSCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK38AicSCG"
    VALUE
    0x8080077A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK38ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK38OR"
    VALUE
    0x8080077C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK38ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK38OR"
    VALUE
    0x8080077E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK38SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK38SCB"
    VALUE
    0x80800780
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK38SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK38SCB"
    VALUE
    0x80800782
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK38SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK38SCG"
    VALUE
    0x80800784
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK38SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK38SCG"
    VALUE
    0x80800786
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK38ShuntSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK38ShuntSCB"
    VALUE
    0x80800788
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK38ShuntSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK38ShuntSCB"
    VALUE
    0x8080078A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK39AicSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK39AicSCB"
    VALUE
    0x8080078C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK39AicSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK39AicSCB"
    VALUE
    0x8080078E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK39AicSCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK39AicSCG"
    VALUE
    0x80800790
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK39AicSCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK39AicSCG"
    VALUE
    0x80800792
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK39ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK39OR"
    VALUE
    0x80800794
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK39ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK39OR"
    VALUE
    0x80800796
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK39SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK39SCB"
    VALUE
    0x80800798
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK39SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK39SCB"
    VALUE
    0x8080079A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK39SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK39SCG"
    VALUE
    0x8080079C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK39SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK39SCG"
    VALUE
    0x8080079E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK39ShuntSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK39ShuntSCB"
    VALUE
    0x808007A0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK39ShuntSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK39ShuntSCB"
    VALUE
    0x808007A2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK40AicSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK40AicSCB"
    VALUE
    0x808007A4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK40AicSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK40AicSCB"
    VALUE
    0x808007A6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK40AicSCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK40AicSCG"
    VALUE
    0x808007A8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK40AicSCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK40AicSCG"
    VALUE
    0x808007AA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK40ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK40OR"
    VALUE
    0x808007AC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK40ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK40OR"
    VALUE
    0x808007AE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK40SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK40SCB"
    VALUE
    0x808007B0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK40SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK40SCB"
    VALUE
    0x808007B2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK40SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK40SCG"
    VALUE
    0x808007B4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK40SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK40SCG"
    VALUE
    0x808007B6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK40ShuntSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK40ShuntSCB"
    VALUE
    0x808007B8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK40ShuntSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK40ShuntSCB"
    VALUE
    0x808007BA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK41AicSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK41AicSCB"
    VALUE
    0x808007BC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK41AicSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK41AicSCB"
    VALUE
    0x808007BE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK41AicSCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK41AicSCG"
    VALUE
    0x808007C0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK41AicSCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK41AicSCG"
    VALUE
    0x808007C2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK41ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK41OR"
    VALUE
    0x808007C4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK41ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK41OR"
    VALUE
    0x808007C6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK41SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK41SCB"
    VALUE
    0x808007C8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK41SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK41SCB"
    VALUE
    0x808007CA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK41SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK41SCG"
    VALUE
    0x808007CC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK41SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK41SCG"
    VALUE
    0x808007CE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK41ShuntSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK41ShuntSCB"
    VALUE
    0x808007D0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK41ShuntSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK41ShuntSCB"
    VALUE
    0x808007D2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK42AicSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK42AicSCB"
    VALUE
    0x808007D4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK42AicSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK42AicSCB"
    VALUE
    0x808007D6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK42AicSCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK42AicSCG"
    VALUE
    0x808007D8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK42AicSCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK42AicSCG"
    VALUE
    0x808007DA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK42ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK42OR"
    VALUE
    0x808007DC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK42ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK42OR"
    VALUE
    0x808007DE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK42SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK42SCB"
    VALUE
    0x808007E0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK42SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK42SCB"
    VALUE
    0x808007E2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK42SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK42SCG"
    VALUE
    0x808007E4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK42SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK42SCG"
    VALUE
    0x808007E6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK42ShuntSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK42ShuntSCB"
    VALUE
    0x808007E8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK42ShuntSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK42ShuntSCB"
    VALUE
    0x808007EA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK43ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK43OR"
    VALUE
    0x808007EC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK43ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK43OR"
    VALUE
    0x808007EE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK43SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK43SCB"
    VALUE
    0x808007F0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK43SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK43SCB"
    VALUE
    0x808007F2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK43SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK43SCG"
    VALUE
    0x808007F4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK43SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK43SCG"
    VALUE
    0x808007F6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK44AicSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK44AicSCB"
    VALUE
    0x808007F8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK44AicSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK44AicSCB"
    VALUE
    0x808007FA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK44AicSCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK44AicSCG"
    VALUE
    0x808007FC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK44AicSCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK44AicSCG"
    VALUE
    0x808007FE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK44ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK44OR"
    VALUE
    0x80800800
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK44ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK44OR"
    VALUE
    0x80800802
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK44SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK44SCG"
    VALUE
    0x80800804
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK44SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK44SCG"
    VALUE
    0x80800806
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK44ShuntSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK44ShuntSCB"
    VALUE
    0x80800808
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK44ShuntSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK44ShuntSCB"
    VALUE
    0x8080080A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK45AicSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK45AicSCB"
    VALUE
    0x8080080C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK45AicSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK45AicSCB"
    VALUE
    0x8080080E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK45AicSCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK45AicSCG"
    VALUE
    0x80800810
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK45AicSCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK45AicSCG"
    VALUE
    0x80800812
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK45ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK45OR"
    VALUE
    0x80800814
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK45ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK45OR"
    VALUE
    0x80800816
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK45SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK45SCB"
    VALUE
    0x80800818
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK45SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK45SCB"
    VALUE
    0x8080081A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK45SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK45SCG"
    VALUE
    0x8080081C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK45SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK45SCG"
    VALUE
    0x8080081E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK45ShuntSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK45ShuntSCB"
    VALUE
    0x80800820
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK45ShuntSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK45ShuntSCB"
    VALUE
    0x80800822
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK52ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK52OR"
    VALUE
    0x80800824
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK52ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK52OR"
    VALUE
    0x80800826
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK52SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK52SCB"
    VALUE
    0x80800828
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK52SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK52SCB"
    VALUE
    0x8080082A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK52SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK52SCG"
    VALUE
    0x8080082C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK52SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK52SCG"
    VALUE
    0x8080082E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK53ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK53OR"
    VALUE
    0x80800830
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK53ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK53OR"
    VALUE
    0x80800832
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK53SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK53SCB"
    VALUE
    0x80800834
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK53SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK53SCB"
    VALUE
    0x80800836
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK53SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK53SCG"
    VALUE
    0x80800838
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK53SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK53SCG"
    VALUE
    0x8080083A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK54AicSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK54AicSCB"
    VALUE
    0x8080083C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK54AicSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK54AicSCB"
    VALUE
    0x8080083E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK54AicSCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK54AicSCG"
    VALUE
    0x80800840
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK54AicSCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK54AicSCG"
    VALUE
    0x80800842
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK54ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK54OR"
    VALUE
    0x80800844
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK54ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK54OR"
    VALUE
    0x80800846
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK54SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK54SCB"
    VALUE
    0x80800848
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK54SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK54SCB"
    VALUE
    0x8080084A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK54SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK54SCG"
    VALUE
    0x8080084C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK54SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK54SCG"
    VALUE
    0x8080084E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK54ShuntSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK54ShuntSCB"
    VALUE
    0x80800850
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK54ShuntSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK54ShuntSCB"
    VALUE
    0x80800852
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK55AicSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK55AicSCB"
    VALUE
    0x80800854
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK55AicSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK55AicSCB"
    VALUE
    0x80800856
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK55AicSCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK55AicSCG"
    VALUE
    0x80800858
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK55AicSCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK55AicSCG"
    VALUE
    0x8080085A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK55ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK55OR"
    VALUE
    0x8080085C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK55ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK55OR"
    VALUE
    0x8080085E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK55SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK55SCB"
    VALUE
    0x80800860
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK55SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK55SCB"
    VALUE
    0x80800862
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK55SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK55SCG"
    VALUE
    0x80800864
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK55SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK55SCG"
    VALUE
    0x80800866
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK55ShuntSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK55ShuntSCB"
    VALUE
    0x80800868
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK55ShuntSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK55ShuntSCB"
    VALUE
    0x8080086A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK56ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK56OR"
    VALUE
    0x8080086C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK56ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK56OR"
    VALUE
    0x8080086E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK56SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK56SCB"
    VALUE
    0x80800870
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK56SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK56SCB"
    VALUE
    0x80800872
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK56SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK56SCG"
    VALUE
    0x80800874
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK56SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK56SCG"
    VALUE
    0x80800876
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK57ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK57OR"
    VALUE
    0x80800878
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK57ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK57OR"
    VALUE
    0x8080087A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK57SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK57SCB"
    VALUE
    0x8080087C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK57SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK57SCB"
    VALUE
    0x8080087E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK57SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK57SCG"
    VALUE
    0x80800880
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK57SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK57SCG"
    VALUE
    0x80800882
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK58ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK58OR"
    VALUE
    0x80800884
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK58ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK58OR"
    VALUE
    0x80800886
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK58SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK58SCB"
    VALUE
    0x80800888
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK58SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK58SCB"
    VALUE
    0x8080088A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK58SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK58SCG"
    VALUE
    0x8080088C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK58SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK58SCG"
    VALUE
    0x8080088E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK59ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK59OR"
    VALUE
    0x80800890
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK59ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK59OR"
    VALUE
    0x80800892
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK59SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK59SCB"
    VALUE
    0x80800894
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK59SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK59SCB"
    VALUE
    0x80800896
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK59SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK59SCG"
    VALUE
    0x80800898
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK59SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK59SCG"
    VALUE
    0x8080089A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK60ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK60OR"
    VALUE
    0x8080089C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK60ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK60OR"
    VALUE
    0x8080089E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK60SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK60SCB"
    VALUE
    0x808008A0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK60SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK60SCB"
    VALUE
    0x808008A2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK60SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK60SCG"
    VALUE
    0x808008A4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK60SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK60SCG"
    VALUE
    0x808008A6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK61AicSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK61AicSCB"
    VALUE
    0x808008A8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK61AicSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK61AicSCB"
    VALUE
    0x808008AA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK61AicSCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK61AicSCG"
    VALUE
    0x808008AC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK61AicSCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK61AicSCG"
    VALUE
    0x808008AE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK61ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK61OR"
    VALUE
    0x808008B0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK61ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK61OR"
    VALUE
    0x808008B2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK61SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK61SCB"
    VALUE
    0x808008B4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK61SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK61SCB"
    VALUE
    0x808008B6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK61SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK61SCG"
    VALUE
    0x808008B8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK61SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK61SCG"
    VALUE
    0x808008BA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK61ShuntSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK61ShuntSCB"
    VALUE
    0x808008BC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK61ShuntSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK61ShuntSCB"
    VALUE
    0x808008BE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK62ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK62OR"
    VALUE
    0x808008C0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK62ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK62OR"
    VALUE
    0x808008C2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK62SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK62SCB"
    VALUE
    0x808008C4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK62SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK62SCB"
    VALUE
    0x808008C6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK62SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK62SCG"
    VALUE
    0x808008C8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK62SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK62SCG"
    VALUE
    0x808008CA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK63AicSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK63AicSCB"
    VALUE
    0x808008CC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK63AicSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK63AicSCB"
    VALUE
    0x808008CE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK63AicSCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK63AicSCG"
    VALUE
    0x808008D0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK63AicSCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK63AicSCG"
    VALUE
    0x808008D2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK63ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK63OR"
    VALUE
    0x808008D4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK63ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK63OR"
    VALUE
    0x808008D6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK63SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK63SCB"
    VALUE
    0x808008D8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK63SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK63SCB"
    VALUE
    0x808008DA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK63SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK63SCG"
    VALUE
    0x808008DC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK63SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK63SCG"
    VALUE
    0x808008DE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK63ShuntSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK63ShuntSCB"
    VALUE
    0x808008E0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK63ShuntSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK63ShuntSCB"
    VALUE
    0x808008E2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK64AicSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK64AicSCB"
    VALUE
    0x808008E4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK64AicSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK64AicSCB"
    VALUE
    0x808008E6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK64AicSCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK64AicSCG"
    VALUE
    0x808008E8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK64AicSCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK64AicSCG"
    VALUE
    0x808008EA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK64ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK64OR"
    VALUE
    0x808008EC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK64ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK64OR"
    VALUE
    0x808008EE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK64SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK64SCB"
    VALUE
    0x808008F0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK64SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK64SCB"
    VALUE
    0x808008F2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK64SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK64SCG"
    VALUE
    0x808008F4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK64SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK64SCG"
    VALUE
    0x808008F6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK64ShuntSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK64ShuntSCB"
    VALUE
    0x808008F8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK64ShuntSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK64ShuntSCB"
    VALUE
    0x808008FA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK65AicSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK65AicSCB"
    VALUE
    0x808008FC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK65AicSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK65AicSCB"
    VALUE
    0x808008FE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK65AicSCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK65AicSCG"
    VALUE
    0x80800900
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK65AicSCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK65AicSCG"
    VALUE
    0x80800902
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK65ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK65OR"
    VALUE
    0x80800904
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK65ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK65OR"
    VALUE
    0x80800906
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK65SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK65SCB"
    VALUE
    0x80800908
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK65SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK65SCB"
    VALUE
    0x8080090A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK65SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK65SCG"
    VALUE
    0x8080090C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK65SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK65SCG"
    VALUE
    0x8080090E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK65ShuntSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK65ShuntSCB"
    VALUE
    0x80800910
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK65ShuntSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK65ShuntSCB"
    VALUE
    0x80800912
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK74ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK74OR"
    VALUE
    0x80800914
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK74ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK74OR"
    VALUE
    0x80800916
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK74SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK74SCB"
    VALUE
    0x80800918
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK74SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK74SCB"
    VALUE
    0x8080091A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK74SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK74SCG"
    VALUE
    0x8080091C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK74SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK74SCG"
    VALUE
    0x8080091E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK75ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK75OR"
    VALUE
    0x80800920
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK75ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK75OR"
    VALUE
    0x80800922
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK75SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK75SCB"
    VALUE
    0x80800924
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK75SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK75SCB"
    VALUE
    0x80800926
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK75SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK75SCG"
    VALUE
    0x80800928
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK75SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK75SCG"
    VALUE
    0x8080092A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK76ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK76OR"
    VALUE
    0x8080092C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK76ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK76OR"
    VALUE
    0x8080092E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK76SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK76SCB"
    VALUE
    0x80800930
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK76SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK76SCB"
    VALUE
    0x80800932
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK76SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK76SCG"
    VALUE
    0x80800934
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK76SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK76SCG"
    VALUE
    0x80800936
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK77ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK77OR"
    VALUE
    0x80800938
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK77ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK77OR"
    VALUE
    0x8080093A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK77SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK77SCB"
    VALUE
    0x8080093C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK77SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK77SCB"
    VALUE
    0x8080093E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK77SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK77SCG"
    VALUE
    0x80800940
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK77SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK77SCG"
    VALUE
    0x80800942
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK78ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK78OR"
    VALUE
    0x80800944
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK78ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK78OR"
    VALUE
    0x80800946
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK78SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK78SCB"
    VALUE
    0x80800948
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK78SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK78SCB"
    VALUE
    0x8080094A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK78SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK78SCG"
    VALUE
    0x8080094C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK78SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK78SCG"
    VALUE
    0x8080094E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK07OLDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK07OL"
    VALUE
    0x80800950
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK07OLDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK07OL"
    VALUE
    0x80800952
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK07ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK07OR"
    VALUE
    0x80800954
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK07ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK07OR"
    VALUE
    0x80800956
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK07OTDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK07OT"
    VALUE
    0x80800958
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK07OTDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK07OT"
    VALUE
    0x8080095A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK07SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK07SCB"
    VALUE
    0x8080095C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK07SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK07SCB"
    VALUE
    0x8080095E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK07SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK07SCG"
    VALUE
    0x80800960
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK07SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK07SCG"
    VALUE
    0x80800962
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK08OLDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK08OL"
    VALUE
    0x80800964
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK08OLDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK08OL"
    VALUE
    0x80800966
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK08ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK08OR"
    VALUE
    0x80800968
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK08ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK08OR"
    VALUE
    0x8080096A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK08OTDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK08OT"
    VALUE
    0x8080096C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK08OTDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK08OT"
    VALUE
    0x8080096E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK08SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK08SCB"
    VALUE
    0x80800970
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK08SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK08SCB"
    VALUE
    0x80800972
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK08SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK08SCG"
    VALUE
    0x80800974
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK08SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK08SCG"
    VALUE
    0x80800976
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK09OLDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK09OL"
    VALUE
    0x80800978
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK09OLDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK09OL"
    VALUE
    0x8080097A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK09ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK09OR"
    VALUE
    0x8080097C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK09ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK09OR"
    VALUE
    0x8080097E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK09OTDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK09OT"
    VALUE
    0x80800980
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK09OTDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK09OT"
    VALUE
    0x80800982
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK09SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK09SCB"
    VALUE
    0x80800984
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK09SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK09SCB"
    VALUE
    0x80800986
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK09SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK09SCG"
    VALUE
    0x80800988
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK09SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK09SCG"
    VALUE
    0x8080098A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK12OLDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK12OL"
    VALUE
    0x8080098C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK12OLDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK12OL"
    VALUE
    0x8080098E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK12OTDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK12OT"
    VALUE
    0x80800990
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK12OTDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK12OT"
    VALUE
    0x80800992
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK12SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK12SCB"
    VALUE
    0x80800994
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK12SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK12SCB"
    VALUE
    0x80800996
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK12SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK12SCG"
    VALUE
    0x80800998
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK12SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK12SCG"
    VALUE
    0x8080099A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK13OLDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK13OL"
    VALUE
    0x8080099C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK13OLDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK13OL"
    VALUE
    0x8080099E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK13OTDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK13OT"
    VALUE
    0x808009A0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK13OTDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK13OT"
    VALUE
    0x808009A2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK13SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK13SCB"
    VALUE
    0x808009A4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK13SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK13SCB"
    VALUE
    0x808009A6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK13SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK13SCG"
    VALUE
    0x808009A8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK13SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK13SCG"
    VALUE
    0x808009AA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK14OLDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK14OL"
    VALUE
    0x808009AC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK14OLDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK14OL"
    VALUE
    0x808009AE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK14OTDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK14OT"
    VALUE
    0x808009B0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK14OTDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK14OT"
    VALUE
    0x808009B2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK14SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK14SCB"
    VALUE
    0x808009B4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK14SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK14SCB"
    VALUE
    0x808009B6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK14SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK14SCG"
    VALUE
    0x808009B8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK14SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK14SCG"
    VALUE
    0x808009BA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK15OLDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK15OL"
    VALUE
    0x808009BC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK15OLDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK15OL"
    VALUE
    0x808009BE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK15OTDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK15OT"
    VALUE
    0x808009C0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK15OTDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK15OT"
    VALUE
    0x808009C2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK15SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK15SCB"
    VALUE
    0x808009C4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK15SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK15SCB"
    VALUE
    0x808009C6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK15SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK15SCG"
    VALUE
    0x808009C8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK15SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK15SCG"
    VALUE
    0x808009CA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK16OLDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK16OL"
    VALUE
    0x808009CC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK16OLDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK16OL"
    VALUE
    0x808009CE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK16OTDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK16OT"
    VALUE
    0x808009D0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK16OTDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK16OT"
    VALUE
    0x808009D2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK16SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK16SCB"
    VALUE
    0x808009D4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK16SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK16SCB"
    VALUE
    0x808009D6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK16SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK16SCG"
    VALUE
    0x808009D8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK16SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK16SCG"
    VALUE
    0x808009DA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK25ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK25OR"
    VALUE
    0x808009DC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK25ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK25OR"
    VALUE
    0x808009DE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK25SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK25SCB"
    VALUE
    0x808009E0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK25SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK25SCB"
    VALUE
    0x808009E2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK25SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK25SCG"
    VALUE
    0x808009E4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK25SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK25SCG"
    VALUE
    0x808009E6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK29OLDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK29OL"
    VALUE
    0x808009E8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK29OLDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK29OL"
    VALUE
    0x808009EA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK29ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK29OR"
    VALUE
    0x808009EC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK29ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK29OR"
    VALUE
    0x808009EE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK29OTDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK29OT"
    VALUE
    0x808009F0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK29OTDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK29OT"
    VALUE
    0x808009F2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK29SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK29SCB"
    VALUE
    0x808009F4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK29SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK29SCB"
    VALUE
    0x808009F6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK29SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK29SCG"
    VALUE
    0x808009F8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK29SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK29SCG"
    VALUE
    0x808009FA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK51OLDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK51OL"
    VALUE
    0x808009FC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK51OLDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK51OL"
    VALUE
    0x808009FE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK51OTDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK51OT"
    VALUE
    0x80800A00
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK51OTDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK51OT"
    VALUE
    0x80800A02
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK51SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK51SCB"
    VALUE
    0x80800A04
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK51SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK51SCB"
    VALUE
    0x80800A06
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK51SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK51SCG"
    VALUE
    0x80800A08
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK51SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK51SCG"
    VALUE
    0x80800A0A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK62ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK62OR"
    VALUE
    0x80800A0C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK62ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK62OR"
    VALUE
    0x80800A0E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK62SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK62SCB"
    VALUE
    0x80800A10
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK62SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK62SCB"
    VALUE
    0x80800A12
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK62SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK62SCG"
    VALUE
    0x80800A14
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK62SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK62SCG"
    VALUE
    0x80800A16
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK73OLDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK73OL"
    VALUE
    0x80800A18
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK73OLDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK73OL"
    VALUE
    0x80800A1A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK73ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK73OR"
    VALUE
    0x80800A1C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK73ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK73OR"
    VALUE
    0x80800A1E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK73OTDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK73OT"
    VALUE
    0x80800A20
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK73OTDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK73OT"
    VALUE
    0x80800A22
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK73SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK73SCB"
    VALUE
    0x80800A24
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK73SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK73SCB"
    VALUE
    0x80800A26
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK73SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK73SCG"
    VALUE
    0x80800A28
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK73SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK73SCG"
    VALUE
    0x80800A2A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK80OLDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK80OL"
    VALUE
    0x80800A2C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK80OLDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK80OL"
    VALUE
    0x80800A2E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK80OTDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK80OT"
    VALUE
    0x80800A30
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK80OTDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK80OT"
    VALUE
    0x80800A32
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK80SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK80SCB"
    VALUE
    0x80800A34
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK80SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK80SCB"
    VALUE
    0x80800A36
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK80SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK80SCG"
    VALUE
    0x80800A38
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK80SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK80SCG"
    VALUE
    0x80800A3A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK81OLDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK81OL"
    VALUE
    0x80800A3C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK81OLDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK81OL"
    VALUE
    0x80800A3E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK81OTDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK81OT"
    VALUE
    0x80800A40
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK81OTDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK81OT"
    VALUE
    0x80800A42
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK81SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK81SCB"
    VALUE
    0x80800A44
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK81SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK81SCB"
    VALUE
    0x80800A46
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK81SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK81SCG"
    VALUE
    0x80800A48
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK81SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK81SCG"
    VALUE
    0x80800A4A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK82OLDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK82OL"
    VALUE
    0x80800A4C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK82OLDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK82OL"
    VALUE
    0x80800A4E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK82OTDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK82OT"
    VALUE
    0x80800A50
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK82OTDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK82OT"
    VALUE
    0x80800A52
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK82SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK82SCB"
    VALUE
    0x80800A54
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK82SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK82SCB"
    VALUE
    0x80800A56
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK82SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK82SCG"
    VALUE
    0x80800A58
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK82SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK82SCG"
    VALUE
    0x80800A5A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK83OLDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK83OL"
    VALUE
    0x80800A5C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK83OLDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK83OL"
    VALUE
    0x80800A5E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK83OTDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK83OT"
    VALUE
    0x80800A60
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK83OTDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK83OT"
    VALUE
    0x80800A62
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK83SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK83SCB"
    VALUE
    0x80800A64
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK83SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK83SCB"
    VALUE
    0x80800A66
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK83SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK83SCG"
    VALUE
    0x80800A68
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK83SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK83SCG"
    VALUE
    0x80800A6A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK84OLDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK84OL"
    VALUE
    0x80800A6C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK84OLDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK84OL"
    VALUE
    0x80800A6E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK84OTDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK84OT"
    VALUE
    0x80800A70
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK84OTDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK84OT"
    VALUE
    0x80800A72
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK84SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK84SCB"
    VALUE
    0x80800A74
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK84SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK84SCB"
    VALUE
    0x80800A76
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK84SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK84SCG"
    VALUE
    0x80800A78
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK84SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK84SCG"
    VALUE
    0x80800A7A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK85OLDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK85OL"
    VALUE
    0x80800A7C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK85OLDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK85OL"
    VALUE
    0x80800A7E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK85OTDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK85OT"
    VALUE
    0x80800A80
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK85OTDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK85OT"
    VALUE
    0x80800A82
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK85SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK85SCB"
    VALUE
    0x80800A84
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK85SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK85SCB"
    VALUE
    0x80800A86
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK85SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK85SCG"
    VALUE
    0x80800A88
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK85SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK85SCG"
    VALUE
    0x80800A8A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK86OLDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK86OL"
    VALUE
    0x80800A8C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK86OLDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK86OL"
    VALUE
    0x80800A8E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK86OTDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK86OT"
    VALUE
    0x80800A90
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK86OTDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK86OT"
    VALUE
    0x80800A92
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK86SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK86SCB"
    VALUE
    0x80800A94
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK86SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK86SCB"
    VALUE
    0x80800A96
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK86SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK86SCG"
    VALUE
    0x80800A98
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK86SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK86SCG"
    VALUE
    0x80800A9A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK87OLDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK87OL"
    VALUE
    0x80800A9C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK87OLDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK87OL"
    VALUE
    0x80800A9E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK87OTDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK87OT"
    VALUE
    0x80800AA0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK87OTDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK87OT"
    VALUE
    0x80800AA2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK87SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK87SCB"
    VALUE
    0x80800AA4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK87SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK87SCB"
    VALUE
    0x80800AA6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK87SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK87SCG"
    VALUE
    0x80800AA8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK87SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK87SCG"
    VALUE
    0x80800AAA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_DvUBAT_FWsDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_mo_DvUBAT_FWs"
    VALUE
    0x80800AAC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_DvUBAT_FWsDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_mo_DvUBAT_FWs"
    VALUE
    0x80800AAE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_OVErr_VPR6DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_mo_OVErr_VPR6"
    VALUE
    0x80800AB0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_OVErr_VPR6DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_mo_OVErr_VPR6"
    VALUE
    0x80800AB2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_OVWarn_VPR6DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_mo_OVWarn_VPR6"
    VALUE
    0x80800AB4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_OVWarn_VPR6DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_mo_OVWarn_VPR6"
    VALUE
    0x80800AB6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2"
    VALUE
    0x80800AB8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2"
    VALUE
    0x80800ABA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_OV_UBAT_MONDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_mo_OV_UBAT_MON"
    VALUE
    0x80800ABC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_OV_UBAT_MONDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_mo_OV_UBAT_MON"
    VALUE
    0x80800ABE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_OV_UBRM24_FLEXINDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_mo_OV_UBRM24_FLEXIN"
    VALUE
    0x80800AC0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_OV_UBRM24_FLEXINDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_mo_OV_UBRM24_FLEXIN"
    VALUE
    0x80800AC2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_OV_UBRM24_LOADSDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_mo_OV_UBRM24_LOADS"
    VALUE
    0x80800AC4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_OV_UBRM24_LOADSDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_mo_OV_UBRM24_LOADS"
    VALUE
    0x80800AC6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_OV_UBRM24_MONDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_mo_OV_UBRM24_MON"
    VALUE
    0x80800AC8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_OV_UBRM24_MONDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_mo_OV_UBRM24_MON"
    VALUE
    0x80800ACA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_OV_VDD5DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_mo_OV_VDD5"
    VALUE
    0x80800ACC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_OV_VDD5DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_mo_OV_VDD5"
    VALUE
    0x80800ACE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_OV_VDD5_INDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_mo_OV_VDD5_IN"
    VALUE
    0x80800AD0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_OV_VDD5_INDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_mo_OV_VDD5_IN"
    VALUE
    0x80800AD2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_OV_VPR6DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_mo_OV_VPR6"
    VALUE
    0x80800AD4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_OV_VPR6DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_mo_OV_VPR6"
    VALUE
    0x80800AD6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_OV_VSS3DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_mo_OV_VSS3"
    VALUE
    0x80800AD8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_OV_VSS3DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_mo_OV_VSS3"
    VALUE
    0x80800ADA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_OV_VSS4DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_mo_OV_VSS4"
    VALUE
    0x80800ADC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_OV_VSS4DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_mo_OV_VSS4"
    VALUE
    0x80800ADE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_Temp1_HTErrDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_mo_Temp1_HTErr"
    VALUE
    0x80800AE0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_Temp1_HTErrDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_mo_Temp1_HTErr"
    VALUE
    0x80800AE2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_Temp1_HTWarnDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_mo_Temp1_HTWarn"
    VALUE
    0x80800AE4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_Temp1_HTWarnDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_mo_Temp1_HTWarn"
    VALUE
    0x80800AE6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_Temp2_HTErrDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_mo_Temp2_HTErr"
    VALUE
    0x80800AE8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_Temp2_HTErrDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_mo_Temp2_HTErr"
    VALUE
    0x80800AEA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_Temp2_HTWarnDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_mo_Temp2_HTWarn"
    VALUE
    0x80800AEC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_Temp2_HTWarnDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_mo_Temp2_HTWarn"
    VALUE
    0x80800AEE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2"
    VALUE
    0x80800AF0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2"
    VALUE
    0x80800AF2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_UV_VDD5DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_mo_UV_VDD5"
    VALUE
    0x80800AF4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_UV_VDD5DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_mo_UV_VDD5"
    VALUE
    0x80800AF6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_UV_VDD5_INDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_mo_UV_VDD5_IN"
    VALUE
    0x80800AF8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_UV_VDD5_INDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_mo_UV_VDD5_IN"
    VALUE
    0x80800AFA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_UV_VPR6DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_mo_UV_VPR6"
    VALUE
    0x80800AFC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_UV_VPR6DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_mo_UV_VPR6"
    VALUE
    0x80800AFE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_UV_VSS3DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_mo_UV_VSS3"
    VALUE
    0x80800B00
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_UV_VSS3DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_mo_UV_VSS3"
    VALUE
    0x80800B02
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_UV_VSS4DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_mo_UV_VSS4"
    VALUE
    0x80800B04
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_UV_VSS4DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_mo_UV_VSS4"
    VALUE
    0x80800B06
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.bds_dsm_EventUpDownDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_EventUpDownDebFault"
    VALUE
    0x80800B08
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.bds_dsm_EventUpDownDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_EventUpDownDebFault"
    VALUE
    0x80800B0A
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.bds_dsm_TimeInRowDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_TimeInRowDebFault"
    VALUE
    0x80800B0C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.bds_dsm_TimeInRowDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_TimeInRowDebFault"
    VALUE
    0x80800B0E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.bds_dsm_EventInRowDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_EventInRowDebFault"
    VALUE
    0x80800B10
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.bds_dsm_EventInRowDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_EventInRowDebFault"
    VALUE
    0x80800B12
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3"
    VALUE
    0x80802578
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3"
    VALUE
    0x80802579
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA01OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA01OL"
    VALUE
    0x8080257A
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA01OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA01OT"
    VALUE
    0x8080257B
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA01SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA01SCB"
    VALUE
    0x8080257C
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA01SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA01SCG"
    VALUE
    0x8080257D
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA02OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA02OL"
    VALUE
    0x8080257E
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA02OR_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA02OR"
    VALUE
    0x8080257F
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA02OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA02OT"
    VALUE
    0x80802580
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA02SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA02SCB"
    VALUE
    0x80802581
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA02SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA02SCG"
    VALUE
    0x80802582
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA03OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA03OL"
    VALUE
    0x80802583
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA03OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA03OT"
    VALUE
    0x80802584
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA03SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA03SCB"
    VALUE
    0x80802585
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA03SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA03SCG"
    VALUE
    0x80802586
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA04OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA04OL"
    VALUE
    0x80802587
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA04OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA04OT"
    VALUE
    0x80802588
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA04SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA04SCB"
    VALUE
    0x80802589
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA04SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA04SCG"
    VALUE
    0x8080258A
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA05OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA05OL"
    VALUE
    0x8080258B
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA05OR_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA05OR"
    VALUE
    0x8080258C
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA05OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA05OT"
    VALUE
    0x8080258D
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA05SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA05SCB"
    VALUE
    0x8080258E
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA05SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA05SCG"
    VALUE
    0x8080258F
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA06OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA06OL"
    VALUE
    0x80802590
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA06OR_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA06OR"
    VALUE
    0x80802591
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA06OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA06OT"
    VALUE
    0x80802592
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA06SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA06SCB"
    VALUE
    0x80802593
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA06SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA06SCG"
    VALUE
    0x80802594
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA07OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA07OL"
    VALUE
    0x80802595
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA07OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA07OT"
    VALUE
    0x80802596
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA07SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA07SCB"
    VALUE
    0x80802597
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA07SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA07SCG"
    VALUE
    0x80802598
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA08OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA08OL"
    VALUE
    0x80802599
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA08OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA08OT"
    VALUE
    0x8080259A
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA08SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA08SCB"
    VALUE
    0x8080259B
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA08SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA08SCG"
    VALUE
    0x8080259C
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA09OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA09OL"
    VALUE
    0x8080259D
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA09OR_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA09OR"
    VALUE
    0x8080259E
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA09OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA09OT"
    VALUE
    0x8080259F
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA09SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA09SCB"
    VALUE
    0x808025A0
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA09SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA09SCG"
    VALUE
    0x808025A1
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA10OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA10OL"
    VALUE
    0x808025A2
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA10OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA10OT"
    VALUE
    0x808025A3
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA10SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA10SCB"
    VALUE
    0x808025A4
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA10SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA10SCG"
    VALUE
    0x808025A5
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA11OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA11OL"
    VALUE
    0x808025A6
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA11OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA11OT"
    VALUE
    0x808025A7
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA11SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA11SCB"
    VALUE
    0x808025A8
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA11SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA11SCG"
    VALUE
    0x808025A9
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA12OR_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA12OR"
    VALUE
    0x808025AA
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA12SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA12SCB"
    VALUE
    0x808025AB
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA12SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA12SCG"
    VALUE
    0x808025AC
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA16OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA16OL"
    VALUE
    0x808025AD
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA16OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA16OT"
    VALUE
    0x808025AE
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA16SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA16SCB"
    VALUE
    0x808025AF
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA16SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA16SCG"
    VALUE
    0x808025B0
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA17OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA17OL"
    VALUE
    0x808025B1
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA17OR_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA17OR"
    VALUE
    0x808025B2
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA17OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA17OT"
    VALUE
    0x808025B3
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA17SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA17SCB"
    VALUE
    0x808025B4
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA17SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA17SCG"
    VALUE
    0x808025B5
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA18OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA18OL"
    VALUE
    0x808025B6
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA18OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA18OT"
    VALUE
    0x808025B7
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA18SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA18SCB"
    VALUE
    0x808025B8
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA18SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA18SCG"
    VALUE
    0x808025B9
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA19OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA19OL"
    VALUE
    0x808025BA
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA19OR_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA19OR"
    VALUE
    0x808025BB
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA19OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA19OT"
    VALUE
    0x808025BC
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA19SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA19SCB"
    VALUE
    0x808025BD
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA19SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA19SCG"
    VALUE
    0x808025BE
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA20OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA20OL"
    VALUE
    0x808025BF
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA20OR_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA20OR"
    VALUE
    0x808025C0
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA20OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA20OT"
    VALUE
    0x808025C1
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA20SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA20SCB"
    VALUE
    0x808025C2
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA20SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA20SCG"
    VALUE
    0x808025C3
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA31OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA31OL"
    VALUE
    0x808025C4
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA31OR_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA31OR"
    VALUE
    0x808025C5
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA31OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA31OT"
    VALUE
    0x808025C6
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA31SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA31SCB"
    VALUE
    0x808025C7
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA31SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA31SCG"
    VALUE
    0x808025C8
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA32OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA32OL"
    VALUE
    0x808025C9
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA32OR_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA32OR"
    VALUE
    0x808025CA
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA32OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA32OT"
    VALUE
    0x808025CB
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA32SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA32SCB"
    VALUE
    0x808025CC
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA32SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA32SCG"
    VALUE
    0x808025CD
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA33OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA33OL"
    VALUE
    0x808025CE
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA33OR_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA33OR"
    VALUE
    0x808025CF
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA33OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA33OT"
    VALUE
    0x808025D0
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA33SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA33SCB"
    VALUE
    0x808025D1
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA33SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA33SCG"
    VALUE
    0x808025D2
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA34OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA34OL"
    VALUE
    0x808025D3
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA34OR_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA34OR"
    VALUE
    0x808025D4
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA34OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA34OT"
    VALUE
    0x808025D5
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA34SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA34SCB"
    VALUE
    0x808025D6
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA34SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA34SCG"
    VALUE
    0x808025D7
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA35OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA35OL"
    VALUE
    0x808025D8
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA35OR_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA35OR"
    VALUE
    0x808025D9
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA35OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA35OT"
    VALUE
    0x808025DA
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA35SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA35SCB"
    VALUE
    0x808025DB
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA35SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA35SCG"
    VALUE
    0x808025DC
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA46OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA46OL"
    VALUE
    0x808025DD
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA46OR_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA46OR"
    VALUE
    0x808025DE
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA46OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA46OT"
    VALUE
    0x808025DF
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA46SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA46SCB"
    VALUE
    0x808025E0
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA46SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA46SCG"
    VALUE
    0x808025E1
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA47OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA47OL"
    VALUE
    0x808025E2
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA47OR_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA47OR"
    VALUE
    0x808025E3
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA47OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA47OT"
    VALUE
    0x808025E4
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA47SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA47SCB"
    VALUE
    0x808025E5
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA47SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA47SCG"
    VALUE
    0x808025E6
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA48OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA48OL"
    VALUE
    0x808025E7
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA48OR_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA48OR"
    VALUE
    0x808025E8
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA48OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA48OT"
    VALUE
    0x808025E9
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA48SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA48SCB"
    VALUE
    0x808025EA
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA48SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA48SCG"
    VALUE
    0x808025EB
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA49OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA49OL"
    VALUE
    0x808025EC
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA49OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA49OT"
    VALUE
    0x808025ED
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA49SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA49SCB"
    VALUE
    0x808025EE
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA49SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA49SCG"
    VALUE
    0x808025EF
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA50OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA50OL"
    VALUE
    0x808025F0
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA50OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA50OT"
    VALUE
    0x808025F1
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA50SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA50SCB"
    VALUE
    0x808025F2
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA50SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA50SCG"
    VALUE
    0x808025F3
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA51OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA51OL"
    VALUE
    0x808025F4
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA51OR_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA51OR"
    VALUE
    0x808025F5
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA51OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA51OT"
    VALUE
    0x808025F6
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA51SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA51SCB"
    VALUE
    0x808025F7
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA51SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA51SCG"
    VALUE
    0x808025F8
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA52OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA52OL"
    VALUE
    0x808025F9
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA52OR_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA52OR"
    VALUE
    0x808025FA
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA52OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA52OT"
    VALUE
    0x808025FB
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA52SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA52SCB"
    VALUE
    0x808025FC
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA52SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA52SCG"
    VALUE
    0x808025FD
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA53OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA53OL"
    VALUE
    0x808025FE
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA53OR_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA53OR"
    VALUE
    0x808025FF
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA53OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA53OT"
    VALUE
    0x80802600
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA53SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA53SCB"
    VALUE
    0x80802601
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA53SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA53SCG"
    VALUE
    0x80802602
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA54OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA54OL"
    VALUE
    0x80802603
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA54OR_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA54OR"
    VALUE
    0x80802604
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA54OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA54OT"
    VALUE
    0x80802605
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA54SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA54SCB"
    VALUE
    0x80802606
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA54SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA54SCG"
    VALUE
    0x80802607
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA55OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA55OL"
    VALUE
    0x80802608
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA55OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA55OT"
    VALUE
    0x80802609
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA55SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA55SCB"
    VALUE
    0x8080260A
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA55SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA55SCG"
    VALUE
    0x8080260B
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA56OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA56OL"
    VALUE
    0x8080260C
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA56OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA56OT"
    VALUE
    0x8080260D
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA56SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA56SCB"
    VALUE
    0x8080260E
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA56SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA56SCG"
    VALUE
    0x8080260F
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA58OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA58OL"
    VALUE
    0x80802610
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA58OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA58OT"
    VALUE
    0x80802611
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA58SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA58SCB"
    VALUE
    0x80802612
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA58SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA58SCG"
    VALUE
    0x80802613
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outK14OR_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK14OR"
    VALUE
    0x80802614
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outK15OR_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK15OR"
    VALUE
    0x80802615
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outK16OR_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK16OR"
    VALUE
    0x80802616
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outK17OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK17OL"
    VALUE
    0x80802617
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outK17OR_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK17OR"
    VALUE
    0x80802618
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outK17OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK17OT"
    VALUE
    0x80802619
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outK17SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK17SCB"
    VALUE
    0x8080261A
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outK17SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK17SCG"
    VALUE
    0x8080261B
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DevLib_tiBattUHiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_DevLibBattUHi"
    VALUE
    0x8080261C
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DevLib_tiBattULoUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_DevLibBattULo"
    VALUE
    0x8080261D
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.bds_dsm_TimeUpDownUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_TimeUpDownDebFault"
    VALUE
    0x8080261E
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tK44SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK44SCB"
    VALUE
    0x8080261F
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA13ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA13OR"
    VALUE
    0x80802620
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA13SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA13SCB"
    VALUE
    0x80802621
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA13SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA13SCG"
    VALUE
    0x80802622
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA14ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA14OR"
    VALUE
    0x80802623
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA14SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA14SCB"
    VALUE
    0x80802624
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA14SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA14SCG"
    VALUE
    0x80802625
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA21ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA21OR"
    VALUE
    0x80802626
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA21SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA21SCB"
    VALUE
    0x80802627
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA21SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA21SCG"
    VALUE
    0x80802628
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA22ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA22OR"
    VALUE
    0x80802629
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA22SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA22SCB"
    VALUE
    0x8080262A
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA22SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA22SCG"
    VALUE
    0x8080262B
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA23ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA23OR"
    VALUE
    0x8080262C
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA23SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA23SCB"
    VALUE
    0x8080262D
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA23SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA23SCG"
    VALUE
    0x8080262E
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA24ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA24OR"
    VALUE
    0x8080262F
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA24SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA24SCB"
    VALUE
    0x80802630
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA24SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA24SCG"
    VALUE
    0x80802631
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA25ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA25OR"
    VALUE
    0x80802632
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA25SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA25SCB"
    VALUE
    0x80802633
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA25SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA25SCG"
    VALUE
    0x80802634
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA26ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA26OR"
    VALUE
    0x80802635
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA26SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA26SCB"
    VALUE
    0x80802636
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA26SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA26SCG"
    VALUE
    0x80802637
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA27ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA27OR"
    VALUE
    0x80802638
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA27SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA27SCB"
    VALUE
    0x80802639
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA27SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA27SCG"
    VALUE
    0x8080263A
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA28ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA28OR"
    VALUE
    0x8080263B
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA28SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA28SCB"
    VALUE
    0x8080263C
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA28SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA28SCG"
    VALUE
    0x8080263D
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA29ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA29OR"
    VALUE
    0x8080263E
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA29SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA29SCB"
    VALUE
    0x8080263F
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA29SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA29SCG"
    VALUE
    0x80802640
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA36AicSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA36AicSCB"
    VALUE
    0x80802641
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA36AicSCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA36AicSCG"
    VALUE
    0x80802642
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA36ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA36OR"
    VALUE
    0x80802643
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA36SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA36SCB"
    VALUE
    0x80802644
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA36SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA36SCG"
    VALUE
    0x80802645
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA36ShuntSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA36ShuntSCB"
    VALUE
    0x80802646
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA37AicSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA37AicSCB"
    VALUE
    0x80802647
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA37AicSCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA37AicSCG"
    VALUE
    0x80802648
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA37ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA37OR"
    VALUE
    0x80802649
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA37SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA37SCB"
    VALUE
    0x8080264A
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA37SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA37SCG"
    VALUE
    0x8080264B
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA37ShuntSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA37ShuntSCB"
    VALUE
    0x8080264C
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA38AicSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA38AicSCB"
    VALUE
    0x8080264D
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA38AicSCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA38AicSCG"
    VALUE
    0x8080264E
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA38ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA38OR"
    VALUE
    0x8080264F
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA38SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA38SCB"
    VALUE
    0x80802650
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA38SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA38SCG"
    VALUE
    0x80802651
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA38ShuntSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA38ShuntSCB"
    VALUE
    0x80802652
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA39AicSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA39AicSCB"
    VALUE
    0x80802653
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA39AicSCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA39AicSCG"
    VALUE
    0x80802654
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA39ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA39OR"
    VALUE
    0x80802655
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA39SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA39SCB"
    VALUE
    0x80802656
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA39SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA39SCG"
    VALUE
    0x80802657
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA39ShuntSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA39ShuntSCB"
    VALUE
    0x80802658
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA40ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA40OR"
    VALUE
    0x80802659
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA40SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA40SCB"
    VALUE
    0x8080265A
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA40SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA40SCG"
    VALUE
    0x8080265B
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA41ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA41OR"
    VALUE
    0x8080265C
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA41SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA41SCB"
    VALUE
    0x8080265D
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA41SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA41SCG"
    VALUE
    0x8080265E
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA42ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA42OR"
    VALUE
    0x8080265F
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA42SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA42SCB"
    VALUE
    0x80802660
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA42SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA42SCG"
    VALUE
    0x80802661
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA43AicSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA43AicSCB"
    VALUE
    0x80802662
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA43AicSCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA43AicSCG"
    VALUE
    0x80802663
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA43ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA43OR"
    VALUE
    0x80802664
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA43SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA43SCB"
    VALUE
    0x80802665
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA43SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA43SCG"
    VALUE
    0x80802666
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA43ShuntSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA43ShuntSCB"
    VALUE
    0x80802667
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA44OLUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA44OL"
    VALUE
    0x80802668
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA44SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA44SCB"
    VALUE
    0x80802669
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA44SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA44SCG"
    VALUE
    0x8080266A
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA57ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA57OR"
    VALUE
    0x8080266B
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA57SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA57SCB"
    VALUE
    0x8080266C
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA57SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA57SCG"
    VALUE
    0x8080266D
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA59OLUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA59OL"
    VALUE
    0x8080266E
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA59SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA59SCB"
    VALUE
    0x8080266F
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA59SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA59SCG"
    VALUE
    0x80802670
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK10ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK10OR"
    VALUE
    0x80802671
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK10SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK10SCB"
    VALUE
    0x80802672
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK10SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK10SCG"
    VALUE
    0x80802673
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK11ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK11OR"
    VALUE
    0x80802674
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK11SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK11SCB"
    VALUE
    0x80802675
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK11SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK11SCG"
    VALUE
    0x80802676
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK30AicSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK30AicSCB"
    VALUE
    0x80802677
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK30AicSCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK30AicSCG"
    VALUE
    0x80802678
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK30ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK30OR"
    VALUE
    0x80802679
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK30SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK30SCB"
    VALUE
    0x8080267A
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK30SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK30SCG"
    VALUE
    0x8080267B
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK30ShuntSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK30ShuntSCB"
    VALUE
    0x8080267C
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK31ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK31OR"
    VALUE
    0x8080267D
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK31SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK31SCB"
    VALUE
    0x8080267E
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK31SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK31SCG"
    VALUE
    0x8080267F
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK32ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK32OR"
    VALUE
    0x80802680
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK32SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK32SCB"
    VALUE
    0x80802681
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK32SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK32SCG"
    VALUE
    0x80802682
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK33ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK33OR"
    VALUE
    0x80802683
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK33SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK33SCB"
    VALUE
    0x80802684
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK33SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK33SCG"
    VALUE
    0x80802685
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK34ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK34OR"
    VALUE
    0x80802686
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK34SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK34SCB"
    VALUE
    0x80802687
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK34SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK34SCG"
    VALUE
    0x80802688
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK35ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK35OR"
    VALUE
    0x80802689
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK35SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK35SCB"
    VALUE
    0x8080268A
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK35SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK35SCG"
    VALUE
    0x8080268B
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK36ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK36OR"
    VALUE
    0x8080268C
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK36SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK36SCB"
    VALUE
    0x8080268D
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK36SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK36SCG"
    VALUE
    0x8080268E
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK37AicSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK37AicSCB"
    VALUE
    0x8080268F
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK37AicSCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK37AicSCG"
    VALUE
    0x80802690
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK37ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK37OR"
    VALUE
    0x80802691
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK37SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK37SCB"
    VALUE
    0x80802692
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK37SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK37SCG"
    VALUE
    0x80802693
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK37ShuntSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK37ShuntSCB"
    VALUE
    0x80802694
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK38AicSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK38AicSCB"
    VALUE
    0x80802695
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK38AicSCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK38AicSCG"
    VALUE
    0x80802696
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK38ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK38OR"
    VALUE
    0x80802697
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK38SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK38SCB"
    VALUE
    0x80802698
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK38SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK38SCG"
    VALUE
    0x80802699
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK38ShuntSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK38ShuntSCB"
    VALUE
    0x8080269A
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK39AicSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK39AicSCB"
    VALUE
    0x8080269B
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK39AicSCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK39AicSCG"
    VALUE
    0x8080269C
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK39ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK39OR"
    VALUE
    0x8080269D
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK39SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK39SCB"
    VALUE
    0x8080269E
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK39SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK39SCG"
    VALUE
    0x8080269F
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK39ShuntSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK39ShuntSCB"
    VALUE
    0x808026A0
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK40AicSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK40AicSCB"
    VALUE
    0x808026A1
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK40AicSCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK40AicSCG"
    VALUE
    0x808026A2
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK40ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK40OR"
    VALUE
    0x808026A3
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK40SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK40SCB"
    VALUE
    0x808026A4
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK40SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK40SCG"
    VALUE
    0x808026A5
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK40ShuntSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK40ShuntSCB"
    VALUE
    0x808026A6
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK41AicSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK41AicSCB"
    VALUE
    0x808026A7
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK41AicSCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK41AicSCG"
    VALUE
    0x808026A8
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK41ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK41OR"
    VALUE
    0x808026A9
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK41SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK41SCB"
    VALUE
    0x808026AA
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK41SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK41SCG"
    VALUE
    0x808026AB
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK41ShuntSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK41ShuntSCB"
    VALUE
    0x808026AC
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK42AicSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK42AicSCB"
    VALUE
    0x808026AD
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK42AicSCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK42AicSCG"
    VALUE
    0x808026AE
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK42ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK42OR"
    VALUE
    0x808026AF
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK42SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK42SCB"
    VALUE
    0x808026B0
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK42SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK42SCG"
    VALUE
    0x808026B1
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK42ShuntSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK42ShuntSCB"
    VALUE
    0x808026B2
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK43ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK43OR"
    VALUE
    0x808026B3
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK43SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK43SCB"
    VALUE
    0x808026B4
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK43SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK43SCG"
    VALUE
    0x808026B5
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK44AicSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK44AicSCB"
    VALUE
    0x808026B6
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK44AicSCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK44AicSCG"
    VALUE
    0x808026B7
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK44ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK44OR"
    VALUE
    0x808026B8
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK44SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK44SCG"
    VALUE
    0x808026B9
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK44ShuntSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK44ShuntSCB"
    VALUE
    0x808026BA
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK45AicSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK45AicSCB"
    VALUE
    0x808026BB
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK45AicSCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK45AicSCG"
    VALUE
    0x808026BC
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK45ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK45OR"
    VALUE
    0x808026BD
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK45SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK45SCB"
    VALUE
    0x808026BE
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK45SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK45SCG"
    VALUE
    0x808026BF
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK45ShuntSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK45ShuntSCB"
    VALUE
    0x808026C0
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK52ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK52OR"
    VALUE
    0x808026C1
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK52SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK52SCB"
    VALUE
    0x808026C2
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK52SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK52SCG"
    VALUE
    0x808026C3
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK53ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK53OR"
    VALUE
    0x808026C4
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK53SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK53SCB"
    VALUE
    0x808026C5
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK53SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK53SCG"
    VALUE
    0x808026C6
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK54AicSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK54AicSCB"
    VALUE
    0x808026C7
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK54AicSCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK54AicSCG"
    VALUE
    0x808026C8
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK54ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK54OR"
    VALUE
    0x808026C9
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK54SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK54SCB"
    VALUE
    0x808026CA
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK54SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK54SCG"
    VALUE
    0x808026CB
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK54ShuntSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK54ShuntSCB"
    VALUE
    0x808026CC
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK55AicSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK55AicSCB"
    VALUE
    0x808026CD
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK55AicSCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK55AicSCG"
    VALUE
    0x808026CE
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK55ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK55OR"
    VALUE
    0x808026CF
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK55SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK55SCB"
    VALUE
    0x808026D0
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK55SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK55SCG"
    VALUE
    0x808026D1
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK55ShuntSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK55ShuntSCB"
    VALUE
    0x808026D2
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK56ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK56OR"
    VALUE
    0x808026D3
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK56SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK56SCB"
    VALUE
    0x808026D4
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK56SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK56SCG"
    VALUE
    0x808026D5
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK57ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK57OR"
    VALUE
    0x808026D6
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK57SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK57SCB"
    VALUE
    0x808026D7
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK57SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK57SCG"
    VALUE
    0x808026D8
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK58ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK58OR"
    VALUE
    0x808026D9
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK58SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK58SCB"
    VALUE
    0x808026DA
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK58SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK58SCG"
    VALUE
    0x808026DB
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK59ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK59OR"
    VALUE
    0x808026DC
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK59SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK59SCB"
    VALUE
    0x808026DD
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK59SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK59SCG"
    VALUE
    0x808026DE
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK60ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK60OR"
    VALUE
    0x808026DF
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK60SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK60SCB"
    VALUE
    0x808026E0
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK60SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK60SCG"
    VALUE
    0x808026E1
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK61AicSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK61AicSCB"
    VALUE
    0x808026E2
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK61AicSCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK61AicSCG"
    VALUE
    0x808026E3
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK61ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK61OR"
    VALUE
    0x808026E4
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK61SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK61SCB"
    VALUE
    0x808026E5
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK61SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK61SCG"
    VALUE
    0x808026E6
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK61ShuntSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK61ShuntSCB"
    VALUE
    0x808026E7
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK62ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK62OR"
    VALUE
    0x808026E8
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK62SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK62SCB"
    VALUE
    0x808026E9
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK62SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK62SCG"
    VALUE
    0x808026EA
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK63AicSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK63AicSCB"
    VALUE
    0x808026EB
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK63AicSCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK63AicSCG"
    VALUE
    0x808026EC
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK63ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK63OR"
    VALUE
    0x808026ED
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK63SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK63SCB"
    VALUE
    0x808026EE
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK63SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK63SCG"
    VALUE
    0x808026EF
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK63ShuntSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK63ShuntSCB"
    VALUE
    0x808026F0
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK64AicSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK64AicSCB"
    VALUE
    0x808026F1
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK64AicSCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK64AicSCG"
    VALUE
    0x808026F2
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK64ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK64OR"
    VALUE
    0x808026F3
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK64SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK64SCB"
    VALUE
    0x808026F4
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK64SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK64SCG"
    VALUE
    0x808026F5
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK64ShuntSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK64ShuntSCB"
    VALUE
    0x808026F6
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK65AicSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK65AicSCB"
    VALUE
    0x808026F7
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK65AicSCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK65AicSCG"
    VALUE
    0x808026F8
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK65ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK65OR"
    VALUE
    0x808026F9
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK65SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK65SCB"
    VALUE
    0x808026FA
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK65SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK65SCG"
    VALUE
    0x808026FB
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK65ShuntSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK65ShuntSCB"
    VALUE
    0x808026FC
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK74ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK74OR"
    VALUE
    0x808026FD
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK74SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK74SCB"
    VALUE
    0x808026FE
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK74SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK74SCG"
    VALUE
    0x808026FF
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK75ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK75OR"
    VALUE
    0x80802700
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK75SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK75SCB"
    VALUE
    0x80802701
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK75SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK75SCG"
    VALUE
    0x80802702
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK76ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK76OR"
    VALUE
    0x80802703
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK76SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK76SCB"
    VALUE
    0x80802704
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK76SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK76SCG"
    VALUE
    0x80802705
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK77ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK77OR"
    VALUE
    0x80802706
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK77SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK77SCB"
    VALUE
    0x80802707
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK77SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK77SCG"
    VALUE
    0x80802708
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK78ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK78OR"
    VALUE
    0x80802709
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK78SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK78SCB"
    VALUE
    0x8080270A
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK78SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK78SCG"
    VALUE
    0x8080270B
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK07OLUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK07OL"
    VALUE
    0x8080270C
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK07ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK07OR"
    VALUE
    0x8080270D
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK07OTUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK07OT"
    VALUE
    0x8080270E
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK07SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK07SCB"
    VALUE
    0x8080270F
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK07SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK07SCG"
    VALUE
    0x80802710
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK08OLUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK08OL"
    VALUE
    0x80802711
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK08ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK08OR"
    VALUE
    0x80802712
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK08OTUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK08OT"
    VALUE
    0x80802713
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK08SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK08SCB"
    VALUE
    0x80802714
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK08SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK08SCG"
    VALUE
    0x80802715
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK09OLUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK09OL"
    VALUE
    0x80802716
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK09ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK09OR"
    VALUE
    0x80802717
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK09OTUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK09OT"
    VALUE
    0x80802718
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK09SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK09SCB"
    VALUE
    0x80802719
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK09SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK09SCG"
    VALUE
    0x8080271A
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK12OLUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK12OL"
    VALUE
    0x8080271B
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK12OTUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK12OT"
    VALUE
    0x8080271C
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK12SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK12SCB"
    VALUE
    0x8080271D
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK12SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK12SCG"
    VALUE
    0x8080271E
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK13OLUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK13OL"
    VALUE
    0x8080271F
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK13OTUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK13OT"
    VALUE
    0x80802720
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK13SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK13SCB"
    VALUE
    0x80802721
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK13SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK13SCG"
    VALUE
    0x80802722
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK14OLUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK14OL"
    VALUE
    0x80802723
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK14OTUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK14OT"
    VALUE
    0x80802724
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK14SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK14SCB"
    VALUE
    0x80802725
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK14SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK14SCG"
    VALUE
    0x80802726
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK15OLUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK15OL"
    VALUE
    0x80802727
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK15OTUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK15OT"
    VALUE
    0x80802728
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK15SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK15SCB"
    VALUE
    0x80802729
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK15SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK15SCG"
    VALUE
    0x8080272A
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK16OLUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK16OL"
    VALUE
    0x8080272B
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK16OTUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK16OT"
    VALUE
    0x8080272C
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK16SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK16SCB"
    VALUE
    0x8080272D
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK16SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK16SCG"
    VALUE
    0x8080272E
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK25ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK25OR"
    VALUE
    0x8080272F
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK25SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK25SCB"
    VALUE
    0x80802730
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK25SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK25SCG"
    VALUE
    0x80802731
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK29OLUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK29OL"
    VALUE
    0x80802732
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK29ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK29OR"
    VALUE
    0x80802733
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK29OTUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK29OT"
    VALUE
    0x80802734
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK29SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK29SCB"
    VALUE
    0x80802735
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK29SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK29SCG"
    VALUE
    0x80802736
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK51OLUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK51OL"
    VALUE
    0x80802737
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK51OTUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK51OT"
    VALUE
    0x80802738
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK51SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK51SCB"
    VALUE
    0x80802739
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK51SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK51SCG"
    VALUE
    0x8080273A
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK62ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK62OR"
    VALUE
    0x8080273B
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK62SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK62SCB"
    VALUE
    0x8080273C
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK62SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK62SCG"
    VALUE
    0x8080273D
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK73OLUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK73OL"
    VALUE
    0x8080273E
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK73ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK73OR"
    VALUE
    0x8080273F
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK73OTUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK73OT"
    VALUE
    0x80802740
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK73SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK73SCB"
    VALUE
    0x80802741
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK73SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK73SCG"
    VALUE
    0x80802742
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK80OLUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK80OL"
    VALUE
    0x80802743
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK80OTUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK80OT"
    VALUE
    0x80802744
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK80SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK80SCB"
    VALUE
    0x80802745
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK80SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK80SCG"
    VALUE
    0x80802746
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK81OLUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK81OL"
    VALUE
    0x80802747
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK81OTUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK81OT"
    VALUE
    0x80802748
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK81SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK81SCB"
    VALUE
    0x80802749
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK81SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK81SCG"
    VALUE
    0x8080274A
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK82OLUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK82OL"
    VALUE
    0x8080274B
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK82OTUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK82OT"
    VALUE
    0x8080274C
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK82SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK82SCB"
    VALUE
    0x8080274D
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK82SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK82SCG"
    VALUE
    0x8080274E
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK83OLUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK83OL"
    VALUE
    0x8080274F
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK83OTUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK83OT"
    VALUE
    0x80802750
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK83SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK83SCB"
    VALUE
    0x80802751
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK83SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK83SCG"
    VALUE
    0x80802752
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK84OLUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK84OL"
    VALUE
    0x80802753
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK84OTUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK84OT"
    VALUE
    0x80802754
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK84SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK84SCB"
    VALUE
    0x80802755
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK84SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK84SCG"
    VALUE
    0x80802756
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK85OLUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK85OL"
    VALUE
    0x80802757
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK85OTUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK85OT"
    VALUE
    0x80802758
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK85SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK85SCB"
    VALUE
    0x80802759
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK85SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK85SCG"
    VALUE
    0x8080275A
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK86OLUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK86OL"
    VALUE
    0x8080275B
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK86OTUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK86OT"
    VALUE
    0x8080275C
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK86SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK86SCB"
    VALUE
    0x8080275D
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK86SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK86SCG"
    VALUE
    0x8080275E
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK87OLUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK87OL"
    VALUE
    0x8080275F
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK87OTUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK87OT"
    VALUE
    0x80802760
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK87SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK87SCB"
    VALUE
    0x80802761
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK87SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK87SCG"
    VALUE
    0x80802762
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbr_mo_DvUBAT_FWsUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_mo_DvUBAT_FWs"
    VALUE
    0x80802763
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbr_mo_OVErr_VPR6UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_mo_OVErr_VPR6"
    VALUE
    0x80802764
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbr_mo_OVWarn_VPR6UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_mo_OVWarn_VPR6"
    VALUE
    0x80802765
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2"
    VALUE
    0x80802766
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbr_mo_OV_UBAT_MONUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_mo_OV_UBAT_MON"
    VALUE
    0x80802767
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbr_mo_OV_UBRM24_FLEXINUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_mo_OV_UBRM24_FLEXIN"
    VALUE
    0x80802768
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbr_mo_OV_UBRM24_LOADSUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_mo_OV_UBRM24_LOADS"
    VALUE
    0x80802769
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbr_mo_OV_UBRM24_MONUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_mo_OV_UBRM24_MON"
    VALUE
    0x8080276A
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbr_mo_OV_VDD5UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_mo_OV_VDD5"
    VALUE
    0x8080276B
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbr_mo_OV_VDD5_INUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_mo_OV_VDD5_IN"
    VALUE
    0x8080276C
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbr_mo_OV_VPR6UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_mo_OV_VPR6"
    VALUE
    0x8080276D
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbr_mo_OV_VSS3UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_mo_OV_VSS3"
    VALUE
    0x8080276E
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbr_mo_OV_VSS4UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_mo_OV_VSS4"
    VALUE
    0x8080276F
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbr_mo_Temp1_HTErrUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_mo_Temp1_HTErr"
    VALUE
    0x80802770
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbr_mo_Temp1_HTWarnUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_mo_Temp1_HTWarn"
    VALUE
    0x80802771
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbr_mo_Temp2_HTErrUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_mo_Temp2_HTErr"
    VALUE
    0x80802772
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbr_mo_Temp2_HTWarnUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_mo_Temp2_HTWarn"
    VALUE
    0x80802773
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2"
    VALUE
    0x80802774
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbr_mo_UV_VDD5UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_mo_UV_VDD5"
    VALUE
    0x80802775
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbr_mo_UV_VDD5_INUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_mo_UV_VDD5_IN"
    VALUE
    0x80802776
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbr_mo_UV_VPR6UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_mo_UV_VPR6"
    VALUE
    0x80802777
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbr_mo_UV_VSS3UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_mo_UV_VSS3"
    VALUE
    0x80802778
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbr_mo_UV_VSS4UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_mo_UV_VSS4"
    VALUE
    0x80802779
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.bds_dsm_EventUpDownUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_EventUpDownDebFault"
    VALUE
    0x8080277A
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DevLib_DigOutDbgSig_C
    "Calibration parameter to select the Digital out signal for which the debugging information is to be updated into the measuring points"
    VALUE
    0x8080725A
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Devlib_PsDisbl.facLowHysLo_C
    "Structure containing hysterisis limits for battery voltage correction factor / Lower hysterisis limit for battery correction factor LOW."
    VALUE
    0x8080725E
    Kw_Ws16
    1.000000
    Fact
    0.00
    1.000000

    FORMAT "%8.6"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Devlib_PsDisbl.facLowHysHi_C
    "Structure containing hysterisis limits for battery voltage correction factor / Higher hysterisis limit for battery correction factor LOW."
    VALUE
    0x80807260
    Kw_Ws16
    1.000000
    Fact
    0.00
    1.000000

    FORMAT "%8.6"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Devlib_PsDisbl.facHighHysLo_C
    "Structure containing hysterisis limits for battery voltage correction factor / Lower hysterisis limit for battery correction factor HIGH."
    VALUE
    0x80807262
    Kw_Ws16
    2.000000
    Fact
    1.000000
    3.000000

    FORMAT "%8.6"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Devlib_PsDisbl.facHighHysHi_C
    "Structure containing hysterisis limits for battery voltage correction factor / Higher hysterisis limit for battery correction factor HIGH."
    VALUE
    0x80807264
    Kw_Ws16
    2.000000
    Fact
    1.000000
    3.000000

    FORMAT "%8.6"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DevLib_PWMOutDbgSig_C
    "Calibration parameter to select the PWM out signal for which the debugging information is to be updated into the measuring points"
    VALUE
    0x8080725C
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Devlib_PwrStg.BattLoHysLo_C
    "Structure containing hysterisis check for battery voltage LOW/HIGH / Lower limit for battery voltage LOW hysterisis check."
    VALUE
    0x80807266
    Kw_Ws16
    9000.000
    Volt_Batt
    3000.00
    12000.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Devlib_PwrStg.BattLoHysHi_C
    "Structure containing hysterisis check for battery voltage LOW/HIGH / Higher limit for battery voltage LOW hysterisis check"
    VALUE
    0x80807268
    Kw_Ws16
    9000.000
    Volt_Batt
    3000.00
    12000.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Devlib_PwrStg.BattHiHysLo_C
    "Structure containing hysterisis check for battery voltage LOW/HIGH / Lower limit for battery voltage HIGH hysterisis check"
    VALUE
    0x8080726A
    Kw_Ws16
    24000.00
    Volt_Batt
    12000.00
    36000.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Devlib_PwrStg.BattHiHysHi_C
    "Structure containing hysterisis check for battery voltage LOW/HIGH / Upper limit for battery voltage HIGH hysterisis check"
    VALUE
    0x8080726C
    Kw_Ws16
    24000.00
    Volt_Batt
    12000.00
    36000.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_Unused_C
    "Behaviour control mask / "
    VALUE
    0x80800B14
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    READ_ONLY

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_TimeInRowDebFault_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_TimeInRowDebFault"
    VALUE
    0x80800B15
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_EventInRowDebFault_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_EventInRowDebFault"
    VALUE
    0x80800B16
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_DevLibBattUHi_C
    "Behaviour control mask / Behaviour control masks of check DFC_DevLibBattUHi"
    VALUE
    0x80800B17
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_DevLibBattULo_C
    "Behaviour control mask / Behaviour control masks of check DFC_DevLibBattULo"
    VALUE
    0x80800B18
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_TimeUpDownDebFault_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_TimeUpDownDebFault"
    VALUE
    0x80800B19
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA13OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA13OR"
    VALUE
    0x80800B1A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA13SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA13SCB"
    VALUE
    0x80800B1B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA13SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA13SCG"
    VALUE
    0x80800B1C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA14OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA14OR"
    VALUE
    0x80800B1D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA14SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA14SCB"
    VALUE
    0x80800B1E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA14SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA14SCG"
    VALUE
    0x80800B1F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA21OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA21OR"
    VALUE
    0x80800B20
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA21SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA21SCB"
    VALUE
    0x80800B21
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA21SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA21SCG"
    VALUE
    0x80800B22
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA22OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA22OR"
    VALUE
    0x80800B23
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA22SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA22SCB"
    VALUE
    0x80800B24
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA22SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA22SCG"
    VALUE
    0x80800B25
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA23OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA23OR"
    VALUE
    0x80800B26
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA23SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA23SCB"
    VALUE
    0x80800B27
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA23SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA23SCG"
    VALUE
    0x80800B28
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA24OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA24OR"
    VALUE
    0x80800B29
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA24SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA24SCB"
    VALUE
    0x80800B2A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA24SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA24SCG"
    VALUE
    0x80800B2B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA25OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA25OR"
    VALUE
    0x80800B2C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA25SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA25SCB"
    VALUE
    0x80800B2D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA25SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA25SCG"
    VALUE
    0x80800B2E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA26OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA26OR"
    VALUE
    0x80800B2F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA26SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA26SCB"
    VALUE
    0x80800B30
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA26SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA26SCG"
    VALUE
    0x80800B31
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA27OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA27OR"
    VALUE
    0x80800B32
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA27SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA27SCB"
    VALUE
    0x80800B33
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
