    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA29SCG"
    VALUE
    0x808064CE
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA36AicSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA36AicSCB"
    VALUE
    0x808064CF
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA36AicSCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA36AicSCG"
    VALUE
    0x808064D0
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA36OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA36OR"
    VALUE
    0x808064D1
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA36SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA36SCB"
    VALUE
    0x808064D2
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA36SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA36SCG"
    VALUE
    0x808064D3
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA36ShuntSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA36ShuntSCB"
    VALUE
    0x808064D4
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA37AicSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA37AicSCB"
    VALUE
    0x808064D5
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA37AicSCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA37AicSCG"
    VALUE
    0x808064D6
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA37OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA37OR"
    VALUE
    0x808064D7
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA37SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA37SCB"
    VALUE
    0x808064D8
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA37SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA37SCG"
    VALUE
    0x808064D9
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA37ShuntSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA37ShuntSCB"
    VALUE
    0x808064DA
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA38AicSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA38AicSCB"
    VALUE
    0x808064DB
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA38AicSCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA38AicSCG"
    VALUE
    0x808064DC
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA38OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA38OR"
    VALUE
    0x808064DD
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA38SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA38SCB"
    VALUE
    0x808064DE
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA38SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA38SCG"
    VALUE
    0x808064DF
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA38ShuntSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA38ShuntSCB"
    VALUE
    0x808064E0
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA39AicSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA39AicSCB"
    VALUE
    0x808064E1
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA39AicSCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA39AicSCG"
    VALUE
    0x808064E2
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA39OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA39OR"
    VALUE
    0x808064E3
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA39SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA39SCB"
    VALUE
    0x808064E4
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA39SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA39SCG"
    VALUE
    0x808064E5
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA39ShuntSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA39ShuntSCB"
    VALUE
    0x808064E6
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA40OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA40OR"
    VALUE
    0x808064E7
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA40SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA40SCB"
    VALUE
    0x808064E8
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA40SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA40SCG"
    VALUE
    0x808064E9
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA41OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA41OR"
    VALUE
    0x808064EA
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA41SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA41SCB"
    VALUE
    0x808064EB
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA41SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA41SCG"
    VALUE
    0x808064EC
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA42OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA42OR"
    VALUE
    0x808064ED
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA42SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA42SCB"
    VALUE
    0x808064EE
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA42SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA42SCG"
    VALUE
    0x808064EF
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA43AicSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA43AicSCB"
    VALUE
    0x808064F0
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA43AicSCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA43AicSCG"
    VALUE
    0x808064F1
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA43OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA43OR"
    VALUE
    0x808064F2
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA43SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA43SCB"
    VALUE
    0x808064F3
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA43SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA43SCG"
    VALUE
    0x808064F4
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA43ShuntSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA43ShuntSCB"
    VALUE
    0x808064F5
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA44OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA44OL"
    VALUE
    0x808064F6
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA44SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA44SCB"
    VALUE
    0x808064F7
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA44SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA44SCG"
    VALUE
    0x808064F8
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA57OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA57OR"
    VALUE
    0x808064F9
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA57SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA57SCB"
    VALUE
    0x808064FA
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA57SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA57SCG"
    VALUE
    0x808064FB
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA59OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA59OL"
    VALUE
    0x808064FC
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA59SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA59SCB"
    VALUE
    0x808064FD
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA59SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA59SCG"
    VALUE
    0x808064FE
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK10OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK10OR"
    VALUE
    0x808064FF
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK10SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK10SCB"
    VALUE
    0x80806500
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK10SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK10SCG"
    VALUE
    0x80806501
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK11OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK11OR"
    VALUE
    0x80806502
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK11SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK11SCB"
    VALUE
    0x80806503
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK11SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK11SCG"
    VALUE
    0x80806504
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK30AicSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK30AicSCB"
    VALUE
    0x80806505
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK30AicSCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK30AicSCG"
    VALUE
    0x80806506
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK30OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK30OR"
    VALUE
    0x80806507
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK30SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK30SCB"
    VALUE
    0x80806508
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK30SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK30SCG"
    VALUE
    0x80806509
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK30ShuntSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK30ShuntSCB"
    VALUE
    0x8080650A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK31OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK31OR"
    VALUE
    0x8080650B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK31SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK31SCB"
    VALUE
    0x8080650C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK31SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK31SCG"
    VALUE
    0x8080650D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK32OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK32OR"
    VALUE
    0x8080650E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK32SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK32SCB"
    VALUE
    0x8080650F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK32SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK32SCG"
    VALUE
    0x80806510
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK33OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK33OR"
    VALUE
    0x80806511
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK33SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK33SCB"
    VALUE
    0x80806512
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK33SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK33SCG"
    VALUE
    0x80806513
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK34OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK34OR"
    VALUE
    0x80806514
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK34SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK34SCB"
    VALUE
    0x80806515
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK34SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK34SCG"
    VALUE
    0x80806516
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK35OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK35OR"
    VALUE
    0x80806517
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK35SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK35SCB"
    VALUE
    0x80806518
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK35SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK35SCG"
    VALUE
    0x80806519
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK36OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK36OR"
    VALUE
    0x8080651A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK36SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK36SCB"
    VALUE
    0x8080651B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK36SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK36SCG"
    VALUE
    0x8080651C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK37AicSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK37AicSCB"
    VALUE
    0x8080651D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK37AicSCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK37AicSCG"
    VALUE
    0x8080651E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK37OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK37OR"
    VALUE
    0x8080651F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK37SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK37SCB"
    VALUE
    0x80806520
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK37SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK37SCG"
    VALUE
    0x80806521
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK37ShuntSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK37ShuntSCB"
    VALUE
    0x80806522
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK38AicSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK38AicSCB"
    VALUE
    0x80806523
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK38AicSCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK38AicSCG"
    VALUE
    0x80806524
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK38OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK38OR"
    VALUE
    0x80806525
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK38SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK38SCB"
    VALUE
    0x80806526
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK38SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK38SCG"
    VALUE
    0x80806527
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK38ShuntSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK38ShuntSCB"
    VALUE
    0x80806528
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK39AicSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK39AicSCB"
    VALUE
    0x80806529
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK39AicSCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK39AicSCG"
    VALUE
    0x8080652A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK39OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK39OR"
    VALUE
    0x8080652B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK39SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK39SCB"
    VALUE
    0x8080652C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK39SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK39SCG"
    VALUE
    0x8080652D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK39ShuntSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK39ShuntSCB"
    VALUE
    0x8080652E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK40AicSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK40AicSCB"
    VALUE
    0x8080652F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK40AicSCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK40AicSCG"
    VALUE
    0x80806530
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK40OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK40OR"
    VALUE
    0x80806531
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK40SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK40SCB"
    VALUE
    0x80806532
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK40SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK40SCG"
    VALUE
    0x80806533
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK40ShuntSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK40ShuntSCB"
    VALUE
    0x80806534
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK41AicSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK41AicSCB"
    VALUE
    0x80806535
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK41AicSCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK41AicSCG"
    VALUE
    0x80806536
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK41OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK41OR"
    VALUE
    0x80806537
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK41SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK41SCB"
    VALUE
    0x80806538
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK41SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK41SCG"
    VALUE
    0x80806539
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK41ShuntSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK41ShuntSCB"
    VALUE
    0x8080653A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK42AicSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK42AicSCB"
    VALUE
    0x8080653B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK42AicSCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK42AicSCG"
    VALUE
    0x8080653C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK42OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK42OR"
    VALUE
    0x8080653D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK42SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK42SCB"
    VALUE
    0x8080653E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK42SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK42SCG"
    VALUE
    0x8080653F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK42ShuntSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK42ShuntSCB"
    VALUE
    0x80806540
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK43OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK43OR"
    VALUE
    0x80806541
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK43SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK43SCB"
    VALUE
    0x80806542
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK43SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK43SCG"
    VALUE
    0x80806543
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK44AicSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK44AicSCB"
    VALUE
    0x80806544
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK44AicSCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK44AicSCG"
    VALUE
    0x80806545
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK44OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK44OR"
    VALUE
    0x80806546
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK44SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK44SCB"
    VALUE
    0x80806547
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK44SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK44SCG"
    VALUE
    0x80806548
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK44ShuntSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK44ShuntSCB"
    VALUE
    0x80806549
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK45AicSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK45AicSCB"
    VALUE
    0x8080654A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK45AicSCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK45AicSCG"
    VALUE
    0x8080654B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK45OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK45OR"
    VALUE
    0x8080654C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK45SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK45SCB"
    VALUE
    0x8080654D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK45SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK45SCG"
    VALUE
    0x8080654E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK45ShuntSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK45ShuntSCB"
    VALUE
    0x8080654F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK52OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK52OR"
    VALUE
    0x80806550
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK52SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK52SCB"
    VALUE
    0x80806551
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK52SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK52SCG"
    VALUE
    0x80806552
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK53OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK53OR"
    VALUE
    0x80806553
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK53SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK53SCB"
    VALUE
    0x80806554
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK53SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK53SCG"
    VALUE
    0x80806555
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK54AicSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK54AicSCB"
    VALUE
    0x80806556
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK54AicSCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK54AicSCG"
    VALUE
    0x80806557
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK54OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK54OR"
    VALUE
    0x80806558
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK54SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK54SCB"
    VALUE
    0x80806559
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK54SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK54SCG"
    VALUE
    0x8080655A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK54ShuntSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK54ShuntSCB"
    VALUE
    0x8080655B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK55AicSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK55AicSCB"
    VALUE
    0x8080655C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK55AicSCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK55AicSCG"
    VALUE
    0x8080655D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK55OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK55OR"
    VALUE
    0x8080655E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK55SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK55SCB"
    VALUE
    0x8080655F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK55SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK55SCG"
    VALUE
    0x80806560
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK55ShuntSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK55ShuntSCB"
    VALUE
    0x80806561
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK56OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK56OR"
    VALUE
    0x80806562
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK56SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK56SCB"
    VALUE
    0x80806563
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK56SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK56SCG"
    VALUE
    0x80806564
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK57OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK57OR"
    VALUE
    0x80806565
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK57SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK57SCB"
    VALUE
    0x80806566
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK57SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK57SCG"
    VALUE
    0x80806567
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK58OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK58OR"
    VALUE
    0x80806568
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK58SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK58SCB"
    VALUE
    0x80806569
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK58SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK58SCG"
    VALUE
    0x8080656A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK59OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK59OR"
    VALUE
    0x8080656B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK59SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK59SCB"
    VALUE
    0x8080656C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK59SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK59SCG"
    VALUE
    0x8080656D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK60OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK60OR"
    VALUE
    0x8080656E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK60SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK60SCB"
    VALUE
    0x8080656F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK60SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK60SCG"
    VALUE
    0x80806570
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK61AicSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK61AicSCB"
    VALUE
    0x80806571
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK61AicSCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK61AicSCG"
    VALUE
    0x80806572
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK61OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK61OR"
    VALUE
    0x80806573
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK61SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK61SCB"
    VALUE
    0x80806574
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK61SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK61SCG"
    VALUE
    0x80806575
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK61ShuntSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK61ShuntSCB"
    VALUE
    0x80806576
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK62OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK62OR"
    VALUE
    0x80806577
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK62SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK62SCB"
    VALUE
    0x80806578
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK62SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK62SCG"
    VALUE
    0x80806579
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK63AicSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK63AicSCB"
    VALUE
    0x8080657A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK63AicSCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK63AicSCG"
    VALUE
    0x8080657B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK63OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK63OR"
    VALUE
    0x8080657C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK63SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK63SCB"
    VALUE
    0x8080657D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK63SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK63SCG"
    VALUE
    0x8080657E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK63ShuntSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK63ShuntSCB"
    VALUE
    0x8080657F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK64AicSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK64AicSCB"
    VALUE
    0x80806580
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK64AicSCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK64AicSCG"
    VALUE
    0x80806581
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK64OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK64OR"
    VALUE
    0x80806582
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK64SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK64SCB"
    VALUE
    0x80806583
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK64SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK64SCG"
    VALUE
    0x80806584
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK64ShuntSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK64ShuntSCB"
    VALUE
    0x80806585
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK65AicSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK65AicSCB"
    VALUE
    0x80806586
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK65AicSCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK65AicSCG"
    VALUE
    0x80806587
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK65OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK65OR"
    VALUE
    0x80806588
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK65SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK65SCB"
    VALUE
    0x80806589
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK65SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK65SCG"
    VALUE
    0x8080658A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK65ShuntSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK65ShuntSCB"
    VALUE
    0x8080658B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK74OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK74OR"
    VALUE
    0x8080658C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK74SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK74SCB"
    VALUE
    0x8080658D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK74SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK74SCG"
    VALUE
    0x8080658E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK75OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK75OR"
    VALUE
    0x8080658F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK75SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK75SCB"
    VALUE
    0x80806590
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK75SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK75SCG"
    VALUE
    0x80806591
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK76OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK76OR"
    VALUE
    0x80806592
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK76SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK76SCB"
    VALUE
    0x80806593
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK76SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK76SCG"
    VALUE
    0x80806594
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK77OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK77OR"
    VALUE
    0x80806595
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK77SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK77SCB"
    VALUE
    0x80806596
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK77SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK77SCG"
    VALUE
    0x80806597
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK78OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK78OR"
    VALUE
    0x80806598
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK78SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK78SCB"
    VALUE
    0x80806599
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK78SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK78SCG"
    VALUE
    0x8080659A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_DvUBAT_FWs_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_DvUBAT_FWs"
    VALUE
    0x8080659B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_OVErr_VPR6_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_OVErr_VPR6"
    VALUE
    0x8080659C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_OVWarn_VPR6_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_OVWarn_VPR6"
    VALUE
    0x8080659D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3"
    VALUE
    0x8080659E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2"
    VALUE
    0x8080659F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_OV_UBAT_MON_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_OV_UBAT_MON"
    VALUE
    0x808065A0
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_OV_UBRM24_FLEXIN_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_OV_UBRM24_FLEXIN"
    VALUE
    0x808065A1
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_OV_UBRM24_LOADS_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_OV_UBRM24_LOADS"
    VALUE
    0x808065A2
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_OV_UBRM24_MON_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_OV_UBRM24_MON"
    VALUE
    0x808065A3
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_OV_VDD5_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_OV_VDD5"
    VALUE
    0x808065A4
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_OV_VDD5_IN_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_OV_VDD5_IN"
    VALUE
    0x808065A5
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_OV_VPR6_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_OV_VPR6"
    VALUE
    0x808065A6
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_OV_VSS3_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_OV_VSS3"
    VALUE
    0x808065A7
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_OV_VSS4_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_OV_VSS4"
    VALUE
    0x808065A8
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_Temp1_HTErr_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_Temp1_HTErr"
    VALUE
    0x808065A9
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_Temp1_HTWarn_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_Temp1_HTWarn"
    VALUE
    0x808065AA
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_Temp2_HTErr_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_Temp2_HTErr"
    VALUE
    0x808065AB
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_Temp2_HTWarn_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_Temp2_HTWarn"
    VALUE
    0x808065AC
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3"
    VALUE
    0x808065AD
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2"
    VALUE
    0x808065AE
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_UV_VDD5_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_UV_VDD5"
    VALUE
    0x808065AF
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_UV_VDD5_IN_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_UV_VDD5_IN"
    VALUE
    0x808065B0
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_UV_VPR6_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_UV_VPR6"
    VALUE
    0x808065B1
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_UV_VSS3_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_UV_VSS3"
    VALUE
    0x808065B2
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_UV_VSS4_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_UV_VSS4"
    VALUE
    0x808065B3
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA01OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA01OL"
    VALUE
    0x808065B4
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA01OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA01OT"
    VALUE
    0x808065B5
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA01SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA01SCB"
    VALUE
    0x808065B6
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA01SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA01SCG"
    VALUE
    0x808065B7
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA02OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA02OL"
    VALUE
    0x808065B8
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA02OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA02OR"
    VALUE
    0x808065B9
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA02OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA02OT"
    VALUE
    0x808065BA
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA02SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA02SCB"
    VALUE
    0x808065BB
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA02SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA02SCG"
    VALUE
    0x808065BC
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA03OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA03OL"
    VALUE
    0x808065BD
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA03OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA03OT"
    VALUE
    0x808065BE
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA03SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA03SCB"
    VALUE
    0x808065BF
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA03SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA03SCG"
    VALUE
    0x808065C0
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA04OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA04OL"
    VALUE
    0x808065C1
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA04OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA04OT"
    VALUE
    0x808065C2
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA04SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA04SCB"
    VALUE
    0x808065C3
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA04SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA04SCG"
    VALUE
    0x808065C4
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA05OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA05OL"
    VALUE
    0x808065C5
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA05OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA05OR"
    VALUE
    0x808065C6
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA05OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA05OT"
    VALUE
    0x808065C7
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA05SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA05SCB"
    VALUE
    0x808065C8
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA05SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA05SCG"
    VALUE
    0x808065C9
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA06OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA06OL"
    VALUE
    0x808065CA
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA06OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA06OR"
    VALUE
    0x808065CB
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA06OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA06OT"
    VALUE
    0x808065CC
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA06SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA06SCB"
    VALUE
    0x808065CD
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA06SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA06SCG"
    VALUE
    0x808065CE
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA07OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA07OL"
    VALUE
    0x808065CF
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA07OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA07OT"
    VALUE
    0x808065D0
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA07SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA07SCB"
    VALUE
    0x808065D1
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA07SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA07SCG"
    VALUE
    0x808065D2
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA08OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA08OL"
    VALUE
    0x808065D3
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA08OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA08OT"
    VALUE
    0x808065D4
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA08SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA08SCB"
    VALUE
    0x808065D5
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA08SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA08SCG"
    VALUE
    0x808065D6
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA09OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA09OL"
    VALUE
    0x808065D7
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA09OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA09OR"
    VALUE
    0x808065D8
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA09OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA09OT"
    VALUE
    0x808065D9
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA09SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA09SCB"
    VALUE
    0x808065DA
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA09SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA09SCG"
    VALUE
    0x808065DB
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA10OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA10OL"
    VALUE
    0x808065DC
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA10OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA10OT"
    VALUE
    0x808065DD
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA10SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA10SCB"
    VALUE
    0x808065DE
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA10SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA10SCG"
    VALUE
    0x808065DF
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA11OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA11OL"
    VALUE
    0x808065E0
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA11OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA11OT"
    VALUE
    0x808065E1
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA11SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA11SCB"
    VALUE
    0x808065E2
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA11SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA11SCG"
    VALUE
    0x808065E3
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA12OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA12OR"
    VALUE
    0x808065E4
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA12SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA12SCB"
    VALUE
    0x808065E5
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA12SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA12SCG"
    VALUE
    0x808065E6
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA16OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA16OL"
    VALUE
    0x808065E7
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA16OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA16OT"
    VALUE
    0x808065E8
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA16SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA16SCB"
    VALUE
    0x808065E9
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA16SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA16SCG"
    VALUE
    0x808065EA
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA17OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA17OL"
    VALUE
    0x808065EB
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA17OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA17OR"
    VALUE
    0x808065EC
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA17OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA17OT"
    VALUE
    0x808065ED
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA17SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA17SCB"
    VALUE
    0x808065EE
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA17SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA17SCG"
    VALUE
    0x808065EF
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA18OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA18OL"
    VALUE
    0x808065F0
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA18OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA18OT"
    VALUE
    0x808065F1
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA18SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA18SCB"
    VALUE
    0x808065F2
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA18SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA18SCG"
    VALUE
    0x808065F3
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA19OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA19OL"
    VALUE
    0x808065F4
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA19OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA19OR"
    VALUE
    0x808065F5
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA19OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA19OT"
    VALUE
    0x808065F6
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA19SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA19SCB"
    VALUE
    0x808065F7
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA19SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA19SCG"
    VALUE
    0x808065F8
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA20OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA20OL"
    VALUE
    0x808065F9
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA20OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA20OR"
    VALUE
    0x808065FA
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA20OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA20OT"
    VALUE
    0x808065FB
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA20SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA20SCB"
    VALUE
    0x808065FC
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA20SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA20SCG"
    VALUE
    0x808065FD
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA31OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA31OL"
    VALUE
    0x808065FE
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA31OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA31OR"
    VALUE
    0x808065FF
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA31OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA31OT"
    VALUE
    0x80806600
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA31SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA31SCB"
    VALUE
    0x80806601
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA31SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA31SCG"
    VALUE
    0x80806602
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA32OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA32OL"
    VALUE
    0x80806603
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA32OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA32OR"
    VALUE
    0x80806604
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA32OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA32OT"
    VALUE
    0x80806605
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA32SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA32SCB"
    VALUE
    0x80806606
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA32SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA32SCG"
    VALUE
    0x80806607
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA33OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA33OL"
    VALUE
    0x80806608
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA33OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA33OR"
    VALUE
    0x80806609
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA33OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA33OT"
    VALUE
    0x8080660A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA33SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA33SCB"
    VALUE
    0x8080660B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA33SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA33SCG"
    VALUE
    0x8080660C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA34OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA34OL"
    VALUE
    0x8080660D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA34OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA34OR"
    VALUE
    0x8080660E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA34OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA34OT"
    VALUE
    0x8080660F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA34SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA34SCB"
    VALUE
    0x80806610
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA34SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA34SCG"
    VALUE
    0x80806611
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA35OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA35OL"
    VALUE
    0x80806612
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA35OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA35OR"
    VALUE
    0x80806613
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA35OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA35OT"
    VALUE
    0x80806614
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA35SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA35SCB"
    VALUE
    0x80806615
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA35SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA35SCG"
    VALUE
    0x80806616
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA46OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA46OL"
    VALUE
    0x80806617
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA46OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA46OR"
    VALUE
    0x80806618
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA46OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA46OT"
    VALUE
    0x80806619
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA46SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA46SCB"
    VALUE
    0x8080661A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA46SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA46SCG"
    VALUE
    0x8080661B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA47OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA47OL"
    VALUE
    0x8080661C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA47OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA47OR"
    VALUE
    0x8080661D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA47OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA47OT"
    VALUE
    0x8080661E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA47SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA47SCB"
    VALUE
    0x8080661F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA47SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA47SCG"
    VALUE
    0x80806620
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA48OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA48OL"
    VALUE
    0x80806621
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA48OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA48OR"
    VALUE
    0x80806622
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA48OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA48OT"
    VALUE
    0x80806623
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA48SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA48SCB"
    VALUE
    0x80806624
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA48SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA48SCG"
    VALUE
    0x80806625
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA49OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA49OL"
    VALUE
    0x80806626
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA49OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA49OT"
    VALUE
    0x80806627
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA49SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA49SCB"
    VALUE
    0x80806628
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA49SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA49SCG"
    VALUE
    0x80806629
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA50OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA50OL"
    VALUE
    0x8080662A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA50OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA50OT"
    VALUE
    0x8080662B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA50SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA50SCB"
    VALUE
    0x8080662C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA50SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA50SCG"
    VALUE
    0x8080662D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA51OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA51OL"
    VALUE
    0x8080662E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA51OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA51OR"
    VALUE
    0x8080662F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA51OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA51OT"
    VALUE
    0x80806630
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA51SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA51SCB"
    VALUE
    0x80806631
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA51SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA51SCG"
    VALUE
    0x80806632
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA52OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA52OL"
    VALUE
    0x80806633
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA52OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA52OR"
    VALUE
    0x80806634
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA52OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA52OT"
    VALUE
    0x80806635
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA52SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA52SCB"
    VALUE
    0x80806636
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA52SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA52SCG"
    VALUE
    0x80806637
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA53OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA53OL"
    VALUE
    0x80806638
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA53OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA53OR"
    VALUE
    0x80806639
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA53OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA53OT"
    VALUE
    0x8080663A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA53SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA53SCB"
    VALUE
    0x8080663B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA53SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA53SCG"
    VALUE
    0x8080663C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA54OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA54OL"
    VALUE
    0x8080663D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA54OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA54OR"
    VALUE
    0x8080663E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA54OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA54OT"
    VALUE
    0x8080663F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA54SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA54SCB"
    VALUE
    0x80806640
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA54SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA54SCG"
    VALUE
    0x80806641
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA55OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA55OL"
    VALUE
    0x80806642
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA55OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA55OT"
    VALUE
    0x80806643
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA55SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA55SCB"
    VALUE
    0x80806644
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA55SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA55SCG"
    VALUE
    0x80806645
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA56OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA56OL"
    VALUE
    0x80806646
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA56OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA56OT"
    VALUE
    0x80806647
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA56SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA56SCB"
    VALUE
    0x80806648
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA56SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA56SCG"
    VALUE
    0x80806649
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA58OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA58OL"
    VALUE
    0x8080664A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA58OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA58OT"
    VALUE
    0x8080664B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA58SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA58SCB"
    VALUE
    0x8080664C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA58SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA58SCG"
    VALUE
    0x8080664D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK07OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK07OL"
    VALUE
    0x8080664E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK07OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK07OR"
    VALUE
    0x8080664F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK07OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK07OT"
    VALUE
    0x80806650
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK07SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK07SCB"
    VALUE
    0x80806651
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK07SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK07SCG"
    VALUE
    0x80806652
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK08OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK08OL"
    VALUE
    0x80806653
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK08OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK08OR"
    VALUE
    0x80806654
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK08OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK08OT"
    VALUE
    0x80806655
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK08SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK08SCB"
    VALUE
    0x80806656
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK08SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK08SCG"
    VALUE
    0x80806657
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK09OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK09OL"
    VALUE
    0x80806658
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK09OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK09OR"
    VALUE
    0x80806659
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK09OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK09OT"
    VALUE
    0x8080665A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK09SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK09SCB"
    VALUE
    0x8080665B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK09SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK09SCG"
    VALUE
    0x8080665C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK12OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK12OL"
    VALUE
    0x8080665D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK12OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK12OT"
    VALUE
    0x8080665E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK12SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK12SCB"
    VALUE
    0x8080665F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK12SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK12SCG"
    VALUE
    0x80806660
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK13OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK13OL"
    VALUE
    0x80806661
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK13OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK13OT"
    VALUE
    0x80806662
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK13SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK13SCB"
    VALUE
    0x80806663
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK13SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK13SCG"
    VALUE
    0x80806664
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK14OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK14OL"
    VALUE
    0x80806665
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK14OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK14OR"
    VALUE
    0x80806666
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK14OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK14OT"
    VALUE
    0x80806667
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK14SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK14SCB"
    VALUE
    0x80806668
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK14SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK14SCG"
    VALUE
    0x80806669
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK15OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK15OL"
    VALUE
    0x8080666A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK15OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK15OR"
    VALUE
    0x8080666B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK15OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK15OT"
    VALUE
    0x8080666C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK15SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK15SCB"
    VALUE
    0x8080666D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK15SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK15SCG"
    VALUE
    0x8080666E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK16OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK16OL"
    VALUE
    0x8080666F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK16OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK16OR"
    VALUE
    0x80806670
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK16OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK16OT"
    VALUE
    0x80806671
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK16SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK16SCB"
    VALUE
    0x80806672
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK16SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK16SCG"
    VALUE
    0x80806673
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK17OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK17OL"
    VALUE
    0x80806674
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK17OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK17OR"
    VALUE
    0x80806675
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK17OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK17OT"
    VALUE
    0x80806676
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK17SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK17SCB"
    VALUE
    0x80806677
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK17SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK17SCG"
    VALUE
    0x80806678
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK25OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK25OR"
    VALUE
    0x80806679
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK25SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK25SCB"
    VALUE
    0x8080667A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK25SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK25SCG"
    VALUE
    0x8080667B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK29OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK29OL"
    VALUE
    0x8080667C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK29OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK29OR"
    VALUE
    0x8080667D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK29OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK29OT"
    VALUE
    0x8080667E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK29SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK29SCB"
    VALUE
    0x8080667F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK29SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK29SCG"
    VALUE
    0x80806680
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK51OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK51OL"
    VALUE
    0x80806681
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK51OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK51OT"
    VALUE
    0x80806682
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK51SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK51SCB"
    VALUE
    0x80806683
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK51SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK51SCG"
    VALUE
    0x80806684
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK62OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK62OR"
    VALUE
    0x80806685
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK62SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK62SCB"
    VALUE
    0x80806686
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK62SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK62SCG"
    VALUE
    0x80806687
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK73OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK73OL"
    VALUE
    0x80806688
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK73OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK73OR"
    VALUE
    0x80806689
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK73OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK73OT"
    VALUE
    0x8080668A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK73SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK73SCB"
    VALUE
    0x8080668B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK73SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK73SCG"
    VALUE
    0x8080668C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK80OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK80OL"
    VALUE
    0x8080668D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK80OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK80OT"
    VALUE
    0x8080668E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK80SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK80SCB"
    VALUE
    0x8080668F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK80SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK80SCG"
    VALUE
    0x80806690
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK81OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK81OL"
    VALUE
    0x80806691
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK81OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK81OT"
    VALUE
    0x80806692
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK81SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK81SCB"
    VALUE
    0x80806693
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK81SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK81SCG"
    VALUE
    0x80806694
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK82OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK82OL"
    VALUE
    0x80806695
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK82OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK82OT"
    VALUE
    0x80806696
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK82SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK82SCB"
    VALUE
    0x80806697
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK82SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK82SCG"
    VALUE
    0x80806698
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK83OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK83OL"
    VALUE
    0x80806699
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK83OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK83OT"
    VALUE
    0x8080669A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK83SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK83SCB"
    VALUE
    0x8080669B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK83SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK83SCG"
    VALUE
    0x8080669C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK84OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK84OL"
    VALUE
    0x8080669D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK84OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK84OT"
    VALUE
    0x8080669E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK84SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK84SCB"
    VALUE
    0x8080669F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK84SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK84SCG"
    VALUE
    0x808066A0
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK85OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK85OL"
    VALUE
    0x808066A1
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK85OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK85OT"
    VALUE
    0x808066A2
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK85SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK85SCB"
    VALUE
    0x808066A3
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK85SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK85SCG"
    VALUE
    0x808066A4
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK86OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK86OL"
    VALUE
    0x808066A5
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK86OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK86OT"
    VALUE
    0x808066A6
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK86SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK86SCB"
    VALUE
    0x808066A7
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK86SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK86SCG"
    VALUE
    0x808066A8
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK87OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK87OL"
    VALUE
    0x808066A9
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK87OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK87OT"
    VALUE
    0x808066AA
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK87SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK87SCB"
    VALUE
    0x808066AB
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK87SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK87SCG"
    VALUE
    0x808066AC
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_EventUpDownDebFault_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_EventUpDownDebFault"
    VALUE
    0x808066AD
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_DSMDummy_C
    "AUTOSAR: Matching DTC group / Check DFC_DSMDummy"
    VALUE
    0x808066AE
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canGetDataNoBuf_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canGetDataNoBuf"
    VALUE
    0x808066AF
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canGetDataParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canGetDataParam"
    VALUE
    0x808066B0
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canGetDataboxNoInit_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canGetDataboxNoInit"
    VALUE
    0x808066B1
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canGetDataboxParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canGetDataboxParam"
    VALUE
    0x808066B2
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canGetRxBufStatusParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canGetRxBufStatusParam"
    VALUE
    0x808066B3
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canGetStatusParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canGetStatusParam"
    VALUE
    0x808066B4
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canGetTxBufStatusParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canGetTxBufStatusParam"
    VALUE
    0x808066B5
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canInitParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canInitParam"
    VALUE
    0x808066B6
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canInitRxDataboxOverlap_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canInitRxDataboxOverlap"
    VALUE
    0x808066B7
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canInitRxDataboxParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canInitRxDataboxParam"
    VALUE
    0x808066B8
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canInitTxDataboxParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canInitTxDataboxParam"
    VALUE
    0x808066B9
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canIpduGroupControl_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canIpduGroupControl"
    VALUE
    0x808066BA
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canIsDataboxFreeNoInit_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canIsDataboxFreeNoInit"
    VALUE
    0x808066BB
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canIsDataboxFreeParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canIsDataboxFreeParam"
    VALUE
    0x808066BC
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canIsTxEmptyParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canIsTxEmptyParam"
    VALUE
    0x808066BD
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canRegBusOffCallbInvState_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canRegBusOffCallbInvState"
    VALUE
    0x808066BE
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canRegBusOffCallbParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canRegBusOffCallbParam"
    VALUE
    0x808066BF
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canRegRxBufInvState_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canRegRxBufInvState"
    VALUE
    0x808066C0
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canRegRxBufOverlap_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canRegRxBufOverlap"
    VALUE
    0x808066C1
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canRegRxBufParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canRegRxBufParam"
    VALUE
    0x808066C2
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canRegRxCallbInvState_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canRegRxCallbInvState"
    VALUE
    0x808066C3
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canRegRxCallbParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canRegRxCallbParam"
    VALUE
    0x808066C4
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canRegRxDataboxInvNumb_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canRegRxDataboxInvNumb"
    VALUE
    0x808066C5
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canRegRxDataboxInvState_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canRegRxDataboxInvState"
    VALUE
    0x808066C6
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canRegRxDataboxOverlap_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canRegRxDataboxOverlap"
    VALUE
    0x808066C7
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canRegRxDataboxParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canRegRxDataboxParam"
    VALUE
    0x808066C8
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canRegTxBufInvState_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canRegTxBufInvState"
    VALUE
    0x808066C9
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canRegTxBufOverlap_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canRegTxBufOverlap"
    VALUE
    0x808066CA
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canRegTxBufParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canRegTxBufParam"
    VALUE
    0x808066CB
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canRegTxDataboxInvNumb_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canRegTxDataboxInvNumb"
    VALUE
    0x808066CC
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canRegTxDataboxInvState_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canRegTxDataboxInvState"
    VALUE
    0x808066CD
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canRegTxDataboxOverlap_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canRegTxDataboxOverlap"
    VALUE
    0x808066CE
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canRegTxDataboxParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canRegTxDataboxParam"
    VALUE
    0x808066CF
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canResetTxBufParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canResetTxBufParam"
    VALUE
    0x808066D0
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canSendDataBufOvfl_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canSendDataBufOvfl"
    VALUE
    0x808066D1
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canSendDataParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canSendDataParam"
    VALUE
    0x808066D2
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canSendDataboxNoInit_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canSendDataboxNoInit"
    VALUE
    0x808066D3
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canSendDataboxParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canSendDataboxParam"
    VALUE
    0x808066D4
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canSetTxCycleParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canSetTxCycleParam"
    VALUE
    0x808066D5
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canStartParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canStartParam"
    VALUE
    0x808066D6
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canStopParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canStopParam"
    VALUE
    0x808066D7
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_can_ClearIpduGroup_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_can_ClearIpduGroup"
    VALUE
    0x808066D8
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_can_ReceiveSignal_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_can_ReceiveSignal"
    VALUE
    0x808066D9
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_can_SendSignal_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_can_SendSignal"
    VALUE
    0x808066DA
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_can_SetIpduGroup_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_can_SetIpduGroup"
    VALUE
    0x808066DB
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_dsmDTCJ1939_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_dsmDTCJ1939"
    VALUE
    0x808066DC
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_dsmDelDTCJ1939_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_dsmDelDTCJ1939"
    VALUE
    0x808066DD
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_dsmDelErrors_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_dsmDelErrors"
    VALUE
    0x808066DE
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_dsmGetDFES_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_dsmGetDFES"
    VALUE
    0x808066DF
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_dsmGetDTCJ1939_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_dsmGetDTCJ1939"
    VALUE
    0x808066E0
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_dsmGetErrors_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_dsmGetErrors"
    VALUE
    0x808066E1
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_dsmGetNumErrors_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_dsmGetNumErrors"
    VALUE
    0x808066E2
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_dsmInitQueueOverflow_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_dsmInitQueueOverflow"
    VALUE
    0x808066E3
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_dsmNumDTCJ1939_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_dsmNumDTCJ1939"
    VALUE
    0x808066E4
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_dsmTesterror_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_dsmTesterror"
    VALUE
    0x808066E5
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_dsmUpdateDebError_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_dsmUpdateDebError"
    VALUE
    0x808066E6
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_dsmUpdateError_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_dsmUpdateError"
    VALUE
    0x808066E7
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_dsmgetDFCStatus_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_dsmgetDFCStatus"
    VALUE
    0x808066E8
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_dsmtestErrorDFC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_dsmtestErrorDFC"
    VALUE
    0x808066E9
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inAi_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inAi"
    VALUE
    0x808066EA
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inAic_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inAic"
    VALUE
    0x808066EB
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inAicCfg_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inAicCfg"
    VALUE
    0x808066EC
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inAicGetStatus_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inAicGetStatus"
    VALUE
    0x808066ED
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inAid_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inAid"
    VALUE
    0x808066EE
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inAidCfg_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inAidCfg"
    VALUE
    0x808066EF
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inAiv_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inAiv"
    VALUE
    0x808066F0
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inAivCfg_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inAivCfg"
    VALUE
    0x808066F1
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inAivGetStatus_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inAivGetStatus"
    VALUE
    0x808066F2
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inDi_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inDi"
    VALUE
    0x808066F3
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inFi_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inFi"
    VALUE
    0x808066F4
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inFiCfg_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inFiCfg"
    VALUE
    0x808066F5
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inFiGetStatus_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inFiGetStatus"
    VALUE
    0x808066F6
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inFi_Buffered_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inFi_Buffered"
    VALUE
    0x808066F7
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inPhase_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inPhase"
    VALUE
    0x808066F8
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inPhaseGetStatus_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inPhaseGetStatus"
    VALUE
    0x808066F9
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inPhaseResetCounter_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inPhaseResetCounter"
    VALUE
    0x808066FA
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inRi_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inRi"
    VALUE
    0x808066FB
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inRiCfg_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inRiCfg"
    VALUE
    0x808066FC
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inRiCfgTemp_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inRiCfgTemp"
    VALUE
    0x808066FD
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inRiGetStatus_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inRiGetStatus"
    VALUE
    0x808066FE
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inRiGetTemp_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inRiGetTemp"
    VALUE
    0x808066FF
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inSentCopyFDFifo_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inSentCopyFDFifo"
    VALUE
    0x80806700
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inSentDisable_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inSentDisable"
    VALUE
    0x80806701
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inSentEnable_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inSentEnable"
    VALUE
    0x80806702
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inSentGetErrorStatus_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inSentGetErrorStatus"
    VALUE
    0x80806703
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inSentGetFD_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inSentGetFD"
    VALUE
    0x80806704
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inSentGetSD_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inSentGetSD"
    VALUE
    0x80806705
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inSentGetSDDatabox_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inSentGetSDDatabox"
    VALUE
    0x80806706
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inSentGetStatus_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inSentGetStatus"
    VALUE
    0x80806707
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inSentInitSDDatabox_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inSentInitSDDatabox"
    VALUE
    0x80806708
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inSentRegisterCopyFDFifo_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inSentRegisterCopyFDFifo"
    VALUE
    0x80806709
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inSentRegisterFDFifo_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inSentRegisterFDFifo"
    VALUE
    0x8080670A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inSentRegisterSDDataboxes_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inSentRegisterSDDataboxes"
    VALUE
    0x8080670B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_isobusCanRxBufferOverflow_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_isobusCanRxBufferOverflow"
    VALUE
    0x8080670C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_isobusGetCaAddrParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_isobusGetCaAddrParam"
    VALUE
    0x8080670D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_isobusGetDiagnosticParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_isobusGetDiagnosticParam"
    VALUE
    0x8080670E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_isobusGetRxDataboxStatusParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_isobusGetRxDataboxStatusParam"
    VALUE
    0x8080670F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_isobusGetStatusParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_isobusGetStatusParam"
    VALUE
    0x80806710
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_isobusInitCommCaMissing_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_isobusInitCommCaMissing"
    VALUE
    0x80806711
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_isobusInitCommParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_isobusInitCommParam"
    VALUE
    0x80806712
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_isobusInitCommState_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_isobusInitCommState"
    VALUE
    0x80806713
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_isobusInitDiagnosticParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_isobusInitDiagnosticParam"
    VALUE
    0x80806714
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_isobusInitFailureListParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_isobusInitFailureListParam"
    VALUE
    0x80806715
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_isobusInitRxDataboxParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_isobusInitRxDataboxParam"
    VALUE
    0x80806716
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_isobusInitTxDataboxParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_isobusInitTxDataboxParam"
    VALUE
    0x80806717
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_isobusRegRxDataboxOverlap_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_isobusRegRxDataboxOverlap"
    VALUE
    0x80806718
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_isobusRegRxDataboxParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_isobusRegRxDataboxParam"
    VALUE
    0x80806719
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_isobusRegRxDataboxState_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_isobusRegRxDataboxState"
    VALUE
    0x8080671A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_isobusRegTxDataboxOverlap_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_isobusRegTxDataboxOverlap"
    VALUE
    0x8080671B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_isobusRegTxDataboxParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_isobusRegTxDataboxParam"
    VALUE
    0x8080671C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_isobusRegTxDataboxState_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_isobusRegTxDataboxState"
    VALUE
    0x8080671D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_isobusRegisterErrClrCallbackParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_isobusRegisterErrClrCallbackParam"
    VALUE
    0x8080671E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_isobusRegisterInstancesOverlap_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_isobusRegisterInstancesOverlap"
    VALUE
    0x8080671F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_isobusRegisterInstancesParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_isobusRegisterInstancesParam"
    VALUE
    0x80806720
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_isobusRegisterInstancesState_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_isobusRegisterInstancesState"
    VALUE
    0x80806721
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_isobusSendDataboxParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_isobusSendDataboxParam"
    VALUE
    0x80806722
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_isobusSendRequestPGNParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_isobusSendRequestPGNParam"
    VALUE
    0x80806723
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_isobusSetCaAddrCaUsed_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_isobusSetCaAddrCaUsed"
    VALUE
    0x80806724
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_isobusSetCaAddrComm_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_isobusSetCaAddrComm"
    VALUE
    0x80806725
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_isobusSetCaAddrInvCan_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_isobusSetCaAddrInvCan"
    VALUE
    0x80806726
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_isobusSetCaAddrParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_isobusSetCaAddrParam"
    VALUE
    0x80806727
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_isobusSetCaInfoParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_isobusSetCaInfoParam"
    VALUE
    0x80806728
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_isobusSetCaNameParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_isobusSetCaNameParam"
    VALUE
    0x80806729
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_isobusSftyCanTxErr_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_isobusSftyCanTxErr"
    VALUE
    0x8080672A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_lin_ReceiveSignal_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_lin_ReceiveSignal"
    VALUE
    0x8080672B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_lin_SendSignal_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_lin_SendSignal"
    VALUE
    0x8080672C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_lin_getStatus_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_lin_getStatus"
    VALUE
    0x8080672D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_lin_gotoSleep_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_lin_gotoSleep"
    VALUE
    0x8080672E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_lin_scheduleRequest_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_lin_scheduleRequest"
    VALUE
    0x8080672F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_lin_wakeUp_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_lin_wakeUp"
    VALUE
    0x80806730
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_memFlsCfgShr_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_memFlsCfgShr"
    VALUE
    0x80806731
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_memGetStatus_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_memGetStatus"
    VALUE
    0x80806732
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_memMarkBlock_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_memMarkBlock"
    VALUE
    0x80806733
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_memReadApi1Error_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_memReadApi1Error"
    VALUE
    0x80806734
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_memReadApi2Error_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_memReadApi2Error"
    VALUE
    0x80806735
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_memReadBlock_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_memReadBlock"
    VALUE
    0x80806736
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_memReadCalibInputError_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_memReadCalibInputError"
    VALUE
    0x80806737
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_memReadCalibOuputError_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_memReadCalibOuputError"
    VALUE
    0x80806738
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_memReadSystemError_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_memReadSystemError"
    VALUE
    0x80806739
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_memWriteBlock_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_memWriteBlock"
    VALUE
    0x8080673A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_moOV_FirstConstADC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_moOV_FirstConstADC"
    VALUE
    0x8080673B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_moOV_SecondConstADC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_moOV_SecondConstADC"
    VALUE
    0x8080673C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_moUV_FirstConstADC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_moUV_FirstConstADC"
    VALUE
    0x8080673D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_moUV_SecondConstADC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_moUV_SecondConstADC"
    VALUE
    0x8080673E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_INH_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_INH"
    VALUE
    0x8080673F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_INHLatch_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_INHLatch"
    VALUE
    0x80806740
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_adcPDD_fail_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_adcPDD_fail"
    VALUE
    0x80806741
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_memoryProtection_err_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_memoryProtection_err"
    VALUE
    0x80806742
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA02OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA02OC"
    VALUE
    0x80806743
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA02Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA02Unintended"
    VALUE
    0x80806744
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA03OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA03OC"
    VALUE
    0x80806745
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA03Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA03Unintended"
    VALUE
    0x80806746
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA04OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA04OC"
    VALUE
    0x80806747
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA04Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA04Unintended"
    VALUE
    0x80806748
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA05OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA05OC"
    VALUE
    0x80806749
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA05Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA05Unintended"
    VALUE
    0x8080674A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA07OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA07OC"
    VALUE
    0x8080674B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA07Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA07Unintended"
    VALUE
    0x8080674C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA08OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA08OC"
    VALUE
    0x8080674D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA08Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA08Unintended"
    VALUE
    0x8080674E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA09OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA09OC"
    VALUE
    0x8080674F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA09Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA09Unintended"
    VALUE
    0x80806750
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA10OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA10OC"
    VALUE
    0x80806751
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA10Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA10Unintended"
    VALUE
    0x80806752
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA17OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA17OC"
    VALUE
    0x80806753
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA17Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA17Unintended"
    VALUE
    0x80806754
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA18OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA18OC"
    VALUE
    0x80806755
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA18Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA18Unintended"
    VALUE
    0x80806756
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA19OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA19OC"
    VALUE
    0x80806757
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA19Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA19Unintended"
    VALUE
    0x80806758
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA20OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA20OC"
    VALUE
    0x80806759
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA20Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA20Unintended"
    VALUE
    0x8080675A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA31OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA31OC"
    VALUE
    0x8080675B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA31Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA31Unintended"
    VALUE
    0x8080675C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA32OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA32OC"
    VALUE
    0x8080675D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA32Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA32Unintended"
    VALUE
    0x8080675E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA33OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA33OC"
    VALUE
    0x8080675F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA33Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA33Unintended"
    VALUE
    0x80806760
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA34OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA34OC"
    VALUE
    0x80806761
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA34Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA34Unintended"
    VALUE
    0x80806762
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA35OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA35OC"
    VALUE
    0x80806763
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA35Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA35Unintended"
    VALUE
    0x80806764
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA46OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA46OC"
    VALUE
    0x80806765
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA46Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA46Unintended"
    VALUE
    0x80806766
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA47OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA47OC"
    VALUE
    0x80806767
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA47Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA47Unintended"
    VALUE
    0x80806768
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA48OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA48OC"
    VALUE
    0x80806769
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA48Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA48Unintended"
    VALUE
    0x8080676A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA51OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA51OC"
    VALUE
    0x8080676B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA51Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA51Unintended"
    VALUE
    0x8080676C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA52OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA52OC"
    VALUE
    0x8080676D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA52Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA52Unintended"
    VALUE
    0x8080676E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA53OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA53OC"
    VALUE
    0x8080676F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA53Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA53Unintended"
    VALUE
    0x80806770
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA54OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA54OC"
    VALUE
    0x80806771
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA54Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA54Unintended"
    VALUE
    0x80806772
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outAov_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outAov"
    VALUE
    0x80806773
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outAovCfg_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outAovCfg"
    VALUE
    0x80806774
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outAovCfgPI_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outAovCfgPI"
    VALUE
    0x80806775
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outAovGetStatus_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outAovGetStatus"
    VALUE
    0x80806776
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outAovGetVoltage_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outAovGetVoltage"
    VALUE
    0x80806777
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outAovResetError_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outAovResetError"
    VALUE
    0x80806778
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outDo_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outDo"
    VALUE
    0x80806779
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outDoCfgPwrLs_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outDoCfgPwrLs"
    VALUE
    0x8080677A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outDoDisable_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outDoDisable"
    VALUE
    0x8080677B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outDoGetCurrent_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outDoGetCurrent"
    VALUE
    0x8080677C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outDoGetStatus_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outDoGetStatus"
    VALUE
    0x8080677D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outDoResetError_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outDoResetError"
    VALUE
    0x8080677E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK07OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK07OC"
    VALUE
    0x8080677F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK07Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK07Unintended"
    VALUE
    0x80806780
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK08OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK08OC"
    VALUE
    0x80806781
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK08Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK08Unintended"
    VALUE
    0x80806782
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK09OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK09OC"
    VALUE
    0x80806783
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK09Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK09Unintended"
    VALUE
    0x80806784
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK12OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK12OC"
    VALUE
    0x80806785
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK12Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK12Unintended"
    VALUE
    0x80806786
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK13OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK13OC"
    VALUE
    0x80806787
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK13Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK13Unintended"
    VALUE
    0x80806788
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK14OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK14OC"
    VALUE
    0x80806789
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK14Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK14Unintended"
    VALUE
    0x8080678A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK15OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK15OC"
    VALUE
    0x8080678B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK15Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK15Unintended"
    VALUE
    0x8080678C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK16OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK16OC"
    VALUE
    0x8080678D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK16Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK16Unintended"
    VALUE
    0x8080678E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK17OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK17OC"
    VALUE
    0x8080678F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK17Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK17Unintended"
    VALUE
    0x80806790
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK29OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK29OC"
    VALUE
    0x80806791
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK29Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK29Unintended"
    VALUE
    0x80806792
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK51OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK51OC"
    VALUE
    0x80806793
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK51Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK51Unintended"
    VALUE
    0x80806794
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK73OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK73OC"
    VALUE
    0x80806795
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK73Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK73Unintended"
    VALUE
    0x80806796
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outPo_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outPo"
    VALUE
    0x80806797
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outPoCfg_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outPoCfg"
    VALUE
    0x80806798
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outPoCfgPeriod_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outPoCfgPeriod"
    VALUE
    0x80806799
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outPoCfgPwrLs_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outPoCfgPwrLs"
    VALUE
    0x8080679A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outPoDisable_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outPoDisable"
    VALUE
    0x8080679B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outPoGetCurrent_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outPoGetCurrent"
    VALUE
    0x8080679C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outPoGetStatus_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outPoGetStatus"
    VALUE
    0x8080679D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outPoResetError_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outPoResetError"
    VALUE
    0x8080679E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outPoc_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outPoc"
    VALUE
    0x8080679F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outPocCfg_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outPocCfg"
    VALUE
    0x808067A0
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outPocCfgDither_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outPocCfgDither"
    VALUE
    0x808067A1
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outPocCfgPI_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outPocCfgPI"
    VALUE
    0x808067A2
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outPod_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outPod"
    VALUE
    0x808067A3
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outPodCfg_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outPodCfg"
    VALUE
    0x808067A4
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outPodCfgPeriod_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outPodCfgPeriod"
    VALUE
    0x808067A5
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_rsmFfiApiCallErr_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_rsmFfiApiCallErr"
    VALUE
    0x808067A6
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safout_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safout"
    VALUE
    0x808067A7
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutCfg_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutCfg"
    VALUE
    0x808067A8
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl1_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl1"
    VALUE
    0x808067A9
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl10_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl10"
    VALUE
    0x808067AA
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl10Dev_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl10Dev"
    VALUE
    0x808067AB
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl10OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl10OR"
    VALUE
    0x808067AC
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl11_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl11"
    VALUE
    0x808067AD
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl11Dev_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl11Dev"
    VALUE
    0x808067AE
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl11OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl11OR"
    VALUE
    0x808067AF
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl12_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl12"
    VALUE
    0x808067B0
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl12Dev_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl12Dev"
    VALUE
    0x808067B1
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl12OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl12OR"
    VALUE
    0x808067B2
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl13_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl13"
    VALUE
    0x808067B3
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl13Dev_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl13Dev"
    VALUE
    0x808067B4
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl13OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl13OR"
    VALUE
    0x808067B5
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl14_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl14"
    VALUE
    0x808067B6
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl14Dev_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl14Dev"
    VALUE
    0x808067B7
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl14OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl14OR"
    VALUE
    0x808067B8
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl15_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl15"
    VALUE
    0x808067B9
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl15Dev_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl15Dev"
    VALUE
    0x808067BA
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl15OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl15OR"
    VALUE
    0x808067BB
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl16_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl16"
    VALUE
    0x808067BC
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl16Dev_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl16Dev"
    VALUE
    0x808067BD
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl16OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl16OR"
    VALUE
    0x808067BE
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl17_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl17"
    VALUE
    0x808067BF
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl17Dev_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl17Dev"
    VALUE
    0x808067C0
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl17OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl17OR"
    VALUE
    0x808067C1
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl18_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl18"
    VALUE
    0x808067C2
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl18Dev_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl18Dev"
    VALUE
    0x808067C3
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl18OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl18OR"
    VALUE
    0x808067C4
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl1Dev_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl1Dev"
    VALUE
    0x808067C5
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl1OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl1OR"
    VALUE
    0x808067C6
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl2_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl2"
    VALUE
    0x808067C7
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl2Dev_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl2Dev"
    VALUE
    0x808067C8
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl2OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl2OR"
    VALUE
    0x808067C9
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl3_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl3"
    VALUE
    0x808067CA
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl3Dev_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl3Dev"
    VALUE
    0x808067CB
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl3OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl3OR"
    VALUE
    0x808067CC
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl4_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl4"
    VALUE
    0x808067CD
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl4Dev_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl4Dev"
    VALUE
    0x808067CE
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl4OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl4OR"
    VALUE
    0x808067CF
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl5_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl5"
    VALUE
    0x808067D0
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl5Dev_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl5Dev"
    VALUE
    0x808067D1
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl5OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl5OR"
    VALUE
    0x808067D2
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl6_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl6"
    VALUE
    0x808067D3
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl6Dev_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl6Dev"
    VALUE
    0x808067D4
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl6OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl6OR"
    VALUE
    0x808067D5
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl7_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl7"
    VALUE
    0x808067D6
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl7Dev_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl7Dev"
    VALUE
    0x808067D7
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl7OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl7OR"
    VALUE
    0x808067D8
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl8_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl8"
    VALUE
    0x808067D9
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl8Dev_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl8Dev"
    VALUE
    0x808067DA
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl8OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl8OR"
    VALUE
    0x808067DB
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl9_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl9"
    VALUE
    0x808067DC
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl9Dev_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl9Dev"
    VALUE
    0x808067DD
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl9OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl9OR"
    VALUE
    0x808067DE
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutDevError_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutDevError"
    VALUE
    0x808067DF
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutGetStatus_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutGetStatus"
    VALUE
    0x808067E0
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutIgnoreError_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutIgnoreError"
    VALUE
    0x808067E1
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutResetError_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutResetError"
    VALUE
    0x808067E2
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutUnlock_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutUnlock"
    VALUE
    0x808067E3
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safout_cfgDiag_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safout_cfgDiag"
    VALUE
    0x808067E4
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_secAccessDenied_RC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_secAccessDenied_RC"
    VALUE
    0x808067E5
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_secAccessDenied_WDBI_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_secAccessDenied_WDBI"
    VALUE
    0x808067E6
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_secEvalRespKey_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_secEvalRespKey"
    VALUE
    0x808067E7
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_secFlashingFailure_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_secFlashingFailure"
    VALUE
    0x808067E8
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_secGetLevel_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_secGetLevel"
    VALUE
    0x808067E9
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_secGetRnd_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_secGetRnd"
    VALUE
    0x808067EA
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_secGetSeed_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_secGetSeed"
    VALUE
    0x808067EB
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_secInvalidPassword_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_secInvalidPassword"
    VALUE
    0x808067EC
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_secIsRequestAllowed_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_secIsRequestAllowed"
    VALUE
    0x808067ED
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_secResetLevel_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_secResetLevel"
    VALUE
    0x808067EE
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_secSaveSecret_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_secSaveSecret"
    VALUE
    0x808067EF
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_secSetLevel_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_secSetLevel"
    VALUE
    0x808067F0
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_sysAit_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_sysAit"
    VALUE
    0x808067F1
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_sysAiv_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_sysAiv"
    VALUE
    0x808067F2
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_sysDi_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_sysDi"
    VALUE
    0x808067F3
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_sysDo_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_sysDo"
    VALUE
    0x808067F4
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_sysGetVss_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_sysGetVss"
    VALUE
    0x808067F5
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_sysInit_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_sysInit"
    VALUE
    0x808067F6
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_sysOperHrIntegrityErr_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_sysOperHrIntegrityErr"
    VALUE
    0x808067F7
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_sysOperHrsSaturated_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_sysOperHrsSaturated"
    VALUE
    0x808067F8
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_sysSetVss_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_sysSetVss"
    VALUE
    0x808067F9
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_sys_coreload_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_sys_coreload"
    VALUE
    0x808067FA
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_sys_taskload_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_sys_taskload"
    VALUE
    0x808067FB
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_OV_VSS1_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_OV_VSS1"
    VALUE
    0x808067FC
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_OV_VSS2_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_OV_VSS2"
    VALUE
    0x808067FD
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_UV_VSS1_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_UV_VSS1"
    VALUE
    0x808067FE
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_UV_VSS2_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_UV_VSS2"
    VALUE
    0x808067FF
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_CANSM_E_BUS_OFF_NETWORK_0_C
    "AUTOSAR: Matching DTC group / Check DFC_CANSM_E_BUS_OFF_NETWORK_0"
    VALUE
    0x80806800
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_CANSM_E_BUS_OFF_NETWORK_1_C
    "AUTOSAR: Matching DTC group / Check DFC_CANSM_E_BUS_OFF_NETWORK_1"
    VALUE
    0x80806801
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_CANSM_E_BUS_OFF_NETWORK_2_C
    "AUTOSAR: Matching DTC group / Check DFC_CANSM_E_BUS_OFF_NETWORK_2"
    VALUE
    0x80806802
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_CANSM_E_BUS_OFF_NETWORK_3_C
    "AUTOSAR: Matching DTC group / Check DFC_CANSM_E_BUS_OFF_NETWORK_3"
    VALUE
    0x80806803
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_CANTRCV_E_NO_TRCV_CONTROL_0_C
    "AUTOSAR: Matching DTC group / Check DFC_CANTRCV_E_NO_TRCV_CONTROL_0"
    VALUE
    0x80806804
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_CAN_E_TIMEOUT_C
    "AUTOSAR: Matching DTC group / Check DFC_CAN_E_TIMEOUT"
    VALUE
    0x80806805
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_COMM_E_NET_START_IND_CHANNEL_0_C
    "AUTOSAR: Matching DTC group / Check DFC_COMM_E_NET_START_IND_CHANNEL_0"
    VALUE
    0x80806806
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_COMM_E_NET_START_IND_CHANNEL_1_C
    "AUTOSAR: Matching DTC group / Check DFC_COMM_E_NET_START_IND_CHANNEL_1"
    VALUE
    0x80806807
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_COMM_E_NET_START_IND_CHANNEL_2_C
    "AUTOSAR: Matching DTC group / Check DFC_COMM_E_NET_START_IND_CHANNEL_2"
    VALUE
    0x80806808
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_COMM_E_NET_START_IND_CHANNEL_3_C
    "AUTOSAR: Matching DTC group / Check DFC_COMM_E_NET_START_IND_CHANNEL_3"
    VALUE
    0x80806809
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_COMM_E_NET_START_IND_CHANNEL_4_C
    "AUTOSAR: Matching DTC group / Check DFC_COMM_E_NET_START_IND_CHANNEL_4"
    VALUE
    0x8080680A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_COMM_E_NET_START_IND_CHANNEL_5_C
    "AUTOSAR: Matching DTC group / Check DFC_COMM_E_NET_START_IND_CHANNEL_5"
    VALUE
    0x8080680B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_LIN_E_TIMEOUT_C
    "AUTOSAR: Matching DTC group / Check DFC_LIN_E_TIMEOUT"
    VALUE
    0x8080680C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rba_MultiStackTrace_Threshold_C
    "AUTOSAR: Matching DTC group / Check DFC_rba_MultiStackTrace_Threshold"
    VALUE
    0x8080680D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_ETH_E_ACCESS_0_C
    "AUTOSAR: Matching DTC group / Check DFC_ETH_E_ACCESS_0"
    VALUE
    0x8080680E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_RBA_IOEXTLIB_KEEPALIVE_DRV_C
    "AUTOSAR: Matching DTC group / Check DFC_RBA_IOEXTLIB_KEEPALIVE_DRV"
    VALUE
    0x8080680F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_RBA_IOEXTLIB_KEEPALIVE_INI_C
    "AUTOSAR: Matching DTC group / Check DFC_RBA_IOEXTLIB_KEEPALIVE_INI"
    VALUE
    0x80806810
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rba_MRly_Diag_Stk_Event_C
    "AUTOSAR: Matching DTC group / Check DFC_rba_MRly_Diag_Stk_Event"
    VALUE
    0x80806811
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rba_MemDiagExtd_MemReadSngErr_C
    "AUTOSAR: Matching DTC group / Check DFC_rba_MemDiagExtd_MemReadSngErr"
    VALUE
    0x80806812
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rba_MemDiag_MemReadErr_C
    "AUTOSAR: Matching DTC group / Check DFC_rba_MemDiag_MemReadErr"
    VALUE
    0x80806813
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rba_MemDiag_MemWrErr_C
    "AUTOSAR: Matching DTC group / Check DFC_rba_MemDiag_MemWrErr"
    VALUE
    0x80806814
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rba_SyC_IrrSwOffTrigEngRun_Event_C
    "AUTOSAR: Matching DTC group / Check DFC_rba_SyC_IrrSwOffTrigEngRun_Event"
    VALUE
    0x80806815
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rba_T15_Diag_ComInVld_Event_C
    "AUTOSAR: Matching DTC group / Check DFC_rba_T15_Diag_ComInVld_Event"
    VALUE
    0x80806816
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rba_T15_Diag_ComOff_HwOn_Event_C
    "AUTOSAR: Matching DTC group / Check DFC_rba_T15_Diag_ComOff_HwOn_Event"
    VALUE
    0x80806817
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rba_T15_Diag_ComOn_HwOff_Event_C
    "AUTOSAR: Matching DTC group / Check DFC_rba_T15_Diag_ComOn_HwOff_Event"
    VALUE
    0x80806818
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM0_0_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM0_0"
    VALUE
    0x80806819
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM0_1_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM0_1"
    VALUE
    0x8080681A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM0_10_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM0_10"
    VALUE
    0x8080681B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM0_11_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM0_11"
    VALUE
    0x8080681C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM0_13_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM0_13"
    VALUE
    0x8080681D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM0_14_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM0_14"
    VALUE
    0x8080681E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM0_2_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM0_2"
    VALUE
    0x8080681F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM0_22_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM0_22"
    VALUE
    0x80806820
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM0_23_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM0_23"
    VALUE
    0x80806821
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM0_4_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM0_4"
    VALUE
    0x80806822
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM0_5_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM0_5"
    VALUE
    0x80806823
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM0_7_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM0_7"
    VALUE
    0x80806824
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM0_8_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM0_8"
    VALUE
    0x80806825
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM10_16_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM10_16"
    VALUE
    0x80806826
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM10_17_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM10_17"
    VALUE
    0x80806827
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM10_21_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM10_21"
    VALUE
    0x80806828
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM11_0_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM11_0"
    VALUE
    0x80806829
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM11_1_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM11_1"
    VALUE
    0x8080682A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM11_2_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM11_2"
    VALUE
    0x8080682B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM11_3_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM11_3"
    VALUE
    0x8080682C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM11_4_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM11_4"
    VALUE
    0x8080682D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM11_5_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM11_5"
    VALUE
    0x8080682E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM11_8_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM11_8"
    VALUE
    0x8080682F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM11_9_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM11_9"
    VALUE
    0x80806830
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM1_0_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM1_0"
    VALUE
    0x80806831
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM1_1_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM1_1"
    VALUE
    0x80806832
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM1_10_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM1_10"
    VALUE
    0x80806833
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM1_11_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM1_11"
    VALUE
    0x80806834
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM1_13_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM1_13"
    VALUE
    0x80806835
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM1_14_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM1_14"
    VALUE
    0x80806836
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM1_2_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM1_2"
    VALUE
    0x80806837
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM1_22_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM1_22"
    VALUE
    0x80806838
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM1_23_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM1_23"
    VALUE
    0x80806839
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM1_4_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM1_4"
    VALUE
    0x8080683A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM1_5_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM1_5"
    VALUE
    0x8080683B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM1_7_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM1_7"
    VALUE
    0x8080683C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM1_8_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM1_8"
    VALUE
    0x8080683D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM21_0_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM21_0"
    VALUE
    0x8080683E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM21_16_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM21_16"
    VALUE
    0x8080683F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM21_3_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM21_3"
    VALUE
    0x80806840
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM2_1_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM2_1"
    VALUE
    0x80806841
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM2_10_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM2_10"
    VALUE
    0x80806842
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM2_11_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM2_11"
    VALUE
    0x80806843
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM2_13_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM2_13"
    VALUE
    0x80806844
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM2_14_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM2_14"
    VALUE
    0x80806845
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM2_2_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM2_2"
    VALUE
    0x80806846
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM2_22_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM2_22"
    VALUE
    0x80806847
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM2_23_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM2_23"
    VALUE
    0x80806848
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM2_4_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM2_4"
    VALUE
    0x80806849
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM2_5_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM2_5"
    VALUE
    0x8080684A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM2_7_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM2_7"
    VALUE
    0x8080684B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM2_8_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM2_8"
    VALUE
    0x8080684C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM3_1_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM3_1"
    VALUE
    0x8080684D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM3_10_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM3_10"
    VALUE
    0x8080684E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM3_11_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM3_11"
    VALUE
    0x8080684F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM3_13_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM3_13"
    VALUE
    0x80806850
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM3_14_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM3_14"
    VALUE
    0x80806851
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM3_2_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM3_2"
    VALUE
    0x80806852
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM3_22_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM3_22"
    VALUE
    0x80806853
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM3_23_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM3_23"
    VALUE
    0x80806854
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM3_4_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM3_4"
    VALUE
    0x80806855
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM3_5_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM3_5"
    VALUE
    0x80806856
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM3_7_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM3_7"
    VALUE
    0x80806857
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM3_8_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM3_8"
    VALUE
    0x80806858
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM6_0_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM6_0"
    VALUE
    0x80806859
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM6_11_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM6_11"
    VALUE
    0x8080685A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM6_12_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM6_12"
    VALUE
    0x8080685B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM6_14_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM6_14"
    VALUE
    0x8080685C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM6_15_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM6_15"
    VALUE
    0x8080685D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM6_17_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM6_17"
    VALUE
    0x8080685E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM6_18_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM6_18"
    VALUE
    0x8080685F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM6_2_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM6_2"
    VALUE
    0x80806860
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM6_20_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM6_20"
    VALUE
    0x80806861
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM6_21_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM6_21"
    VALUE
    0x80806862
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM6_25_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM6_25"
    VALUE
    0x80806863
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM6_4_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM6_4"
    VALUE
    0x80806864
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM6_5_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM6_5"
    VALUE
    0x80806865
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM6_7_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM6_7"
    VALUE
    0x80806866
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM6_8_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM6_8"
    VALUE
    0x80806867
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM7_1_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM7_1"
    VALUE
    0x80806868
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM7_12_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM7_12"
    VALUE
    0x80806869
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM7_13_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM7_13"
    VALUE
    0x8080686A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM7_14_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM7_14"
    VALUE
    0x8080686B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM7_15_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM7_15"
    VALUE
    0x8080686C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM7_16_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM7_16"
    VALUE
    0x8080686D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM7_17_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM7_17"
    VALUE
    0x8080686E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM7_2_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM7_2"
    VALUE
    0x8080686F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM7_20_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM7_20"
    VALUE
    0x80806870
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM7_25_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM7_25"
    VALUE
    0x80806871
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM7_26_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM7_26"
    VALUE
    0x80806872
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM7_28_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM7_28"
    VALUE
    0x80806873
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM7_29_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM7_29"
    VALUE
    0x80806874
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM7_30_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM7_30"
    VALUE
    0x80806875
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM7_31_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM7_31"
    VALUE
    0x80806876
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM8_0_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM8_0"
    VALUE
    0x80806877
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM8_1_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM8_1"
    VALUE
    0x80806878
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM8_10_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM8_10"
    VALUE
    0x80806879
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM8_11_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM8_11"
    VALUE
    0x8080687A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM8_12_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM8_12"
    VALUE
    0x8080687B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM8_13_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM8_13"
    VALUE
    0x8080687C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM8_16_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM8_16"
    VALUE
    0x8080687D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM8_18_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM8_18"
    VALUE
    0x8080687E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM8_2_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM8_2"
    VALUE
    0x8080687F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM8_3_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM8_3"
    VALUE
    0x80806880
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM8_30_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM8_30"
    VALUE
    0x80806881
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM8_31_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM8_31"
    VALUE
    0x80806882
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM8_4_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM8_4"
    VALUE
    0x80806883
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM9_0_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM9_0"
    VALUE
    0x80806884
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM9_1_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM9_1"
    VALUE
    0x80806885
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM9_15_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM9_15"
    VALUE
    0x80806886
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM9_3_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM9_3"
    VALUE
    0x80806887
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MoCSOPICO_C
    "AUTOSAR: Matching DTC group / Check DFC_MoCSOPICO"
    VALUE
    0x80806888
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MoFVarPostBldSel_C
    "AUTOSAR: Matching DTC group / Check DFC_MoFVarPostBldSel"
    VALUE
    0x80806889
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MoSysCtrlReIni_C
    "AUTOSAR: Matching DTC group / Check DFC_MoSysCtrlReIni"
    VALUE
    0x8080688A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MoXEMMHwLTMCUFW_C
    "AUTOSAR: Matching DTC group / Check DFC_MoXEMMHwLTMCUFW"
    VALUE
    0x8080688B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MoXEMMHwLTMonBIST_C
    "AUTOSAR: Matching DTC group / Check DFC_MoXEMMHwLTMonBIST"
    VALUE
    0x8080688C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MoXEMMHwLTRegMonTest_C
    "AUTOSAR: Matching DTC group / Check DFC_MoXEMMHwLTRegMonTest"
    VALUE
    0x8080688D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MoXEMMHwLTStbySMUAlvTest_C
    "AUTOSAR: Matching DTC group / Check DFC_MoXEMMHwLTStbySMUAlvTest"
    VALUE
    0x8080688E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MoXEMMHwLTTempSens_C
    "AUTOSAR: Matching DTC group / Check DFC_MoXEMMHwLTTempSens"
    VALUE
    0x8080688F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MoXEMMHwLTUCBCfg_C
    "AUTOSAR: Matching DTC group / Check DFC_MoXEMMHwLTUCBCfg"
    VALUE
    0x80806890
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_OCWDAABEActv_C
    "AUTOSAR: Matching DTC group / Check DFC_OCWDAABEActv"
    VALUE
    0x80806891
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_OCWDACom_C
    "AUTOSAR: Matching DTC group / Check DFC_OCWDACom"
    VALUE
    0x80806892
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_OCWDAErrPin_C
    "AUTOSAR: Matching DTC group / Check DFC_OCWDAErrPin"
    VALUE
    0x80806893
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_SWReset_0_C
    "AUTOSAR: Matching DTC group / Check DFC_SWReset_0"
    VALUE
    0x80806894
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_SWReset_1_C
    "AUTOSAR: Matching DTC group / Check DFC_SWReset_1"
    VALUE
    0x80806895
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_SWReset_2_C
    "AUTOSAR: Matching DTC group / Check DFC_SWReset_2"
    VALUE
    0x80806896
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDebFault1_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDebFault1"
    VALUE
    0x80806897
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_Unused_C
    "AUTOSAR: DTC severity class / Check DFC_Unused"
    VALUE
    0x80806CC4
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    READ_ONLY

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_TimeInRowDebFault_C
    "AUTOSAR: DTC severity class / Check DFC_bds_TimeInRowDebFault"
    VALUE
    0x80806CC5
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_EventInRowDebFault_C
    "AUTOSAR: DTC severity class / Check DFC_bds_EventInRowDebFault"
    VALUE
    0x80806CC6
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_DevLibBattUHi_C
    "AUTOSAR: DTC severity class / Check DFC_DevLibBattUHi"
    VALUE
    0x80806CC7
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_DevLibBattULo_C
    "AUTOSAR: DTC severity class / Check DFC_DevLibBattULo"
    VALUE
    0x80806CC8
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_TimeUpDownDebFault_C
    "AUTOSAR: DTC severity class / Check DFC_bds_TimeUpDownDebFault"
    VALUE
    0x80806CC9
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA13OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA13OR"
    VALUE
    0x80806CCA
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA13SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA13SCB"
    VALUE
    0x80806CCB
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA13SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA13SCG"
    VALUE
    0x80806CCC
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA14OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA14OR"
    VALUE
    0x80806CCD
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA14SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA14SCB"
    VALUE
    0x80806CCE
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA14SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA14SCG"
    VALUE
    0x80806CCF
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA21OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA21OR"
    VALUE
    0x80806CD0
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA21SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA21SCB"
    VALUE
    0x80806CD1
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA21SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA21SCG"
    VALUE
    0x80806CD2
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA22OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA22OR"
    VALUE
    0x80806CD3
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA22SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA22SCB"
    VALUE
    0x80806CD4
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA22SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA22SCG"
    VALUE
    0x80806CD5
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA23OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA23OR"
    VALUE
    0x80806CD6
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA23SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA23SCB"
    VALUE
    0x80806CD7
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA23SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA23SCG"
    VALUE
    0x80806CD8
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA24OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA24OR"
    VALUE
    0x80806CD9
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA24SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA24SCB"
    VALUE
    0x80806CDA
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA24SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA24SCG"
    VALUE
    0x80806CDB
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA25OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA25OR"
    VALUE
    0x80806CDC
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA25SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA25SCB"
    VALUE
    0x80806CDD
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA25SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA25SCG"
    VALUE
    0x80806CDE
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA26OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA26OR"
    VALUE
    0x80806CDF
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA26SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA26SCB"
    VALUE
    0x80806CE0
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA26SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA26SCG"
    VALUE
    0x80806CE1
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA27OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA27OR"
    VALUE
    0x80806CE2
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA27SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA27SCB"
    VALUE
    0x80806CE3
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA27SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA27SCG"
    VALUE
    0x80806CE4
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA28OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA28OR"
    VALUE
    0x80806CE5
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA28SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA28SCB"
    VALUE
    0x80806CE6
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA28SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA28SCG"
    VALUE
    0x80806CE7
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA29OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA29OR"
    VALUE
    0x80806CE8
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA29SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA29SCB"
    VALUE
    0x80806CE9
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA29SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA29SCG"
    VALUE
    0x80806CEA
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA36AicSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA36AicSCB"
    VALUE
    0x80806CEB
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA36AicSCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA36AicSCG"
    VALUE
    0x80806CEC
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA36OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA36OR"
    VALUE
    0x80806CED
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA36SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA36SCB"
    VALUE
    0x80806CEE
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA36SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA36SCG"
    VALUE
    0x80806CEF
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA36ShuntSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA36ShuntSCB"
    VALUE
    0x80806CF0
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA37AicSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA37AicSCB"
    VALUE
    0x80806CF1
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA37AicSCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA37AicSCG"
    VALUE
    0x80806CF2
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA37OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA37OR"
    VALUE
    0x80806CF3
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA37SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA37SCB"
    VALUE
    0x80806CF4
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA37SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA37SCG"
    VALUE
    0x80806CF5
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA37ShuntSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA37ShuntSCB"
    VALUE
    0x80806CF6
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA38AicSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA38AicSCB"
    VALUE
    0x80806CF7
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA38AicSCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA38AicSCG"
    VALUE
    0x80806CF8
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA38OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA38OR"
    VALUE
    0x80806CF9
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA38SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA38SCB"
    VALUE
    0x80806CFA
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA38SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA38SCG"
    VALUE
    0x80806CFB
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA38ShuntSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA38ShuntSCB"
    VALUE
    0x80806CFC
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA39AicSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA39AicSCB"
    VALUE
    0x80806CFD
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA39AicSCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA39AicSCG"
    VALUE
    0x80806CFE
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA39OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA39OR"
    VALUE
    0x80806CFF
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA39SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA39SCB"
    VALUE
    0x80806D00
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA39SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA39SCG"
    VALUE
    0x80806D01
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA39ShuntSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA39ShuntSCB"
    VALUE
    0x80806D02
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA40OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA40OR"
    VALUE
    0x80806D03
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA40SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA40SCB"
    VALUE
    0x80806D04
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA40SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA40SCG"
    VALUE
    0x80806D05
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA41OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA41OR"
    VALUE
    0x80806D06
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA41SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA41SCB"
    VALUE
    0x80806D07
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA41SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA41SCG"
    VALUE
    0x80806D08
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA42OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA42OR"
    VALUE
    0x80806D09
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA42SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA42SCB"
    VALUE
    0x80806D0A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA42SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA42SCG"
    VALUE
    0x80806D0B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA43AicSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA43AicSCB"
    VALUE
    0x80806D0C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA43AicSCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA43AicSCG"
    VALUE
    0x80806D0D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA43OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA43OR"
    VALUE
    0x80806D0E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA43SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA43SCB"
    VALUE
    0x80806D0F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA43SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA43SCG"
    VALUE
    0x80806D10
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA43ShuntSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA43ShuntSCB"
    VALUE
    0x80806D11
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA44OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA44OL"
    VALUE
    0x80806D12
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA44SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA44SCB"
    VALUE
    0x80806D13
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA44SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA44SCG"
    VALUE
    0x80806D14
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA57OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA57OR"
    VALUE
    0x80806D15
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA57SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA57SCB"
    VALUE
    0x80806D16
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA57SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA57SCG"
    VALUE
    0x80806D17
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA59OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA59OL"
    VALUE
    0x80806D18
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA59SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA59SCB"
    VALUE
    0x80806D19
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA59SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA59SCG"
    VALUE
    0x80806D1A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK10OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK10OR"
    VALUE
    0x80806D1B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK10SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK10SCB"
    VALUE
    0x80806D1C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK10SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK10SCG"
    VALUE
    0x80806D1D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK11OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK11OR"
    VALUE
    0x80806D1E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK11SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK11SCB"
    VALUE
    0x80806D1F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK11SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK11SCG"
    VALUE
    0x80806D20
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK30AicSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK30AicSCB"
    VALUE
    0x80806D21
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK30AicSCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK30AicSCG"
    VALUE
    0x80806D22
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK30OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK30OR"
    VALUE
    0x80806D23
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK30SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK30SCB"
    VALUE
    0x80806D24
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK30SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK30SCG"
    VALUE
    0x80806D25
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK30ShuntSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK30ShuntSCB"
    VALUE
    0x80806D26
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK31OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK31OR"
    VALUE
    0x80806D27
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK31SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK31SCB"
    VALUE
    0x80806D28
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK31SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK31SCG"
    VALUE
    0x80806D29
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK32OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK32OR"
    VALUE
    0x80806D2A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK32SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK32SCB"
    VALUE
    0x80806D2B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK32SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK32SCG"
    VALUE
    0x80806D2C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK33OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK33OR"
    VALUE
    0x80806D2D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK33SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK33SCB"
    VALUE
    0x80806D2E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK33SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK33SCG"
    VALUE
    0x80806D2F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK34OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK34OR"
    VALUE
    0x80806D30
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK34SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK34SCB"
    VALUE
    0x80806D31
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK34SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK34SCG"
    VALUE
    0x80806D32
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK35OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK35OR"
    VALUE
    0x80806D33
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK35SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK35SCB"
    VALUE
    0x80806D34
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK35SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK35SCG"
    VALUE
    0x80806D35
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK36OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK36OR"
    VALUE
    0x80806D36
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK36SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK36SCB"
    VALUE
    0x80806D37
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK36SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK36SCG"
    VALUE
    0x80806D38
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK37AicSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK37AicSCB"
    VALUE
    0x80806D39
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK37AicSCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK37AicSCG"
    VALUE
    0x80806D3A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK37OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK37OR"
    VALUE
    0x80806D3B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK37SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK37SCB"
    VALUE
    0x80806D3C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK37SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK37SCG"
    VALUE
    0x80806D3D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK37ShuntSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK37ShuntSCB"
    VALUE
    0x80806D3E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK38AicSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK38AicSCB"
    VALUE
    0x80806D3F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK38AicSCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK38AicSCG"
    VALUE
    0x80806D40
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK38OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK38OR"
    VALUE
    0x80806D41
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK38SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK38SCB"
    VALUE
    0x80806D42
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK38SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK38SCG"
    VALUE
    0x80806D43
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK38ShuntSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK38ShuntSCB"
    VALUE
    0x80806D44
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK39AicSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK39AicSCB"
    VALUE
    0x80806D45
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK39AicSCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK39AicSCG"
    VALUE
    0x80806D46
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK39OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK39OR"
    VALUE
    0x80806D47
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK39SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK39SCB"
    VALUE
    0x80806D48
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK39SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK39SCG"
    VALUE
    0x80806D49
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK39ShuntSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK39ShuntSCB"
    VALUE
    0x80806D4A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK40AicSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK40AicSCB"
    VALUE
    0x80806D4B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK40AicSCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK40AicSCG"
    VALUE
    0x80806D4C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK40OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK40OR"
    VALUE
    0x80806D4D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK40SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK40SCB"
    VALUE
    0x80806D4E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK40SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK40SCG"
    VALUE
    0x80806D4F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK40ShuntSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK40ShuntSCB"
    VALUE
    0x80806D50
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK41AicSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK41AicSCB"
    VALUE
    0x80806D51
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK41AicSCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK41AicSCG"
    VALUE
    0x80806D52
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK41OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK41OR"
    VALUE
    0x80806D53
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK41SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK41SCB"
    VALUE
    0x80806D54
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK41SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK41SCG"
    VALUE
    0x80806D55
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK41ShuntSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK41ShuntSCB"
    VALUE
    0x80806D56
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK42AicSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK42AicSCB"
    VALUE
    0x80806D57
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK42AicSCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK42AicSCG"
    VALUE
    0x80806D58
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK42OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK42OR"
    VALUE
    0x80806D59
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK42SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK42SCB"
    VALUE
    0x80806D5A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK42SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK42SCG"
    VALUE
    0x80806D5B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK42ShuntSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK42ShuntSCB"
    VALUE
    0x80806D5C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK43OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK43OR"
    VALUE
    0x80806D5D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK43SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK43SCB"
    VALUE
    0x80806D5E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK43SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK43SCG"
    VALUE
    0x80806D5F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK44AicSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK44AicSCB"
    VALUE
    0x80806D60
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK44AicSCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK44AicSCG"
    VALUE
    0x80806D61
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK44OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK44OR"
    VALUE
    0x80806D62
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK44SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK44SCB"
    VALUE
    0x80806D63
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK44SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK44SCG"
    VALUE
    0x80806D64
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK44ShuntSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK44ShuntSCB"
    VALUE
    0x80806D65
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK45AicSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK45AicSCB"
    VALUE
    0x80806D66
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK45AicSCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK45AicSCG"
    VALUE
    0x80806D67
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK45OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK45OR"
    VALUE
    0x80806D68
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK45SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK45SCB"
    VALUE
    0x80806D69
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK45SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK45SCG"
    VALUE
    0x80806D6A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK45ShuntSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK45ShuntSCB"
    VALUE
    0x80806D6B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK52OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK52OR"
    VALUE
    0x80806D6C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK52SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK52SCB"
    VALUE
    0x80806D6D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK52SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK52SCG"
    VALUE
    0x80806D6E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK53OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK53OR"
    VALUE
    0x80806D6F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK53SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK53SCB"
    VALUE
    0x80806D70
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK53SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK53SCG"
    VALUE
    0x80806D71
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK54AicSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK54AicSCB"
    VALUE
    0x80806D72
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK54AicSCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK54AicSCG"
    VALUE
    0x80806D73
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK54OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK54OR"
    VALUE
    0x80806D74
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK54SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK54SCB"
    VALUE
    0x80806D75
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK54SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK54SCG"
    VALUE
    0x80806D76
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK54ShuntSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK54ShuntSCB"
    VALUE
    0x80806D77
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK55AicSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK55AicSCB"
    VALUE
    0x80806D78
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK55AicSCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK55AicSCG"
    VALUE
    0x80806D79
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK55OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK55OR"
    VALUE
    0x80806D7A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK55SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK55SCB"
    VALUE
    0x80806D7B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK55SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK55SCG"
    VALUE
    0x80806D7C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK55ShuntSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK55ShuntSCB"
    VALUE
    0x80806D7D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK56OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK56OR"
    VALUE
    0x80806D7E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK56SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK56SCB"
    VALUE
    0x80806D7F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK56SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK56SCG"
    VALUE
    0x80806D80
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK57OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK57OR"
    VALUE
    0x80806D81
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK57SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK57SCB"
    VALUE
    0x80806D82
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK57SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK57SCG"
    VALUE
    0x80806D83
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK58OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK58OR"
    VALUE
    0x80806D84
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK58SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK58SCB"
    VALUE
    0x80806D85
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK58SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK58SCG"
    VALUE
    0x80806D86
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK59OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK59OR"
    VALUE
    0x80806D87
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK59SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK59SCB"
    VALUE
    0x80806D88
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK59SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK59SCG"
    VALUE
    0x80806D89
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK60OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK60OR"
    VALUE
    0x80806D8A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK60SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK60SCB"
    VALUE
    0x80806D8B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK60SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK60SCG"
    VALUE
    0x80806D8C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK61AicSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK61AicSCB"
    VALUE
    0x80806D8D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK61AicSCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK61AicSCG"
    VALUE
    0x80806D8E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK61OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK61OR"
    VALUE
    0x80806D8F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK61SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK61SCB"
    VALUE
    0x80806D90
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK61SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK61SCG"
    VALUE
    0x80806D91
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK61ShuntSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK61ShuntSCB"
    VALUE
    0x80806D92
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK62OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK62OR"
    VALUE
    0x80806D93
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK62SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK62SCB"
    VALUE
    0x80806D94
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK62SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK62SCG"
    VALUE
    0x80806D95
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK63AicSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK63AicSCB"
    VALUE
    0x80806D96
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK63AicSCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK63AicSCG"
    VALUE
    0x80806D97
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK63OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK63OR"
    VALUE
    0x80806D98
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK63SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK63SCB"
    VALUE
    0x80806D99
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK63SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK63SCG"
    VALUE
    0x80806D9A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK63ShuntSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK63ShuntSCB"
    VALUE
    0x80806D9B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK64AicSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK64AicSCB"
    VALUE
    0x80806D9C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK64AicSCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK64AicSCG"
    VALUE
    0x80806D9D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK64OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK64OR"
    VALUE
    0x80806D9E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK64SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK64SCB"
    VALUE
    0x80806D9F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK64SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK64SCG"
    VALUE
    0x80806DA0
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK64ShuntSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK64ShuntSCB"
    VALUE
    0x80806DA1
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK65AicSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK65AicSCB"
    VALUE
    0x80806DA2
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK65AicSCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK65AicSCG"
    VALUE
    0x80806DA3
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK65OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK65OR"
    VALUE
    0x80806DA4
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK65SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK65SCB"
    VALUE
    0x80806DA5
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK65SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK65SCG"
    VALUE
    0x80806DA6
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK65ShuntSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK65ShuntSCB"
    VALUE
    0x80806DA7
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK74OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK74OR"
    VALUE
    0x80806DA8
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK74SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK74SCB"
    VALUE
    0x80806DA9
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK74SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK74SCG"
    VALUE
    0x80806DAA
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK75OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK75OR"
    VALUE
    0x80806DAB
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK75SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK75SCB"
    VALUE
    0x80806DAC
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK75SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK75SCG"
    VALUE
    0x80806DAD
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK76OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK76OR"
    VALUE
    0x80806DAE
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK76SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK76SCB"
    VALUE
    0x80806DAF
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK76SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK76SCG"
    VALUE
    0x80806DB0
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK77OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK77OR"
    VALUE
    0x80806DB1
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK77SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK77SCB"
    VALUE
    0x80806DB2
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK77SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK77SCG"
    VALUE
    0x80806DB3
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK78OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK78OR"
    VALUE
    0x80806DB4
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK78SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK78SCB"
    VALUE
    0x80806DB5
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK78SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK78SCG"
    VALUE
    0x80806DB6
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_DvUBAT_FWs_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_DvUBAT_FWs"
    VALUE
    0x80806DB7
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_OVErr_VPR6_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_OVErr_VPR6"
    VALUE
    0x80806DB8
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_OVWarn_VPR6_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_OVWarn_VPR6"
    VALUE
    0x80806DB9
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3"
    VALUE
    0x80806DBA
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2"
    VALUE
    0x80806DBB
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_OV_UBAT_MON_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_OV_UBAT_MON"
    VALUE
    0x80806DBC
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_OV_UBRM24_FLEXIN_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_OV_UBRM24_FLEXIN"
    VALUE
    0x80806DBD
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_OV_UBRM24_LOADS_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_OV_UBRM24_LOADS"
    VALUE
    0x80806DBE
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_OV_UBRM24_MON_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_OV_UBRM24_MON"
    VALUE
    0x80806DBF
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_OV_VDD5_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_OV_VDD5"
    VALUE
    0x80806DC0
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_OV_VDD5_IN_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_OV_VDD5_IN"
    VALUE
    0x80806DC1
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_OV_VPR6_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_OV_VPR6"
    VALUE
    0x80806DC2
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_OV_VSS3_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_OV_VSS3"
    VALUE
    0x80806DC3
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_OV_VSS4_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_OV_VSS4"
    VALUE
    0x80806DC4
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_Temp1_HTErr_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_Temp1_HTErr"
    VALUE
    0x80806DC5
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_Temp1_HTWarn_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_Temp1_HTWarn"
    VALUE
    0x80806DC6
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_Temp2_HTErr_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_Temp2_HTErr"
    VALUE
    0x80806DC7
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_Temp2_HTWarn_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_Temp2_HTWarn"
    VALUE
    0x80806DC8
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3"
    VALUE
    0x80806DC9
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2"
    VALUE
    0x80806DCA
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_UV_VDD5_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_UV_VDD5"
    VALUE
    0x80806DCB
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_UV_VDD5_IN_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_UV_VDD5_IN"
    VALUE
    0x80806DCC
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_UV_VPR6_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_UV_VPR6"
    VALUE
    0x80806DCD
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_UV_VSS3_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_UV_VSS3"
    VALUE
    0x80806DCE
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_UV_VSS4_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_UV_VSS4"
    VALUE
    0x80806DCF
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA01OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA01OL"
    VALUE
    0x80806DD0
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA01OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA01OT"
    VALUE
    0x80806DD1
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA01SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA01SCB"
    VALUE
    0x80806DD2
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA01SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA01SCG"
    VALUE
    0x80806DD3
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA02OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA02OL"
    VALUE
    0x80806DD4
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA02OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA02OR"
    VALUE
    0x80806DD5
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA02OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA02OT"
    VALUE
    0x80806DD6
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA02SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA02SCB"
    VALUE
    0x80806DD7
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA02SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA02SCG"
    VALUE
    0x80806DD8
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA03OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA03OL"
    VALUE
    0x80806DD9
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA03OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA03OT"
    VALUE
    0x80806DDA
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA03SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA03SCB"
    VALUE
    0x80806DDB
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA03SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA03SCG"
    VALUE
    0x80806DDC
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA04OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA04OL"
    VALUE
    0x80806DDD
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA04OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA04OT"
    VALUE
    0x80806DDE
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA04SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA04SCB"
    VALUE
    0x80806DDF
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA04SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA04SCG"
    VALUE
    0x80806DE0
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA05OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA05OL"
    VALUE
    0x80806DE1
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA05OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA05OR"
    VALUE
    0x80806DE2
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA05OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA05OT"
    VALUE
    0x80806DE3
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA05SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA05SCB"
    VALUE
    0x80806DE4
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA05SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA05SCG"
    VALUE
    0x80806DE5
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA06OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA06OL"
    VALUE
    0x80806DE6
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA06OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA06OR"
    VALUE
    0x80806DE7
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA06OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA06OT"
    VALUE
    0x80806DE8
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA06SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA06SCB"
    VALUE
    0x80806DE9
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA06SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA06SCG"
    VALUE
    0x80806DEA
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA07OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA07OL"
    VALUE
    0x80806DEB
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA07OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA07OT"
    VALUE
    0x80806DEC
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA07SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA07SCB"
    VALUE
    0x80806DED
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA07SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA07SCG"
    VALUE
    0x80806DEE
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA08OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA08OL"
    VALUE
    0x80806DEF
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA08OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA08OT"
    VALUE
    0x80806DF0
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA08SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA08SCB"
    VALUE
    0x80806DF1
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA08SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA08SCG"
    VALUE
    0x80806DF2
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA09OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA09OL"
    VALUE
    0x80806DF3
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA09OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA09OR"
    VALUE
    0x80806DF4
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA09OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA09OT"
    VALUE
    0x80806DF5
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA09SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA09SCB"
    VALUE
    0x80806DF6
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA09SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA09SCG"
    VALUE
    0x80806DF7
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA10OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA10OL"
    VALUE
    0x80806DF8
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA10OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA10OT"
    VALUE
    0x80806DF9
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA10SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA10SCB"
    VALUE
    0x80806DFA
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA10SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA10SCG"
    VALUE
    0x80806DFB
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA11OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA11OL"
    VALUE
    0x80806DFC
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA11OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA11OT"
    VALUE
    0x80806DFD
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA11SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA11SCB"
    VALUE
    0x80806DFE
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA11SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA11SCG"
    VALUE
    0x80806DFF
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA12OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA12OR"
    VALUE
    0x80806E00
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA12SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA12SCB"
    VALUE
    0x80806E01
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA12SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA12SCG"
    VALUE
    0x80806E02
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA16OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA16OL"
    VALUE
    0x80806E03
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA16OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA16OT"
    VALUE
    0x80806E04
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA16SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA16SCB"
    VALUE
    0x80806E05
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA16SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA16SCG"
    VALUE
    0x80806E06
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA17OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA17OL"
    VALUE
    0x80806E07
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA17OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA17OR"
    VALUE
    0x80806E08
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA17OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA17OT"
    VALUE
    0x80806E09
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA17SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA17SCB"
    VALUE
    0x80806E0A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA17SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA17SCG"
    VALUE
    0x80806E0B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA18OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA18OL"
    VALUE
    0x80806E0C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA18OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA18OT"
    VALUE
    0x80806E0D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA18SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA18SCB"
    VALUE
    0x80806E0E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA18SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA18SCG"
    VALUE
    0x80806E0F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA19OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA19OL"
    VALUE
    0x80806E10
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA19OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA19OR"
    VALUE
    0x80806E11
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA19OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA19OT"
    VALUE
    0x80806E12
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA19SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA19SCB"
    VALUE
    0x80806E13
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA19SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA19SCG"
    VALUE
    0x80806E14
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA20OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA20OL"
    VALUE
    0x80806E15
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA20OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA20OR"
    VALUE
    0x80806E16
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA20OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA20OT"
    VALUE
    0x80806E17
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA20SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA20SCB"
    VALUE
    0x80806E18
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA20SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA20SCG"
    VALUE
    0x80806E19
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA31OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA31OL"
    VALUE
    0x80806E1A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA31OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA31OR"
    VALUE
    0x80806E1B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA31OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA31OT"
    VALUE
    0x80806E1C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA31SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA31SCB"
    VALUE
    0x80806E1D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA31SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA31SCG"
    VALUE
    0x80806E1E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA32OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA32OL"
    VALUE
    0x80806E1F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA32OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA32OR"
    VALUE
    0x80806E20
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA32OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA32OT"
    VALUE
    0x80806E21
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA32SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA32SCB"
    VALUE
    0x80806E22
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA32SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA32SCG"
    VALUE
    0x80806E23
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA33OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA33OL"
    VALUE
    0x80806E24
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA33OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA33OR"
    VALUE
    0x80806E25
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA33OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA33OT"
    VALUE
    0x80806E26
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA33SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA33SCB"
    VALUE
    0x80806E27
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA33SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA33SCG"
    VALUE
    0x80806E28
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA34OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA34OL"
    VALUE
    0x80806E29
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA34OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA34OR"
    VALUE
    0x80806E2A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA34OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA34OT"
    VALUE
    0x80806E2B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA34SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA34SCB"
    VALUE
    0x80806E2C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA34SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA34SCG"
    VALUE
    0x80806E2D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA35OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA35OL"
    VALUE
    0x80806E2E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA35OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA35OR"
    VALUE
    0x80806E2F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA35OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA35OT"
    VALUE
    0x80806E30
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA35SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA35SCB"
    VALUE
    0x80806E31
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA35SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA35SCG"
    VALUE
    0x80806E32
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA46OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA46OL"
    VALUE
    0x80806E33
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA46OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA46OR"
    VALUE
    0x80806E34
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA46OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA46OT"
    VALUE
    0x80806E35
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA46SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA46SCB"
    VALUE
    0x80806E36
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA46SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA46SCG"
    VALUE
    0x80806E37
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA47OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA47OL"
    VALUE
    0x80806E38
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA47OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA47OR"
    VALUE
    0x80806E39
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA47OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA47OT"
    VALUE
    0x80806E3A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA47SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA47SCB"
    VALUE
    0x80806E3B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA47SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA47SCG"
    VALUE
    0x80806E3C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA48OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA48OL"
    VALUE
    0x80806E3D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA48OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA48OR"
    VALUE
    0x80806E3E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA48OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA48OT"
    VALUE
    0x80806E3F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA48SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA48SCB"
    VALUE
    0x80806E40
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA48SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA48SCG"
    VALUE
    0x80806E41
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA49OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA49OL"
    VALUE
    0x80806E42
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA49OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA49OT"
    VALUE
    0x80806E43
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA49SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA49SCB"
    VALUE
    0x80806E44
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA49SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA49SCG"
    VALUE
    0x80806E45
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA50OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA50OL"
    VALUE
    0x80806E46
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA50OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA50OT"
    VALUE
    0x80806E47
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA50SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA50SCB"
    VALUE
    0x80806E48
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA50SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA50SCG"
    VALUE
    0x80806E49
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA51OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA51OL"
    VALUE
    0x80806E4A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA51OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA51OR"
    VALUE
    0x80806E4B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA51OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA51OT"
    VALUE
    0x80806E4C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA51SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA51SCB"
    VALUE
    0x80806E4D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA51SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA51SCG"
    VALUE
    0x80806E4E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA52OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA52OL"
    VALUE
    0x80806E4F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA52OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA52OR"
    VALUE
    0x80806E50
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA52OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA52OT"
    VALUE
    0x80806E51
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA52SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA52SCB"
    VALUE
    0x80806E52
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA52SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA52SCG"
    VALUE
    0x80806E53
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA53OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA53OL"
    VALUE
    0x80806E54
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA53OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA53OR"
    VALUE
    0x80806E55
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA53OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA53OT"
    VALUE
    0x80806E56
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA53SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA53SCB"
    VALUE
    0x80806E57
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA53SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA53SCG"
    VALUE
    0x80806E58
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA54OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA54OL"
    VALUE
    0x80806E59
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA54OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA54OR"
    VALUE
    0x80806E5A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA54OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA54OT"
    VALUE
    0x80806E5B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA54SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA54SCB"
    VALUE
    0x80806E5C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA54SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA54SCG"
    VALUE
    0x80806E5D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA55OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA55OL"
    VALUE
    0x80806E5E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA55OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA55OT"
    VALUE
    0x80806E5F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA55SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA55SCB"
    VALUE
    0x80806E60
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA55SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA55SCG"
    VALUE
    0x80806E61
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA56OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA56OL"
    VALUE
    0x80806E62
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA56OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA56OT"
    VALUE
    0x80806E63
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA56SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA56SCB"
    VALUE
    0x80806E64
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA56SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA56SCG"
    VALUE
    0x80806E65
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA58OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA58OL"
    VALUE
    0x80806E66
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA58OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA58OT"
    VALUE
    0x80806E67
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA58SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA58SCB"
    VALUE
    0x80806E68
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA58SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA58SCG"
    VALUE
    0x80806E69
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK07OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK07OL"
    VALUE
    0x80806E6A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK07OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK07OR"
    VALUE
    0x80806E6B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK07OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK07OT"
    VALUE
    0x80806E6C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK07SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK07SCB"
    VALUE
    0x80806E6D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK07SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK07SCG"
    VALUE
    0x80806E6E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK08OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK08OL"
    VALUE
    0x80806E6F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK08OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK08OR"
    VALUE
    0x80806E70
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK08OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK08OT"
    VALUE
    0x80806E71
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK08SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK08SCB"
    VALUE
    0x80806E72
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK08SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK08SCG"
    VALUE
    0x80806E73
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK09OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK09OL"
    VALUE
    0x80806E74
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK09OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK09OR"
    VALUE
    0x80806E75
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK09OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK09OT"
    VALUE
    0x80806E76
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK09SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK09SCB"
    VALUE
    0x80806E77
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK09SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK09SCG"
    VALUE
    0x80806E78
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK12OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK12OL"
    VALUE
    0x80806E79
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK12OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK12OT"
    VALUE
    0x80806E7A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK12SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK12SCB"
    VALUE
    0x80806E7B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK12SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK12SCG"
    VALUE
    0x80806E7C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK13OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK13OL"
    VALUE
    0x80806E7D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK13OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK13OT"
    VALUE
    0x80806E7E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK13SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK13SCB"
    VALUE
    0x80806E7F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK13SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK13SCG"
    VALUE
    0x80806E80
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK14OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK14OL"
    VALUE
    0x80806E81
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK14OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK14OR"
    VALUE
    0x80806E82
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK14OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK14OT"
    VALUE
    0x80806E83
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK14SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK14SCB"
    VALUE
    0x80806E84
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK14SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK14SCG"
    VALUE
    0x80806E85
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK15OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK15OL"
    VALUE
    0x80806E86
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK15OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK15OR"
    VALUE
    0x80806E87
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK15OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK15OT"
    VALUE
    0x80806E88
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK15SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK15SCB"
    VALUE
    0x80806E89
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK15SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK15SCG"
    VALUE
    0x80806E8A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK16OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK16OL"
    VALUE
    0x80806E8B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK16OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK16OR"
    VALUE
    0x80806E8C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK16OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK16OT"
    VALUE
    0x80806E8D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK16SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK16SCB"
    VALUE
    0x80806E8E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK16SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK16SCG"
    VALUE
    0x80806E8F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK17OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK17OL"
    VALUE
    0x80806E90
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK17OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK17OR"
    VALUE
    0x80806E91
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK17OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK17OT"
    VALUE
    0x80806E92
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK17SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK17SCB"
    VALUE
    0x80806E93
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK17SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK17SCG"
    VALUE
    0x80806E94
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK25OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK25OR"
    VALUE
    0x80806E95
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK25SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK25SCB"
    VALUE
    0x80806E96
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK25SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK25SCG"
    VALUE
    0x80806E97
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK29OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK29OL"
    VALUE
    0x80806E98
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK29OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK29OR"
    VALUE
    0x80806E99
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK29OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK29OT"
    VALUE
    0x80806E9A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK29SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK29SCB"
    VALUE
    0x80806E9B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK29SCG_C
