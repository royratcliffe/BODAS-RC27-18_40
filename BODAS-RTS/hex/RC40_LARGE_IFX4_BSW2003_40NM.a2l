    rba_Runtime_MonTask_ast[63].tiMaxRT_u32
    "rba_Runtime Measurement Variable[63]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002980


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[64].tiMaxRT_u32
    "rba_Runtime Measurement Variable[64]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700029B4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[0].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001CB8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[1].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[1]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001CEC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[2].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[2]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D20


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[3].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[3]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D54


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[4].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[4]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D88


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[5].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[5]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001DBC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[6].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[6]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001DF0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[7].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[7]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E24


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[8].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[8]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E58


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[9].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[9]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E8C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[10].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[10]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001EC0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[11].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[11]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001EF4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[12].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[12]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F28


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[13].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[13]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F5C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[14].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[14]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F90


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[15].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[15]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001FC4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[16].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[16]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001FF8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[17].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[17]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000202C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[18].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[18]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002060


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[19].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[19]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002094


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[20].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[20]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700020C8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[21].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[21]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700020FC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[22].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[22]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002130


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[23].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[23]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002164


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[24].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[24]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002198


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[25].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[25]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700021CC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[26].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[26]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002200


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[27].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[27]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002234


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[28].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[28]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002268


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[29].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[29]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000229C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[30].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[30]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700022D0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[31].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[31]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002304


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[32].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[32]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002338


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[33].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[33]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000236C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[34].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[34]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700023A0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[35].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[35]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700023D4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[36].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[36]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002408


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[37].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[37]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000243C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[38].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[38]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002470


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[39].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[39]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700024A4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[40].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[40]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700024D8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[41].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[41]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000250C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[42].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[42]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002540


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[43].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[43]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002574


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[44].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[44]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700025A8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[45].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[45]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700025DC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[46].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[46]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002610


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[47].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[47]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002644


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[48].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[48]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002678


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[49].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[49]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700026AC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[50].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[50]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700026E0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[51].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[51]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002714


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[52].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[52]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002748


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[53].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[53]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000277C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[54].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[54]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700027B0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[55].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[55]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700027E4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[56].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[56]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002818


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[57].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[57]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000284C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[58].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[58]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002880


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[59].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[59]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700028B4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[60].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[60]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700028E8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[61].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[61]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000291C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[62].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[62]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002950


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[63].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[63]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002984


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[64].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[64]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700029B8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[0].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001CBC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[1].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[1]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001CF0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[2].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[2]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D24


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[3].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[3]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D58


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[4].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[4]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D8C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[5].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[5]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001DC0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[6].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[6]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001DF4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[7].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[7]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E28


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[8].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[8]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E5C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[9].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[9]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E90


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[10].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[10]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001EC4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[11].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[11]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001EF8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[12].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[12]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F2C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[13].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[13]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F60


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[14].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[14]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F94


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[15].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[15]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001FC8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[16].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[16]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001FFC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[17].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[17]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002030


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[18].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[18]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002064


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[19].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[19]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002098


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[20].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[20]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700020CC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[21].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[21]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002100


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[22].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[22]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002134


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[23].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[23]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002168


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[24].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[24]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000219C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[25].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[25]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700021D0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[26].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[26]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002204


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[27].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[27]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002238


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[28].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[28]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000226C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[29].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[29]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700022A0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[30].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[30]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700022D4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[31].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[31]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002308


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[32].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[32]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000233C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[33].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[33]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002370


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[34].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[34]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700023A4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[35].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[35]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700023D8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[36].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[36]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000240C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[37].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[37]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002440


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[38].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[38]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002474


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[39].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[39]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700024A8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[40].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[40]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700024DC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[41].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[41]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002510


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[42].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[42]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002544


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[43].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[43]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002578


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[44].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[44]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700025AC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[45].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[45]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700025E0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[46].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[46]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002614


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[47].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[47]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002648


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[48].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[48]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000267C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[49].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[49]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700026B0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[50].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[50]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700026E4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[51].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[51]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002718


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[52].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[52]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000274C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[53].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[53]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002780


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[54].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[54]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700027B4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[55].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[55]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700027E8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[56].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[56]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000281C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[57].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[57]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002850


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[58].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[58]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002884


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[59].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[59]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700028B8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[60].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[60]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700028EC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[61].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[61]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002920


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[62].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[62]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002954


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[63].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[63]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002988


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[64].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[64]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700029BC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[0].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001CC0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[1].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[1]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001CF4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[2].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[2]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D28


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[3].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[3]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D5C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[4].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[4]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D90


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[5].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[5]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001DC4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[6].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[6]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001DF8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[7].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[7]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E2C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[8].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[8]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E60


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[9].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[9]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E94


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[10].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[10]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001EC8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[11].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[11]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001EFC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[12].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[12]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F30


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[13].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[13]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F64


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[14].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[14]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F98


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[15].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[15]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001FCC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[16].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[16]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002000


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[17].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[17]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002034


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[18].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[18]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002068


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[19].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[19]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000209C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[20].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[20]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700020D0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[21].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[21]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002104


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[22].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[22]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002138


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[23].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[23]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000216C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[24].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[24]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700021A0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[25].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[25]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700021D4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[26].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[26]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002208


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[27].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[27]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000223C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[28].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[28]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002270


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[29].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[29]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700022A4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[30].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[30]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700022D8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[31].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[31]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000230C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[32].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[32]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002340


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[33].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[33]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002374


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[34].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[34]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700023A8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[35].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[35]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700023DC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[36].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[36]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002410


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[37].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[37]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002444


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[38].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[38]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002478


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[39].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[39]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700024AC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[40].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[40]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700024E0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[41].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[41]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002514


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[42].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[42]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002548


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[43].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[43]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000257C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[44].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[44]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700025B0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[45].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[45]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700025E4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[46].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[46]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002618


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[47].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[47]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000264C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[48].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[48]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002680


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[49].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[49]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700026B4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[50].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[50]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700026E8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[51].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[51]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000271C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[52].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[52]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002750


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[53].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[53]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002784


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[54].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[54]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700027B8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[55].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[55]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700027EC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[56].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[56]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002820


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[57].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[57]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002854


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[58].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[58]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002888


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[59].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[59]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700028BC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[60].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[60]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700028F0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[61].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[61]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002924


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[62].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[62]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002958


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[63].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[63]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000298C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[64].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[64]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700029C0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[0].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[0]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001CC4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[1].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[1]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001CF8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[2].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[2]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D2C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[3].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[3]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D60


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[4].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[4]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D94


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[5].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[5]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001DC8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[6].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[6]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001DFC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[7].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[7]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E30


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[8].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[8]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E64


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[9].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[9]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E98


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[10].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[10]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001ECC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[11].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[11]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F00


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[12].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[12]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F34


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[13].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[13]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F68


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[14].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[14]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F9C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[15].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[15]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001FD0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[16].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[16]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002004


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[17].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[17]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002038


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[18].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[18]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000206C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[19].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[19]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700020A0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[20].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[20]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700020D4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[21].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[21]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002108


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[22].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[22]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000213C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[23].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[23]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002170


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[24].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[24]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700021A4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[25].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[25]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700021D8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[26].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[26]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000220C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[27].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[27]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002240


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[28].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[28]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002274


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[29].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[29]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700022A8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[30].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[30]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700022DC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[31].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[31]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002310


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[32].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[32]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002344


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[33].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[33]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002378


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[34].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[34]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700023AC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[35].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[35]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700023E0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[36].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[36]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002414


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[37].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[37]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002448


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[38].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[38]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000247C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[39].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[39]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700024B0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[40].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[40]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700024E4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[41].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[41]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002518


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[42].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[42]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000254C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[43].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[43]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002580


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[44].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[44]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700025B4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[45].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[45]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700025E8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[46].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[46]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000261C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[47].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[47]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002650


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[48].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[48]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002684


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[49].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[49]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700026B8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[50].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[50]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700026EC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[51].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[51]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002720


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[52].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[52]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002754


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[53].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[53]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002788


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[54].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[54]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700027BC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[55].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[55]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700027F0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[56].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[56]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002824


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[57].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[57]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002858


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[58].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[58]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000288C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[59].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[59]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700028C0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[60].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[60]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700028F4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[61].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[61]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002928


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[62].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[62]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000295C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[63].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[63]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002990


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[64].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[64]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700029C4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[0].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001CC8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[1].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[1]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001CFC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[2].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[2]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D30


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[3].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[3]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D64


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[4].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[4]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D98


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[5].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[5]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001DCC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[6].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[6]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E00


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[7].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[7]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E34


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[8].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[8]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E68


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[9].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[9]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E9C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[10].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[10]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001ED0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[11].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[11]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F04


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[12].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[12]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F38


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[13].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[13]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F6C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[14].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[14]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001FA0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[15].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[15]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001FD4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[16].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[16]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002008


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[17].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[17]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000203C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[18].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[18]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002070


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[19].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[19]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700020A4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[20].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[20]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700020D8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[21].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[21]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000210C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[22].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[22]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002140


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[23].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[23]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002174


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[24].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[24]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700021A8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[25].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[25]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700021DC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[26].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[26]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002210


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[27].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[27]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002244


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[28].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[28]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002278


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[29].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[29]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700022AC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[30].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[30]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700022E0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[31].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[31]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002314


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[32].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[32]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002348


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[33].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[33]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000237C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[34].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[34]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700023B0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[35].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[35]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700023E4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[36].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[36]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002418


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[37].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[37]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000244C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[38].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[38]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002480


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[39].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[39]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700024B4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[40].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[40]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700024E8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[41].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[41]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000251C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[42].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[42]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002550


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[43].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[43]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002584


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[44].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[44]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700025B8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[45].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[45]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700025EC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[46].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[46]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002620


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[47].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[47]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002654


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[48].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[48]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002688


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[49].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[49]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700026BC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[50].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[50]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700026F0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[51].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[51]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002724


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[52].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[52]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002758


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[53].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[53]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000278C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[54].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[54]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700027C0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[55].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[55]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700027F4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[56].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[56]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002828


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[57].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[57]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000285C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[58].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[58]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002890


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[59].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[59]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700028C4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[60].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[60]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700028F8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[61].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[61]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000292C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[62].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[62]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002960


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[63].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[63]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002994


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[64].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[64]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700029C8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[0].ctCalls_u32
    "rba_Runtime Measurement Variable[0]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001CCC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[1].ctCalls_u32
    "rba_Runtime Measurement Variable[1]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D00


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[2].ctCalls_u32
    "rba_Runtime Measurement Variable[2]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D34


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[3].ctCalls_u32
    "rba_Runtime Measurement Variable[3]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D68


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[4].ctCalls_u32
    "rba_Runtime Measurement Variable[4]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D9C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[5].ctCalls_u32
    "rba_Runtime Measurement Variable[5]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001DD0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[6].ctCalls_u32
    "rba_Runtime Measurement Variable[6]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E04


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[7].ctCalls_u32
    "rba_Runtime Measurement Variable[7]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E38


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[8].ctCalls_u32
    "rba_Runtime Measurement Variable[8]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E6C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[9].ctCalls_u32
    "rba_Runtime Measurement Variable[9]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001EA0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[10].ctCalls_u32
    "rba_Runtime Measurement Variable[10]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001ED4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[11].ctCalls_u32
    "rba_Runtime Measurement Variable[11]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F08


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[12].ctCalls_u32
    "rba_Runtime Measurement Variable[12]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F3C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[13].ctCalls_u32
    "rba_Runtime Measurement Variable[13]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F70


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[14].ctCalls_u32
    "rba_Runtime Measurement Variable[14]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001FA4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[15].ctCalls_u32
    "rba_Runtime Measurement Variable[15]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001FD8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[16].ctCalls_u32
    "rba_Runtime Measurement Variable[16]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000200C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[17].ctCalls_u32
    "rba_Runtime Measurement Variable[17]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002040


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[18].ctCalls_u32
    "rba_Runtime Measurement Variable[18]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002074


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[19].ctCalls_u32
    "rba_Runtime Measurement Variable[19]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700020A8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[20].ctCalls_u32
    "rba_Runtime Measurement Variable[20]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700020DC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[21].ctCalls_u32
    "rba_Runtime Measurement Variable[21]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002110


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[22].ctCalls_u32
    "rba_Runtime Measurement Variable[22]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002144


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[23].ctCalls_u32
    "rba_Runtime Measurement Variable[23]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002178


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[24].ctCalls_u32
    "rba_Runtime Measurement Variable[24]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700021AC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[25].ctCalls_u32
    "rba_Runtime Measurement Variable[25]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700021E0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[26].ctCalls_u32
    "rba_Runtime Measurement Variable[26]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002214


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[27].ctCalls_u32
    "rba_Runtime Measurement Variable[27]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002248


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[28].ctCalls_u32
    "rba_Runtime Measurement Variable[28]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000227C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[29].ctCalls_u32
    "rba_Runtime Measurement Variable[29]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700022B0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[30].ctCalls_u32
    "rba_Runtime Measurement Variable[30]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700022E4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[31].ctCalls_u32
    "rba_Runtime Measurement Variable[31]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002318


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[32].ctCalls_u32
    "rba_Runtime Measurement Variable[32]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000234C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[33].ctCalls_u32
    "rba_Runtime Measurement Variable[33]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002380


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[34].ctCalls_u32
    "rba_Runtime Measurement Variable[34]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700023B4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[35].ctCalls_u32
    "rba_Runtime Measurement Variable[35]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700023E8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[36].ctCalls_u32
    "rba_Runtime Measurement Variable[36]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000241C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[37].ctCalls_u32
    "rba_Runtime Measurement Variable[37]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002450


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[38].ctCalls_u32
    "rba_Runtime Measurement Variable[38]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002484


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[39].ctCalls_u32
    "rba_Runtime Measurement Variable[39]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700024B8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[40].ctCalls_u32
    "rba_Runtime Measurement Variable[40]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700024EC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[41].ctCalls_u32
    "rba_Runtime Measurement Variable[41]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002520


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[42].ctCalls_u32
    "rba_Runtime Measurement Variable[42]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002554


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[43].ctCalls_u32
    "rba_Runtime Measurement Variable[43]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002588


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[44].ctCalls_u32
    "rba_Runtime Measurement Variable[44]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700025BC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[45].ctCalls_u32
    "rba_Runtime Measurement Variable[45]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700025F0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[46].ctCalls_u32
    "rba_Runtime Measurement Variable[46]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002624


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[47].ctCalls_u32
    "rba_Runtime Measurement Variable[47]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002658


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[48].ctCalls_u32
    "rba_Runtime Measurement Variable[48]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000268C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[49].ctCalls_u32
    "rba_Runtime Measurement Variable[49]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700026C0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[50].ctCalls_u32
    "rba_Runtime Measurement Variable[50]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700026F4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[51].ctCalls_u32
    "rba_Runtime Measurement Variable[51]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002728


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[52].ctCalls_u32
    "rba_Runtime Measurement Variable[52]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000275C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[53].ctCalls_u32
    "rba_Runtime Measurement Variable[53]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002790


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[54].ctCalls_u32
    "rba_Runtime Measurement Variable[54]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700027C4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[55].ctCalls_u32
    "rba_Runtime Measurement Variable[55]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700027F8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[56].ctCalls_u32
    "rba_Runtime Measurement Variable[56]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000282C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[57].ctCalls_u32
    "rba_Runtime Measurement Variable[57]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002860


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[58].ctCalls_u32
    "rba_Runtime Measurement Variable[58]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002894


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[59].ctCalls_u32
    "rba_Runtime Measurement Variable[59]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700028C8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[60].ctCalls_u32
    "rba_Runtime Measurement Variable[60]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700028FC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[61].ctCalls_u32
    "rba_Runtime Measurement Variable[61]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002930


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[62].ctCalls_u32
    "rba_Runtime Measurement Variable[62]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002964


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[63].ctCalls_u32
    "rba_Runtime Measurement Variable[63]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002998


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[64].ctCalls_u32
    "rba_Runtime Measurement Variable[64]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700029CC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[0].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[0]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001CD0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[1].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[1]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D04


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[2].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[2]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D38


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[3].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[3]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D6C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[4].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[4]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001DA0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[5].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[5]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001DD4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[6].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[6]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E08


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[7].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[7]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E3C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[8].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[8]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E70


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[9].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[9]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001EA4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[10].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[10]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001ED8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[11].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[11]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F0C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[12].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[12]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F40


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[13].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[13]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F74


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[14].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[14]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001FA8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[15].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[15]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001FDC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[16].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[16]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002010


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[17].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[17]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002044


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[18].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[18]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002078


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[19].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[19]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700020AC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[20].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[20]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700020E0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[21].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[21]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002114


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[22].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[22]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002148


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[23].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[23]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000217C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[24].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[24]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700021B0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[25].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[25]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700021E4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[26].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[26]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002218


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[27].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[27]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000224C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[28].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[28]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002280


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[29].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[29]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700022B4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[30].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[30]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700022E8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[31].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[31]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000231C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[32].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[32]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002350


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[33].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[33]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002384


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[34].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[34]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700023B8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[35].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[35]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700023EC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[36].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[36]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002420


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[37].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[37]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002454


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[38].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[38]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002488


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[39].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[39]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700024BC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[40].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[40]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700024F0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[41].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[41]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002524


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[42].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[42]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002558


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[43].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[43]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000258C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[44].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[44]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700025C0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[45].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[45]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700025F4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[46].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[46]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002628


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[47].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[47]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000265C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[48].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[48]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002690


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[49].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[49]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700026C4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[50].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[50]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700026F8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[51].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[51]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000272C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[52].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[52]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002760


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[53].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[53]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002794


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[54].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[54]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700027C8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[55].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[55]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700027FC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[56].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[56]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002830


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[57].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[57]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002864


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[58].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[58]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002898


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[59].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[59]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700028CC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[60].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[60]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002900


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[61].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[61]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002934


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[62].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[62]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002968


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[63].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[63]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000299C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[64].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[64]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700029D0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[0].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[0]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001CD4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[1].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[1]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D08


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[2].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[2]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D3C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[3].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[3]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D70


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[4].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[4]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001DA4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[5].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[5]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001DD8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[6].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[6]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E0C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[7].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[7]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E40


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[8].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[8]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E74


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[9].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[9]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001EA8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[10].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[10]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001EDC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[11].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[11]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F10


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[12].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[12]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F44


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[13].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[13]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F78


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[14].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[14]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001FAC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[15].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[15]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001FE0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[16].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[16]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002014


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[17].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[17]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002048


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[18].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[18]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000207C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[19].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[19]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700020B0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[20].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[20]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700020E4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[21].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[21]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002118


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[22].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[22]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000214C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[23].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[23]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002180


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[24].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[24]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700021B4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[25].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[25]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700021E8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[26].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[26]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000221C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[27].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[27]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002250


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[28].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[28]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002284


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[29].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[29]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700022B8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[30].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[30]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700022EC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[31].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[31]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002320


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[32].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[32]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002354


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[33].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[33]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002388


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[34].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[34]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700023BC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[35].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[35]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700023F0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[36].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[36]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002424


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[37].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[37]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002458


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[38].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[38]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000248C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[39].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[39]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700024C0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[40].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[40]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700024F4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[41].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[41]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002528


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[42].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[42]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000255C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[43].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[43]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002590


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[44].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[44]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700025C4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[45].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[45]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700025F8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[46].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[46]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000262C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[47].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[47]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002660


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[48].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[48]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002694


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[49].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[49]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700026C8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[50].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[50]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700026FC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[51].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[51]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002730


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[52].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[52]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002764


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[53].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[53]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002798


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[54].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[54]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700027CC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[55].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[55]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002800


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[56].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[56]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002834


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[57].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[57]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002868


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[58].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[58]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000289C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[59].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[59]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700028D0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[60].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[60]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002904


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[61].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[61]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002938


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[62].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[62]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000296C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[63].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[63]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700029A0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[64].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[64]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700029D4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[0].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[0]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001CD8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[1].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[1]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D0C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[2].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[2]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D40


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[3].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[3]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D74


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[4].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[4]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001DA8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[5].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[5]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001DDC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[6].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[6]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E10


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[7].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[7]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E44


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[8].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[8]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E78


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[9].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[9]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001EAC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[10].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[10]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001EE0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[11].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[11]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F14


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[12].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[12]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F48


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[13].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[13]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F7C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[14].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[14]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001FB0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[15].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[15]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001FE4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[16].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[16]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002018


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[17].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[17]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000204C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[18].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[18]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002080


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[19].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[19]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700020B4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[20].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[20]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700020E8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[21].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[21]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000211C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[22].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[22]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002150


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[23].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[23]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002184


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[24].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[24]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700021B8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[25].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[25]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700021EC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[26].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[26]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002220


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[27].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[27]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002254


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[28].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[28]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002288


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[29].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[29]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700022BC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[30].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[30]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700022F0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[31].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[31]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002324


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[32].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[32]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002358


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[33].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[33]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000238C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[34].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[34]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700023C0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[35].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[35]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700023F4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[36].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[36]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002428


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[37].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[37]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000245C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[38].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[38]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002490


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[39].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[39]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700024C4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[40].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[40]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700024F8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[41].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[41]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000252C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[42].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[42]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002560


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[43].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[43]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002594


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[44].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[44]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700025C8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[45].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[45]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700025FC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[46].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[46]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002630


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[47].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[47]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002664


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[48].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[48]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002698


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[49].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[49]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700026CC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[50].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[50]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002700


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[51].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[51]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002734


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[52].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[52]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002768


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[53].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[53]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000279C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[54].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[54]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700027D0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[55].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[55]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002804


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[56].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[56]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002838


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[57].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[57]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000286C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[58].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[58]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700028A0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[59].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[59]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700028D4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[60].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[60]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002908


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[61].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[61]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000293C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[62].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[62]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002970


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[63].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[63]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700029A4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[64].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[64]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700029D8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[0].loadPer64k_u16
    "rba_Runtime Measurement Variable[0]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001CDC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[1].loadPer64k_u16
    "rba_Runtime Measurement Variable[1]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D10


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[2].loadPer64k_u16
    "rba_Runtime Measurement Variable[2]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D44


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[3].loadPer64k_u16
    "rba_Runtime Measurement Variable[3]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D78


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[4].loadPer64k_u16
    "rba_Runtime Measurement Variable[4]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001DAC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[5].loadPer64k_u16
    "rba_Runtime Measurement Variable[5]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001DE0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[6].loadPer64k_u16
    "rba_Runtime Measurement Variable[6]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E14


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[7].loadPer64k_u16
    "rba_Runtime Measurement Variable[7]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E48


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[8].loadPer64k_u16
    "rba_Runtime Measurement Variable[8]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E7C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[9].loadPer64k_u16
    "rba_Runtime Measurement Variable[9]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001EB0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[10].loadPer64k_u16
    "rba_Runtime Measurement Variable[10]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001EE4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[11].loadPer64k_u16
    "rba_Runtime Measurement Variable[11]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F18


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[12].loadPer64k_u16
    "rba_Runtime Measurement Variable[12]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F4C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[13].loadPer64k_u16
    "rba_Runtime Measurement Variable[13]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F80


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[14].loadPer64k_u16
    "rba_Runtime Measurement Variable[14]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001FB4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[15].loadPer64k_u16
    "rba_Runtime Measurement Variable[15]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001FE8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[16].loadPer64k_u16
    "rba_Runtime Measurement Variable[16]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000201C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[17].loadPer64k_u16
    "rba_Runtime Measurement Variable[17]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002050


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[18].loadPer64k_u16
    "rba_Runtime Measurement Variable[18]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002084


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[19].loadPer64k_u16
    "rba_Runtime Measurement Variable[19]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x700020B8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[20].loadPer64k_u16
    "rba_Runtime Measurement Variable[20]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x700020EC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[21].loadPer64k_u16
    "rba_Runtime Measurement Variable[21]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002120


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[22].loadPer64k_u16
    "rba_Runtime Measurement Variable[22]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002154


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[23].loadPer64k_u16
    "rba_Runtime Measurement Variable[23]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002188


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[24].loadPer64k_u16
    "rba_Runtime Measurement Variable[24]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x700021BC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[25].loadPer64k_u16
    "rba_Runtime Measurement Variable[25]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x700021F0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[26].loadPer64k_u16
    "rba_Runtime Measurement Variable[26]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002224


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[27].loadPer64k_u16
    "rba_Runtime Measurement Variable[27]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002258


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[28].loadPer64k_u16
    "rba_Runtime Measurement Variable[28]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000228C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[29].loadPer64k_u16
    "rba_Runtime Measurement Variable[29]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x700022C0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[30].loadPer64k_u16
    "rba_Runtime Measurement Variable[30]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x700022F4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[31].loadPer64k_u16
    "rba_Runtime Measurement Variable[31]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002328


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[32].loadPer64k_u16
    "rba_Runtime Measurement Variable[32]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000235C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[33].loadPer64k_u16
    "rba_Runtime Measurement Variable[33]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002390


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[34].loadPer64k_u16
    "rba_Runtime Measurement Variable[34]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x700023C4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[35].loadPer64k_u16
    "rba_Runtime Measurement Variable[35]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x700023F8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[36].loadPer64k_u16
    "rba_Runtime Measurement Variable[36]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000242C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[37].loadPer64k_u16
    "rba_Runtime Measurement Variable[37]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002460


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[38].loadPer64k_u16
    "rba_Runtime Measurement Variable[38]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002494


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[39].loadPer64k_u16
    "rba_Runtime Measurement Variable[39]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x700024C8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[40].loadPer64k_u16
    "rba_Runtime Measurement Variable[40]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x700024FC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[41].loadPer64k_u16
    "rba_Runtime Measurement Variable[41]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002530


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[42].loadPer64k_u16
    "rba_Runtime Measurement Variable[42]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002564


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[43].loadPer64k_u16
    "rba_Runtime Measurement Variable[43]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002598


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[44].loadPer64k_u16
    "rba_Runtime Measurement Variable[44]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x700025CC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[45].loadPer64k_u16
    "rba_Runtime Measurement Variable[45]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002600


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[46].loadPer64k_u16
    "rba_Runtime Measurement Variable[46]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002634


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[47].loadPer64k_u16
    "rba_Runtime Measurement Variable[47]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002668


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[48].loadPer64k_u16
    "rba_Runtime Measurement Variable[48]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000269C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[49].loadPer64k_u16
    "rba_Runtime Measurement Variable[49]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x700026D0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[50].loadPer64k_u16
    "rba_Runtime Measurement Variable[50]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002704


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[51].loadPer64k_u16
    "rba_Runtime Measurement Variable[51]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002738


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[52].loadPer64k_u16
    "rba_Runtime Measurement Variable[52]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000276C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[53].loadPer64k_u16
    "rba_Runtime Measurement Variable[53]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x700027A0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[54].loadPer64k_u16
    "rba_Runtime Measurement Variable[54]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x700027D4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[55].loadPer64k_u16
    "rba_Runtime Measurement Variable[55]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002808


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[56].loadPer64k_u16
    "rba_Runtime Measurement Variable[56]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000283C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[57].loadPer64k_u16
    "rba_Runtime Measurement Variable[57]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002870


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[58].loadPer64k_u16
    "rba_Runtime Measurement Variable[58]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x700028A4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[59].loadPer64k_u16
    "rba_Runtime Measurement Variable[59]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x700028D8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[60].loadPer64k_u16
    "rba_Runtime Measurement Variable[60]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000290C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[61].loadPer64k_u16
    "rba_Runtime Measurement Variable[61]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002940


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[62].loadPer64k_u16
    "rba_Runtime Measurement Variable[62]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002974


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[63].loadPer64k_u16
    "rba_Runtime Measurement Variable[63]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x700029A8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[64].loadPer64k_u16
    "rba_Runtime Measurement Variable[64]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x700029DC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[0].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001CDE


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[1].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[1]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D12


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[2].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[2]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D46


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[3].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[3]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D7A


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[4].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[4]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001DAE


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[5].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[5]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001DE2


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[6].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[6]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E16


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[7].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[7]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E4A


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[8].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[8]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E7E


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[9].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[9]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001EB2


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[10].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[10]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001EE6


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[11].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[11]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F1A


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[12].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[12]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F4E


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[13].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[13]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F82


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[14].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[14]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001FB6


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[15].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[15]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001FEA


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[16].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[16]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000201E


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[17].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[17]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002052


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[18].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[18]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002086


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[19].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[19]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x700020BA


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[20].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[20]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x700020EE


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[21].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[21]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002122


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[22].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[22]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002156


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[23].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[23]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000218A


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[24].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[24]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x700021BE


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[25].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[25]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x700021F2


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[26].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[26]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002226


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[27].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[27]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000225A


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[28].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[28]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000228E


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[29].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[29]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x700022C2


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[30].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[30]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x700022F6


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[31].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[31]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000232A


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[32].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[32]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000235E


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[33].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[33]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002392


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[34].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[34]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x700023C6


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[35].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[35]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x700023FA


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[36].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[36]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000242E


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[37].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[37]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002462


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[38].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[38]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002496


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[39].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[39]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x700024CA


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[40].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[40]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x700024FE


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[41].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[41]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002532


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[42].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[42]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002566


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[43].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[43]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000259A


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[44].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[44]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x700025CE


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[45].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[45]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002602


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[46].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[46]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002636


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[47].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[47]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000266A


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[48].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[48]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000269E


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[49].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[49]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x700026D2


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[50].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[50]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002706


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[51].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[51]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000273A


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[52].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[52]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000276E


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[53].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[53]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x700027A2


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[54].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[54]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x700027D6


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[55].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[55]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000280A


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[56].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[56]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000283E


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[57].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[57]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002872


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[58].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[58]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x700028A6


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[59].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[59]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x700028DA


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[60].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[60]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000290E


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[61].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[61]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002942


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[62].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[62]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002976


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[63].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[63]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x700029AA


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[64].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[64]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x700029DE


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[0].results_ast[0].tiAvrgRT_u32
    "rba_Runtime Measurement Variable/[0]/[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700017CC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[1].results_ast[0].tiAvrgRT_u32
    "rba_Runtime Measurement Variable/[1]/[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700017F0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[2].results_ast[0].tiAvrgRT_u32
    "rba_Runtime Measurement Variable/[2]/[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001814


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[3].results_ast[0].tiAvrgRT_u32
    "rba_Runtime Measurement Variable/[3]/[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001838


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[0].results_ast[0].tiMinRT_u32
    "rba_Runtime Measurement Variable/[0]/[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700017D0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[1].results_ast[0].tiMinRT_u32
    "rba_Runtime Measurement Variable/[1]/[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700017F4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[2].results_ast[0].tiMinRT_u32
    "rba_Runtime Measurement Variable/[2]/[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001818


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[3].results_ast[0].tiMinRT_u32
    "rba_Runtime Measurement Variable/[3]/[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000183C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[0].results_ast[0].tiMaxRT_u32
    "rba_Runtime Measurement Variable/[0]/[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700017D4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[1].results_ast[0].tiMaxRT_u32
    "rba_Runtime Measurement Variable/[1]/[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700017F8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[2].results_ast[0].tiMaxRT_u32
    "rba_Runtime Measurement Variable/[2]/[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000181C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[3].results_ast[0].tiMaxRT_u32
    "rba_Runtime Measurement Variable/[3]/[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001840


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[0].results_ast[0].tiAvrgCD_u32
    "rba_Runtime Measurement Variable/[0]/[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700017D8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[1].results_ast[0].tiAvrgCD_u32
    "rba_Runtime Measurement Variable/[1]/[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700017FC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[2].results_ast[0].tiAvrgCD_u32
    "rba_Runtime Measurement Variable/[2]/[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001820


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[3].results_ast[0].tiAvrgCD_u32
    "rba_Runtime Measurement Variable/[3]/[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001844


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[0].results_ast[0].tiMinCD_u32
    "rba_Runtime Measurement Variable/[0]/[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700017DC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[1].results_ast[0].tiMinCD_u32
    "rba_Runtime Measurement Variable/[1]/[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001800


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[2].results_ast[0].tiMinCD_u32
    "rba_Runtime Measurement Variable/[2]/[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001824


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[3].results_ast[0].tiMinCD_u32
    "rba_Runtime Measurement Variable/[3]/[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001848


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[0].results_ast[0].tiMaxCD_u32
    "rba_Runtime Measurement Variable/[0]/[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700017E0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[1].results_ast[0].tiMaxCD_u32
    "rba_Runtime Measurement Variable/[1]/[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001804


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[2].results_ast[0].tiMaxCD_u32
    "rba_Runtime Measurement Variable/[2]/[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001828


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[3].results_ast[0].tiMaxCD_u32
    "rba_Runtime Measurement Variable/[3]/[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000184C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[0].results_ast[0].ctCalls_u32
    "rba_Runtime Measurement Variable/[0]/[0]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700017E4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[1].results_ast[0].ctCalls_u32
    "rba_Runtime Measurement Variable/[1]/[0]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001808


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[2].results_ast[0].ctCalls_u32
    "rba_Runtime Measurement Variable/[2]/[0]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000182C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[3].results_ast[0].ctCalls_u32
    "rba_Runtime Measurement Variable/[3]/[0]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001850


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[0].results_ast[0].ctReentCalls_u32
    "rba_Runtime Measurement Variable/[0]/[0]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700017E8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[1].results_ast[0].ctReentCalls_u32
    "rba_Runtime Measurement Variable/[1]/[0]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000180C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[2].results_ast[0].ctReentCalls_u32
    "rba_Runtime Measurement Variable/[2]/[0]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001830


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[3].results_ast[0].ctReentCalls_u32
    "rba_Runtime Measurement Variable/[3]/[0]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001854


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[0].tiSampleDuration_u32
    "rba_Runtime Measurement Variable/[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700017EC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[1].tiSampleDuration_u32
    "rba_Runtime Measurement Variable/[1]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001810


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[2].tiSampleDuration_u32
    "rba_Runtime Measurement Variable/[2]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001834


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[3].tiSampleDuration_u32
    "rba_Runtime Measurement Variable/[3]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001858


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.ctSample_u8
    "rba_Runtime Measurement Variable/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000185C


/end MEASUREMENT




/begin MEASUREMENT

    rba_SvbbEtk_ControlVar[0].Control_u8
    "State of configured ServicePoints[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600031A0


/end MEASUREMENT




/begin MEASUREMENT

    rba_SvbbEtk_ControlVar[1].Control_u8
    "State of configured ServicePoints[1]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600031A4


/end MEASUREMENT




/begin MEASUREMENT

    rba_SvbbEtk_ControlVar[2].Control_u8
    "State of configured ServicePoints[2]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600031A8


/end MEASUREMENT




/begin MEASUREMENT

    rba_SvbbEtk_ControlVar[3].Control_u8
    "State of configured ServicePoints[3]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600031AC


/end MEASUREMENT




/begin MEASUREMENT

    rba_SvbbEtk_ControlVar[0].ErrCntPre_u8
    "State of configured ServicePoints[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600031A1


/end MEASUREMENT




/begin MEASUREMENT

    rba_SvbbEtk_ControlVar[1].ErrCntPre_u8
    "State of configured ServicePoints[1]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600031A5


/end MEASUREMENT




/begin MEASUREMENT

    rba_SvbbEtk_ControlVar[2].ErrCntPre_u8
    "State of configured ServicePoints[2]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600031A9


/end MEASUREMENT




/begin MEASUREMENT

    rba_SvbbEtk_ControlVar[3].ErrCntPre_u8
    "State of configured ServicePoints[3]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600031AD


/end MEASUREMENT




/begin MEASUREMENT

    rba_SvbbEtk_ControlVar[0].ErrCntPost_u8
    "State of configured ServicePoints[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600031A2


/end MEASUREMENT




/begin MEASUREMENT

    rba_SvbbEtk_ControlVar[1].ErrCntPost_u8
    "State of configured ServicePoints[1]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600031A6


/end MEASUREMENT




/begin MEASUREMENT

    rba_SvbbEtk_ControlVar[2].ErrCntPost_u8
    "State of configured ServicePoints[2]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600031AA


/end MEASUREMENT




/begin MEASUREMENT

    rba_SvbbEtk_ControlVar[3].ErrCntPost_u8
    "State of configured ServicePoints[3]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600031AE


/end MEASUREMENT




/begin MEASUREMENT

    rba_SvbbEtk_ControlVar[0].FailedTriggerCounter_u8
    "State of configured ServicePoints[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600031A3


/end MEASUREMENT




/begin MEASUREMENT

    rba_SvbbEtk_ControlVar[1].FailedTriggerCounter_u8
    "State of configured ServicePoints[1]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600031A7


/end MEASUREMENT




/begin MEASUREMENT

    rba_SvbbEtk_ControlVar[2].FailedTriggerCounter_u8
    "State of configured ServicePoints[2]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600031AB


/end MEASUREMENT




/begin MEASUREMENT

    rba_SvbbEtk_ControlVar[3].FailedTriggerCounter_u8
    "State of configured ServicePoints[3]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600031AF


/end MEASUREMENT




/begin MEASUREMENT

    rba_SvbbEtk_DelayedEcuInitialisation
    "time in ms the ECU initialization was delayed, because it was waiting for download of Bypass configuration"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.1"
    ECU_ADDRESS 0x6000C46A


/end MEASUREMENT




/begin MEASUREMENT

    rba_SvbbEtk_DummyVar
    "Dummy variable which can be stimulated at ServicePoint \"rba_Svbb_DummyActivate\" for activation of ServiceBasedBypass"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.1"
    ECU_ADDRESS 0x6000C469


/end MEASUREMENT




/begin MEASUREMENT

    rba_SvbbEtk_stEnable
    "Internal state of Service Based Bypass"
    UBYTE
    RB_RBA_rba_SvbbEtk_CompuMethods_rba_SvbbEtk_StateEnable_CM
    1
    100
    0.0
    255.
    FORMAT "%5.1"
    ECU_ADDRESS 0x6000C468


/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_ObservationCounters_IrrSwOffTrigEngRun_Value_MP
    "ObservationCounter: Irregular Switch Off Counter Triggered by Engine Running"
    UBYTE
    DefaultIdenticalCompu
    1
    100
    0.0
    255.0
    ECU_ADDRESS 0x700303D8

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "ObservationCounter: Irregular Switch Off Counter Triggered by Engine Running\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_ObservationCounters_IrrSwOff_Value_MP
    "ObservationCounter: Irregular SwitchOff Counter"
    UBYTE
    DefaultIdenticalCompu
    1
    100
    0.0
    255.0
    ECU_ADDRESS 0x700303D9

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "ObservationCounter: Irregular SwitchOff Counter\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_States_CurrentState_MP
    "Current state of System Control"
    UBYTE
    RB_RBA_rba_SyC_States_BswModuleDescriptions_rba_SyC_States_CompuMethod
    1
    100
    0.0
    7.
    FORMAT "%8.3"
    ECU_ADDRESS 0x700303DC

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Current state of System Control\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_States_PostDrive_Prolongers_MP
    "Prolongers in PostDrive State"
    UBYTE
    RB_RBA_rba_SyC_States_BswModuleDescriptions_rba_SyC_Prolongers_CompuMethod
    1
    100
    0.0
    255.
    FORMAT "%8.3"
    ECU_ADDRESS 0x700303E3

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Prolongers in PostDrive State\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION

    MATRIX_DIM 1 


/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_States_PostDrive_TimeoutCounterBegin_MP
    "Timeout Counter for PostDrive Begin"
    UBYTE
    DefaultIdenticalCompu
    1
    100
    0.0
    255.0
    ECU_ADDRESS 0x700303DF

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Timeout Counter for PostDrive Begin\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_States_PostDrive_TimeoutCounterEnd_MP
    "Timeout Counter for PostDrive End"
    UBYTE
    DefaultIdenticalCompu
    1
    100
    0.0
    255.0
    ECU_ADDRESS 0x700303DD

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Timeout Counter for PostDrive End\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_States_PostDrive_TimeoutCounterNetwork_MP
    "Timeout Counter for PostDrive Network"
    UBYTE
    DefaultIdenticalCompu
    1
    100
    0.0
    255.0
    ECU_ADDRESS 0x700303DE

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Timeout Counter for PostDrive Network\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_States_PostDrive_TimeoutHistoryBegin_MP
    "Timeout history for PostDrive Begin"
    UBYTE
    DefaultIdenticalCompu
    1
    100
    0.0
    255.0
    ECU_ADDRESS 0x700303E2

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Timeout history for PostDrive Begin\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_States_PostDrive_TimeoutHistoryEnd_MP
    "Timeout history for PostDrive End"
    UBYTE
    DefaultIdenticalCompu
    1
    100
    0.0
    255.0
    ECU_ADDRESS 0x700303E0

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Timeout history for PostDrive End\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_States_PostDrive_TimeoutHistoryNetwork_MP
    "Timeout history for PostDrive Network"
    UBYTE
    DefaultIdenticalCompu
    1
    100
    0.0
    255.0
    ECU_ADDRESS 0x700303E1

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Timeout history for PostDrive Network\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_States_PostDrive_substate_MP
    "Sub-state of System Control state PostDrive"
    UBYTE
    RB_RBA_rba_SyC_States_BswModuleDescriptions_rba_SyC_States_PostDrive_CompuMethod
    1
    100
    0.0
    9.
    FORMAT "%8.3"
    ECU_ADDRESS 0x700303E4

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Sub-state of System Control state PostDrive\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_States_PrepareDrive_substate_MP
    "Sub-state of System Control state PrepareDrive"
    UBYTE
    RB_RBA_rba_SyC_States_BswModuleDescriptions_rba_SyC_States_PrepareDrive_CompuMethod
    1
    100
    0.0
    3.
    FORMAT "%8.3"
    ECU_ADDRESS 0x700303E5

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Sub-state of System Control state PrepareDrive\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_States_PrepareShutdown_Prolongers_MP
    "Prolongers in PrepareShutdown State"
    UBYTE
    RB_RBA_rba_SyC_States_BswModuleDescriptions_rba_SyC_Prolongers_CompuMethod
    1
    100
    0.0
    255.
    FORMAT "%8.3"
    ECU_ADDRESS 0x700303E8

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Prolongers in PrepareShutdown State\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION

    MATRIX_DIM 1 


/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_States_PrepareShutdown_TimeoutCounterComplete_MP
    "Timeout Counter for PrepareShutdown Complete"
    UBYTE
    DefaultIdenticalCompu
    1
    100
    0.0
    255.0
    ECU_ADDRESS 0x700303E6

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Timeout Counter for PrepareShutdown Complete\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_States_PrepareShutdown_TimeoutHistoryComplete_MP
    "Timeout history for PrepareShutdown Complete"
    UBYTE
    DefaultIdenticalCompu
    1
    100
    0.0
    255.0
    ECU_ADDRESS 0x700303E7

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Timeout history for PrepareShutdown Complete\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_States_PrepareShutdown_substate_MP
    "Sub-state of System Control state PrepareShutdown"
    UBYTE
    RB_RBA_rba_SyC_States_BswModuleDescriptions_rba_SyC_States_PrepareShutdown_CompuMethod
    1
    100
    0.0
    6.
    FORMAT "%8.3"
    ECU_ADDRESS 0x700303E9

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Sub-state of System Control state PrepareShutdown\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_States_PreviousState_MP
    "Previous state of System Control"
    UBYTE
    RB_RBA_rba_SyC_States_BswModuleDescriptions_rba_SyC_States_CompuMethod
    1
    100
    0.0
    7.
    FORMAT "%8.3"
    ECU_ADDRESS 0x700303DB

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Previous state of System Control\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_States_Wait_Prolongers_MP
    "Prolongers in Wait State"
    UBYTE
    RB_RBA_rba_SyC_States_BswModuleDescriptions_rba_SyC_Prolongers_CompuMethod
    1
    100
    0.0
    255.
    FORMAT "%8.3"
    ECU_ADDRESS 0x700303F6

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Prolongers in Wait Stat\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION

    MATRIX_DIM 1 


/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_States_Wait_TimeoutCounterDelay_MP
    "Timeout Counter for Wait Delay"
    UBYTE
    DefaultIdenticalCompu
    1
    100
    0.0
    255.0
    ECU_ADDRESS 0x700303F0

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Timeout Counter for Wait Delay\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_States_Wait_TimeoutCounterNetwork_MP
    "Timeout Counter for Wait Network"
    UBYTE
    DefaultIdenticalCompu
    1
    100
    0.0
    255.0
    ECU_ADDRESS 0x700303F1

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Timeout Counter for Wait Network\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_States_Wait_TimeoutCounterProlong_MP
    "Timeout Counter for Wait Prolong"
    UBYTE
    DefaultIdenticalCompu
    1
    100
    0.0
    255.0
    ECU_ADDRESS 0x700303F2

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Timeout Counter for Wait Prolong\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_States_Wait_TimeoutHistoryDelay_MP
    "Timeout history for Wait Delay"
    UBYTE
    DefaultIdenticalCompu
    1
    100
    0.0
    255.0
    ECU_ADDRESS 0x700303F3

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Timeout history for Wait Delay\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_States_Wait_TimeoutHistoryNetwork_MP
    "Timeout history for Wait Network"
    UBYTE
    DefaultIdenticalCompu
    1
    100
    0.0
    255.0
    ECU_ADDRESS 0x700303F4

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Timeout history for Wait Network\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_States_Wait_TimeoutHistoryProlong_MP
    "Timeout history for Wait Prolong"
    UBYTE
    DefaultIdenticalCompu
    1
    100
    0.0
    255.0
    ECU_ADDRESS 0x700303F5

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Timeout history for Wait Prolong\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_States_Wait_substate_MP
    "Sub-state of System Control state Wait"
    UBYTE
    RB_RBA_rba_SyC_States_BswModuleDescriptions_rba_SyC_States_Wait_CompuMethod
    1
    100
    0.0
    5.
    FORMAT "%8.3"
    ECU_ADDRESS 0x700303F7

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Sub-state of System Control state Wait\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_User_GlobalScope_Prolongers_MP
    "Prolongers in Global Scope"
    UBYTE
    RB_RBA_rba_SyC_States_BswModuleDescriptions_rba_SyC_Prolongers_CompuMethod
    1
    100
    0.0
    255.
    FORMAT "%8.3"
    ECU_ADDRESS 0x700303ED

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Prolongers in Global Scope\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION

    MATRIX_DIM 1 


/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_User_PostDriveScope_Delayers_MP
    "Delayers in PostDrive Scope"
    UBYTE
    RB_RBA_rba_SyC_States_BswModuleDescriptions_rba_SyC_Prolongers_CompuMethod
    1
    100
    0.0
    255.
    FORMAT "%8.3"
    ECU_ADDRESS 0x700303EB

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Delayers in PostDrive Scope\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION

    MATRIX_DIM 1 


/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_User_PostDriveScope_Prolongers_MP
    "Prolongers in PostDrive Scope"
    UBYTE
    RB_RBA_rba_SyC_States_BswModuleDescriptions_rba_SyC_Prolongers_CompuMethod
    1
    100
    0.0
    255.
    FORMAT "%8.3"
    ECU_ADDRESS 0x700303EE

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Prolongers in PostDrive Scope\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION

    MATRIX_DIM 1 


/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_User_PrepareShutdownScope_Delayers_MP
    "Delayers in PrepareShutdown Scope"
    UBYTE
    RB_RBA_rba_SyC_States_BswModuleDescriptions_rba_SyC_Prolongers_CompuMethod
    1
    100
    0.0
    255.
    FORMAT "%8.3"
    ECU_ADDRESS 0x700303EA

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Delayers in PrepareShutdown Scope\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION

    MATRIX_DIM 1 


/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_User_WaitScope_Delayers_MP
    "Delayers in Wait Scope"
    UBYTE
    RB_RBA_rba_SyC_States_BswModuleDescriptions_rba_SyC_Prolongers_CompuMethod
    1
    100
    0.0
    255.
    FORMAT "%8.3"
    ECU_ADDRESS 0x700303EC

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Delayers in Wait Scope\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION

    MATRIX_DIM 1 


/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_User_WaitScope_Prolongers_MP
    "Prolongers in Wait Scope"
    UBYTE
    RB_RBA_rba_SyC_States_BswModuleDescriptions_rba_SyC_Prolongers_CompuMethod
    1
    100
    0.0
    255.
    FORMAT "%8.3"
    ECU_ADDRESS 0x700303EF

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Prolongers in Wait Scope\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION

    MATRIX_DIM 1 


/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_tiBoot_us_MP
    "Time elapsed for BOOT State in micro seconds"
    ULONG
    DefaultIdenticalCompu
    1
    100
    0.0
    4.294967295E9
    ECU_ADDRESS 0x700303CC

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Time elapsed for BOOT State in micro seconds\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_tiDrive_10ms_MP
    "Time elapsed for Drive State in 10 milli seconds"
    ULONG
    DefaultIdenticalCompu
    1
    100
    0.0
    4.294967295E9
    ECU_ADDRESS 0x700303BC

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Time elapsed for Drive State in 10 milli seconds\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_tiInit_us_MP
    "Time elapsed for Init State in micro seconds"
    ULONG
    DefaultIdenticalCompu
    1
    100
    0.0
    4.294967295E9
    ECU_ADDRESS 0x700303C8

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Time elapsed for Init State in micro seconds\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_tiLastShutdown_us_MP
    "Time elapsed for Last Shutdown State in micro seconds"
    ULONG
    DefaultIdenticalCompu
    1
    100
    0.0
    4.294967295E9
    ECU_ADDRESS 0x700303B0

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Time elapsed for Shutdown State in micro seconds\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_tiPostDrive_10ms_MP
    "Time elapsed for Post Drive State in 10 milli seconds"
    ULONG
    DefaultIdenticalCompu
    1
    100
    0.0
    4.294967295E9
    ECU_ADDRESS 0x700303B8

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Time elapsed for Post Drive State in 10 milli seconds\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_tiPrepareDrive_10ms_MP
    "Time elapsed for Prepare drive State in 10 milli seconds"
    ULONG
    DefaultIdenticalCompu
    1
    100
    0.0
    4.294967295E9
    ECU_ADDRESS 0x700303C0

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Time elapsed for Prepare drive State in 10 milli seconds\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_tiPrepareShutdown_10ms_MP
    "Time elapsed for Prepare Shutdown State in 10 milli seconds"
    ULONG
    DefaultIdenticalCompu
    1
    100
    0.0
    4.294967295E9
    ECU_ADDRESS 0x700303B4

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Time elapsed for Prepare Shutdown State in 10 milli seconds\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_tiWait_10ms_MP
    "Time elapsed for Wait State in 10 milli seconds"
    ULONG
    DefaultIdenticalCompu
    1
    100
    0.0
    4.294967295E9
    ECU_ADDRESS 0x700303C4

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Time elapsed for Wait State in 10 milli seconds\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_T15_Signal_Debounced_MP
    "Debounced signal status of Terminal 15"
    UBYTE
    RB_RBA_rba_T15_BswModuleDescriptions_rba_T15_Signal_Status_CompuMethod
    1
    100
    0.0
    1.
    FORMAT "%8.3"
    ECU_ADDRESS 0x700303D6

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Debounced signal status of Terminal 15\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_T15_Signal_Logical_MP
    "Logical signal status of Terminal 15"
    UBYTE
    RB_RBA_rba_T15_BswModuleDescriptions_rba_T15_Signal_Status_CompuMethod
    1
    100
    0.0
    1.
    FORMAT "%8.3"
    ECU_ADDRESS 0x700303D7

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Logical signal status of Terminal 15\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_T15_Signal_UndebouncedValid_MP
    "Validity of undebounced signal status of Terminal 15"
    UBYTE
    RB_RBA_rba_T15_BswModuleDescriptions_rba_T15_Signal_StatusValid_CompuMethod
    1
    100
    0.0
    1.
    FORMAT "%8.3"
    ECU_ADDRESS 0x700303D4

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Validity of undebounced signal status of Terminal 15\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_T15_Signal_Undebounced_MP
    "Undebounced signal status of Terminal 15"
    UBYTE
    RB_RBA_rba_T15_BswModuleDescriptions_rba_T15_Signal_Status_CompuMethod
    1
    100
    0.0
    1.
    FORMAT "%8.3"
    ECU_ADDRESS 0x700303D5

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Undebounced signal status of Terminal 15\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    Unconnected_DcmTest_EngineSpeed
    "unsigned integer 16bit"
    UWORD
    SwComponentTypes_ComDia_Dcm_Rte_Adapter_SwComponentTypes_EngN
    1
    100
    0.0
    65535.
    FORMAT "%6.3"
    MAX_REFRESH 6 1
    ECU_ADDRESS 0x6000B40E


/end MEASUREMENT




/begin MEASUREMENT

    Unconnected_DcmTest_Timer
    "unsigned integer 16bit"
    UWORD
    SwComponentTypes_ComDia_Dcm_Rte_Adapter_SwComponentTypes_t100msxs_uw_b6553p5
    1
    100
    0.0
    65535.0
    MAX_REFRESH 6 1
    ECU_ADDRESS 0x6000B40C


/end MEASUREMENT




/begin MEASUREMENT

    TimedCom_hchannel_HC_OS_1ms_Task__OS_10ms_Task.TimedCom_HrmcCh_St_u32
    "State of the timed communication channel HC_OS_1ms_Task__OS_10ms_Task"
    ULONG
    TimedCom_HrmcCh_StMac_COMPU_VERB
    1
    1
    0.00
    4.00000000000
    FORMAT "%13.2"
    ECU_ADDRESS 0x70005724


/end MEASUREMENT




/begin MEASUREMENT

    TimedCom_hchannel_HC_OS_1ms_Task__OS_10ms_Task.TimedCom_HrmcCh_TransLastDurInUs_u32
    "Execution time (us) of last transaction for timed communication channel HC_OS_1ms_Task__OS_10ms_Task"
    ULONG
    OneToOne_us
    1
    1
    0.00
    4294967295.00
    FORMAT "%13.2"
    ECU_ADDRESS 0x70005730


/end MEASUREMENT




/begin MEASUREMENT

    TimedCom_hchannel_HC_OS_1ms_Task__OS_10ms_Task.TimedCom_HrmcCh_Err_u16
    "Last error of the timed communication channel HC_OS_1ms_Task__OS_10ms_Task"
    UWORD
    TimedCom_HrmcCh_Err_COMPU_VERB
    1
    1
    0.00
    4.00000000000
    FORMAT "%13.2"
    ECU_ADDRESS 0x70005734


/end MEASUREMENT




/begin MEASUREMENT

    TimedCom_hchannel_HC_OS_1ms_Task__OS_10ms_Task.TimedCom_HrmcCh_ErrCntr_u16
    "Error counter for timed communication channel HC_OS_1ms_Task__OS_10ms_Task"
    UWORD
    OneToOne
    1
    1
    0.00
    65536.00
    FORMAT "%13.2"
    ECU_ADDRESS 0x70005736


/end MEASUREMENT




/begin MEASUREMENT

    TimedCom_hchannel_HC_OS_1ms_Task__OS_10ms_Task.TimedCom_HrmcCh_TransCntr_u32
    "Transaction counter for timed communication channel HC_OS_1ms_Task__OS_10ms_Task"
    ULONG
    OneToOne
    1
    1
    0.00
    4294967295.00
    FORMAT "%13.2"
    ECU_ADDRESS 0x70005738


/end MEASUREMENT




/begin MEASUREMENT

    TimedCom_hchannel_HC_OS_1ms_Task__OS_10ms_Task.TimedCom_HrmcCh_SrcTskTransCntDwn_u32
    "Transaction counter of task OS_1ms_Task for timed communication channel HC_OS_1ms_Task__OS_10ms_Task"
    ULONG
    OneToOne
    1
    1
    0.00
    4294967295.00
    FORMAT "%13.2"
    ECU_ADDRESS 0x7000573C


/end MEASUREMENT




/begin MEASUREMENT

    TimedCom_hchannel_HC_OS_1ms_Task__OS_10ms_Task.TimedCom_HrmcCh_DestTskTransCntDwn_u32
    "Transaction counter of task OS_10ms_Task for timed communication channel HC_OS_1ms_Task__OS_10ms_Task"
    ULONG
    OneToOne
    1
    1
    0.00
    4294967295.00
    FORMAT "%13.2"
    ECU_ADDRESS 0x70005740


/end MEASUREMENT



/***********   End of merged MEASUREMENT blocks    ***********/
/begin MEASUREMENT

    ACCI_mEstimCAN
    "Vehiclemass of the Massestimationunit (needed to be written on the CAN)"
    SWORD
    ACCIMass
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B5E8

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    ACCI_rSlpRoad
    "Highway slope in ratio"
    SWORD
    Prc
    1
    100
    -400.0000
    399.9878

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0x6000B5E6

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    ACCI_stMVeh
    "Qualification bit for the vehicle mass"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7A8

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    ACCI_stRSlpRoad
    "Qualification bit for the highway slope"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7A7

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    AFS_mAirPerCyl
    "Air mass per cylinder"
    SWORD
    AirMassPerCyl
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000B5E4

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    AirSys_tFld
    "Temperature field, induction system"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    MATRIX_DIM 1  
    ECU_ADDRESS 0x6000B5DC

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    AmbPres_dataDigSens
    ""
    SLONG
    p_q1_Pa
    1
    100
    -2147483648.00
    2147483647.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x60003394

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    APP1_uRaw
    "."
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000B5E2

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    APP_r
    "Standardized accelerator pedal position"
    SWORD
    Prc
    1
    100
    -400.0000
    399.9878

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0x6000B5E0

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    APP_rUnFlt
    "Unfiltered APP value"
    SWORD
    Prc
    1
    100
    -400.0000
    399.9878

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0x6000B5DE

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    ATS_ctCurRunTst
    "Number of current activated actuators"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7A6

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    ATS_IntvVal_mp
    "Intervention value"
    SWORD
    OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x700302EE

/end MEASUREMENT

/begin MEASUREMENT

    ATS_stMon
    "status of ATS internal monitoring"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7B1

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    ATS_stMonTimeLimit
    "Behaviour time limit response for new tester demands"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7A5

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    ATS_TstStatus_mp
    "Status of actuatorintervention"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x700303A7

/end MEASUREMENT

/begin MEASUREMENT

    BasSvr_bFuncTstReq
    "condition general function request"
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x1
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6000C7AB

/end MEASUREMENT

/begin MEASUREMENT

    BattU_facCor
    "Correction factor for battery voltage"
    SWORD
    Fact
    1
    100
    -4.000000
    3.999878

    
    FORMAT "%8.6"
    
    ECU_ADDRESS 0x6000B5DA

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    BattU_u
    "Battery voltage"
    SWORD
    Volt_Batt
    1
    100
    -655360.0
    655340.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0x6000B5D8

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    BattU_uRaw
    "Battery voltage before defect detection and handling"
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000B5D6

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    BattU_uSens
    "Sensed battery voltage"
    SWORD
    Volt_Batt
    1
    100
    -655360.0
    655340.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0x6000B5D4

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    BrkP_uRaw
    "Raw voltage signal from brake pressure sensor."
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000B5D2

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Brk_r
    "Standardized angle of brake pedal"
    SWORD
    Prc
    1
    100
    -400.0000
    399.9878

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0x6000B542

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Brk_st
    "Brake switch state"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7A4

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Brk_stBrkBstWarn
    "Status to indicate low vacuum in brake booster"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7A3

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Brk_stExt
    "This is SW-VARIABLE"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7A2

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    B_deseehr_msg
    "Diagnosis power stage after the main Relay: entry conditions fulfilled"
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x1
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x700000D4

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    B_desee_msg
    "Diagnosis power stages, entry conditions fulfilled"
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x1
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x700000D5

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    B_eepwf
    "Condition Powerfail EEPROM"
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x1
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x700000CA

/end MEASUREMENT

/begin MEASUREMENT

    B_PmdInit_msg
    "Reset of standard powerstage diagnosis required"
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x1
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x700000D6

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    B_pwf
    "condition for powerfail"
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x1
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x700000C9

/end MEASUREMENT

/begin MEASUREMENT

    CEngDsT_t
    "Coolant temperature at engine output"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000B5D0

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Clth_st
    "Debounced status of Clutch"
    UBYTE
    dez
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7A1

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    CoDsplCtl_stCoErrLmp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7A0

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    CoDsplCtl_stDiaBlnIntv
    ""
    SWORD
    Pres_hPa
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B5CE

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    CoDsplCtl_stSVSReq_mp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x700303A6

/end MEASUREMENT

/begin MEASUREMENT

    CoEng_bObdTmrInctg
    "OBD timer is incrementing"
    UBYTE
    OneToOne
    1
    100
    0.00
    1.000

    BIT_MASK 0x1
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x6000C7AD

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    CoEng_flgShOffCtrlDne
    "Flag: the engine shut off control is completed and there are no further CoEng requirements to control actuators."
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x1
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x600000C8

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    CoEng_st
    "Engine operation status"
    UBYTE
    CoEng_st_COMPU_VERB
    1
    100
    0.00
    5.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6000C79E

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    CoEng_stMai
    "Variable for engine states"
    UWORD
    CoEng_stMai_VERB
    1
    100
    0.00
    16384.0000000

    
    FORMAT "%13.7"
    
    ECU_ADDRESS 0x6000B53E

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    CoEng_stOld
    "engine state before current state was reached"
    UBYTE
    CoEng_st_COMPU_VERB
    1
    100
    0.00
    5.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6000C79D

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    CoEng_stStopEng
    "Engine STOP order from CoEng"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C79C

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    CoEng_tiNormal
    "time since state COENG_RUNNING was reached"
    ULONG
    Time_ms
    1
    100
    0.00
    42949672950.0

    
    FORMAT "%13.1"
    
    ECU_ADDRESS 0x60003380

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    CoEng_tiNormalOBD
    "Engine running time - for OBD requirement"
    ULONG
    Time_sec_q1_COMPU
    1
    100
    1.0000000
    65535.0000000

    
    FORMAT "%13.7"
    
    ECU_ADDRESS 0x6000337C

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    CoEOM_stDSCHEDDem
    "Operation mode demand from DSCHED"
    UWORD
    OneToOne
    1
    100
    1.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B540

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    CoEOM_stOpModeActTSync
    "Diesel Particulate Filter Active Regeneration Status."
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x60003384

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    CoEOM_stOpModePos
    "Bit mask of the possible operation modes for the DSM-Scheduler"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B56C

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    CoEOM_stTransActv
    "Status if an operation mode change is active"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6D1

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    CoESS_stRcpt
    "recuperation state"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C79F

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    CoETS_rTrq
    "Calculated load value"
    SWORD
    Prc
    1
    100
    -400.0000
    399.9878

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0x6000B5CC

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_adrSrcAdrCtlDev
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C791

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_APP_rUnFlt
    ""
    SWORD
    Prc
    1
    100
    -400.0000
    399.9878

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0x6000B5CA

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_BOOST_Bauteil_Temp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C79A

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_BOOST_elektr_Fehler
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6BE

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_BOOST_Fehler_CAN_Comm
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6CF

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_BOOST_IstStrom_Aufnahme
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C799

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_BOOST_Ist_Spannung
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C798

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_BOOST_mech_Fehler
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6BD

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_BOOST_QBit_Bauteil_Temp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6CE

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_BOOST_QBit_Ist_Strom
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6CD

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_BOOST_Regelabweichung
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6CC

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_BOOST_StromSens_KS_Masse
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6CB

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_BOOST_StromSens_KS_Plus
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6CA

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_BOOST_Tempsens_KS_Masse
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6C9

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_BOOST_Tempsens_KS_Plus
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6C8

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_BOOST_Tempsens_OpenLoad
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6C7

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_BOOST_Uberspannung_48V
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6C6

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_BOOST_Ubertemperatur
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6C5

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_BOOST_Ueberspannung_12V
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6C4

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_BOOST_Unterspannung_12V
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6C3

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_BOOST_Unterspannung_48V
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6C2

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_BOOST_Verpolung_48V
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6C1

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_BOOST_ZyklusBit_EEPROM
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6C0

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_BOOST_ZyklusBit_kont
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6BF

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_ctENG11MsgCnt
    "Message counter value of CAN frame Motor_11"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C790

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_ctENG12V6MsgCnt
    "Message counter information of CAN frame Motor_12"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C78F

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_ctENG20MsgCnt
    "Message counter value of CAN frame Motor_20"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C78E

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_ctENG28MsgCnt
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C78D

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_dataEngCod0
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C789

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_dataEngCod1
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C788

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_dataEngCod2
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C787

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_dataEngCod3
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C786

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_dCANVer
    "Supported CAN version sent via CAN"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C78C

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_dDrvDemTrq
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C78B

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_dOilTOut
    "CAN Value of the oil temperature"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C78A

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_drAPPPrefilg
    "Absolute value for accelerator pedal position gradient sent on CAN"
    SWORD
    PrcPerSec_4ms
    1
    100
    -100000.0
    99996.9

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0x6000B5C8

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_ENG11Chksum
    "CAN signal Motor_11_CRC"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C797

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_ENG12V6Chksum
    "CAN signal Motor_12_CRC"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C796

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_ENG20Chksum
    "CAN signal Motor_20_CRC"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C795

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_ENG28Chksum
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C794

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_flgComNEngNeut
    "Neutral flag for Com_nEng"
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x1
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x700000D3

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_flgSwsVWGearActDspl
    "calibration variable"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6BC

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_flgSwvar
    "Flag Variable for Pdu EcuVariant"
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x1
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x70002B4C

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_flgtrqClthEngNegAvl
    "calibration variable"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6BB

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_MO_Drehzahl_VM
    ""
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B56A

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_MO_Fehlerstatus_Antrieb_FDR
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C793

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_MO_IstMoment_VKM
    "FlexRay Application Signal for Motor_28"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B568

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_MO_Mom_Begr_Schalt
    ""
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B566

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_MO_Mom_Begr_Schalt_Min
    ""
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B564

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_MO_Primaerachse_Anforderung
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C792

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_nEng
    "Engine speed sent over CAN"
    SWORD
    EngN
    1
    100
    -16384.00
    16383.50

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B5C6

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_nEngDes
    "Desired min/max engine speed for gearbox"
    SWORD
    EngN
    1
    100
    -16384.00
    16383.50

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B5C4

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_nEngMin
    "Desired minimal engine speed for gearbox"
    SWORD
    EngN
    1
    100
    -16384.00
    16383.50

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B5C2

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_nEngSpd
    ""
    SWORD
    EngN
    1
    100
    -16384.00
    16383.50

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B5C0

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_numCDA
    "CAN signal MO_Anzahl_Abgesch_Zyl"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C785

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_numGearPos
    "CAN signal MO_Gangposition"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C784

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_pCACDs
    "Boost Pressure"
    UWORD
    Pres_hPa
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B562

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_pEnv
    ""
    SWORD
    Pres_hPa
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B5BE

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_pwrPTC
    "CAN interface for signal MO_PTC_Leistung"
    UBYTE
    Pwr_50
    1
    100
    0.00
    12750.

    
    FORMAT "%5.0"
    
    ECU_ADDRESS 0x6000C783

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_rActEngTrq
    ""
    SWORD
    Prc_trq
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B5BC

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_rActEngTrqHiRes
    ""
    SBYTE
    Trq_PrcHi
    1
    100
    -16.00
    15.88

    
    FORMAT "%5.2"
    
    ECU_ADDRESS 0x6000C7A9

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_rEngDemTrq
    ""
    SWORD
    Prc_trq
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B5BA

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_rIncrRmn
    "Percentage value of torque-integral transmission intervention to be sent over CAN"
    SWORD
    Prc
    1
    100
    -400.0000
    399.9878

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0x6000B5B8

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_rNOvrd
    "Influence of number of revolution"
    SWORD
    Prc
    1
    100
    -400.0000
    399.9878

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0x6000B5B6

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_rWaPmpHeat
    "CAN signal for MO_Heizungspumpenansteuerung"
    SWORD
    Prc
    1
    100
    -400.0000
    399.9878

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0x6000B5B4

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_stAftRunTyp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C780

/end MEASUREMENT

/begin MEASUREMENT

    Com_stAirCIntv
    "Status of the Air Conditioned Intervention"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C77F

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_stAPPGradSign
    "Sign of the accelerator pedal gradient transmitted via CAN"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C782

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_stAPPLowIdl
    "Low Idle Information"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C781

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_stBrkTOut
    "Timeout brake message"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C77E

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_stCarTyp
    "CAN signal for MO_Fahrzeugtyp"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C77C

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_stCDA
    "CAN signal MO_Zylinderabschaltung"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C77D

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_stClthOut
    "Clutch switch Status"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C77B

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_stCylShOff
    "State of cylinder shut off for CAN transmission"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C77A

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_stDFESEntry
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C779

/end MEASUREMENT

/begin MEASUREMENT

    Com_stEng
    "Engine status"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C778

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_stEngTQBit
    "ComCIL interface of MO_QBit_Kuehlmittel_Temp"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C777

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_stEngTrqMode
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C776

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_stEngTxt
    "Motor text bits"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C775

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_stFlConsOvrFlw
    "fuel consumption &amp; Overflowbit in MSB"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C774

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_stGbxIntvLeadActv
    "Air path during gearbox intervention active"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C773

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_stGearAdvPrs
    "CAN signal MO_Schaltempf_verfbar"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C772

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_stGearPos
    "Display_position_gearbox"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C771

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_stIntrLck
    "Interlock switch signal for CAN output"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C770

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_stKD
    "Secured kick down signal"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C76F

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_stMILBlinkReq
    ""
    UBYTE
    Pres_hPa
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C76E

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_stMILReq
    "status of external request for MIL illumination"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C76D

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_stOilTQBit
    "Qualification bit for Oil temperature"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C76C

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_stPFltRgnActv
    "CAN signal MO_DPF_reg"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C76B

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_stSCRWarn
    "Com interface for SCR Warning"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C76A

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_stStopReq
    ""
    UBYTE
    Pres_hPa
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C767

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_stStSys
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C768

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_stSVSReq
    "Blink or Illuminate SVS Lamp"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C769

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_stSysErr
    "CAN signal SCR_Systemfehler"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C766

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_stSysLmp
    "Status system lamp for B8"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C765

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_stTransptModeActv
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C763

/end MEASUREMENT

/begin MEASUREMENT

    Com_stTRQ
    "Torque specification imprecise"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C764

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_stWaHtStg
    "Status of glow plugs"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C762

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_stWrnReq
    ""
    UBYTE
    Pres_hPa
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C761

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_swtSCRDsplEna
    "CAN signal SCR_verbaut"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C760

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_tEngTEng07
    "CAN signal MO_Kuehlmittel_Temp"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000B5B2

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_tEngTEng09
    "CAN signal MO_ITM_Kuehlmittel_Temp"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000B5B0

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_tIntkAirT
    "Intake Air temperature Sensor Value"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000B5AE

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_trqClthEng
    "CAN signal MO_Mom_Ist_Summe"
    SWORD
    Trq
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000B5AC

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_trqClthEngDes
    "Momentenanforderung Fahrpedal ACC ASR"
    SWORD
    Trq
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000B5AA

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_trqClthEngDesFlt
    "Momentenanforderung Fahrpedal ACC ASR gefiltert"
    SWORD
    Trq
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000B5A8

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_trqClthEngLimDyn
    "Maximal mögliches Drehmoment mit ESP ASR Eingriff"
    SWORD
    Trq
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000B5A6

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_trqClthEngLimStat
    "Maximal mögliches Drehmoment ohne ESP ASR Eingriff"
    SWORD
    Trq
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000B5A4

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_trqClthEngNegAvl
    "CAN signal for MO_Mom_neg_verfuegbar"
    SWORD
    Trq
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000B5A2

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_trqLos
    "Schub bzw. Verlustmoment ohne Gas"
    SWORD
    Trq
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000B5A0

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    CoVeh_bRollrModeActv
    "Status of local roll mode activates export BIT"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C79B

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    CoVOM_bSailEna
    "Application variable for the flexray pdu"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6D0

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    DcmDspUds_DID_requestIBChk
    "Internal variable to request the Info Block check internaly"
    UBYTE
    DcmDspUds_DID_requestIBChk_Cnv
    1
    100
    0.00
    2.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x70001480

/end MEASUREMENT

/begin MEASUREMENT

    Dcm_stCallWr
    "Call state of writing information into EEPROM"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6AD

/end MEASUREMENT

/begin MEASUREMENT

    Dcm_stEepOrder
    "EEPROM order state of writing information into EEPROM"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6AC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_ctArDebLvl.DFC_rbr_mo_OV_VSS1
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_mo_OV_VSS1"
    SWORD
    DFC_OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C278

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_ctArDebLvl.DFC_rbr_mo_OV_VSS2
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_mo_OV_VSS2"
    SWORD
    DFC_OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C27A

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_ctArDebLvl.DFC_rbr_mo_UV_VSS1
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_mo_UV_VSS1"
    SWORD
    DFC_OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C27C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_ctArDebLvl.DFC_rbr_mo_UV_VSS2
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_mo_UV_VSS2"
    SWORD
    DFC_OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C27E

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_ctArDebLvl.DFC_CANSM_E_BUS_OFF_NETWORK_0
    "Debouncing counters / Debounce Timer or Event counter for check DFC_CANSM_E_BUS_OFF_NETWORK_0"
    SWORD
    DFC_OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C280

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_ctArDebLvl.DFC_CANSM_E_BUS_OFF_NETWORK_1
    "Debouncing counters / Debounce Timer or Event counter for check DFC_CANSM_E_BUS_OFF_NETWORK_1"
    SWORD
    DFC_OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C282

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_ctArDebLvl.DFC_CANSM_E_BUS_OFF_NETWORK_2
    "Debouncing counters / Debounce Timer or Event counter for check DFC_CANSM_E_BUS_OFF_NETWORK_2"
    SWORD
    DFC_OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C284

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_ctArDebLvl.DFC_CANSM_E_BUS_OFF_NETWORK_3
    "Debouncing counters / Debounce Timer or Event counter for check DFC_CANSM_E_BUS_OFF_NETWORK_3"
    SWORD
    DFC_OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C286

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_ctArDebLvl.DFC_CANTRCV_E_NO_TRCV_CONTROL_0
    "Debouncing counters / Debounce Timer or Event counter for check DFC_CANTRCV_E_NO_TRCV_CONTROL_0"
    SWORD
    DFC_OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C288

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_ctArDebLvl.DFC_CAN_E_TIMEOUT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_CAN_E_TIMEOUT"
    SWORD
    DFC_OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C28A

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_ctArDebLvl.DFC_COMM_E_NET_START_IND_CHANNEL_0
    "Debouncing counters / Debounce Timer or Event counter for check DFC_COMM_E_NET_START_IND_CHANNEL_0"
    SWORD
    DFC_OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C28C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_ctArDebLvl.DFC_COMM_E_NET_START_IND_CHANNEL_1
    "Debouncing counters / Debounce Timer or Event counter for check DFC_COMM_E_NET_START_IND_CHANNEL_1"
    SWORD
    DFC_OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C28E

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_ctArDebLvl.DFC_COMM_E_NET_START_IND_CHANNEL_2
    "Debouncing counters / Debounce Timer or Event counter for check DFC_COMM_E_NET_START_IND_CHANNEL_2"
    SWORD
    DFC_OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C290

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_ctArDebLvl.DFC_COMM_E_NET_START_IND_CHANNEL_3
    "Debouncing counters / Debounce Timer or Event counter for check DFC_COMM_E_NET_START_IND_CHANNEL_3"
    SWORD
    DFC_OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C292

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_ctArDebLvl.DFC_COMM_E_NET_START_IND_CHANNEL_4
    "Debouncing counters / Debounce Timer or Event counter for check DFC_COMM_E_NET_START_IND_CHANNEL_4"
    SWORD
    DFC_OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C294

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_ctArDebLvl.DFC_COMM_E_NET_START_IND_CHANNEL_5
    "Debouncing counters / Debounce Timer or Event counter for check DFC_COMM_E_NET_START_IND_CHANNEL_5"
    SWORD
    DFC_OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C296

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_ctArDebLvl.DFC_LIN_E_TIMEOUT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_LIN_E_TIMEOUT"
    SWORD
    DFC_OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C298

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_ctArDebLvl.DFC_rba_MultiStackTrace_Threshold
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rba_MultiStackTrace_Threshold"
    SWORD
    DFC_OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C29A

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_TimeInRowDebFault
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_TimeInRowDebFault"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A894

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_EventInRowDebFault
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_EventInRowDebFault"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A898

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_DevLibBattUHi
    "Debouncing counters / Debounce Timer or Event counter for check DFC_DevLibBattUHi"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A89C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_DevLibBattULo
    "Debouncing counters / Debounce Timer or Event counter for check DFC_DevLibBattULo"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A8A0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_TimeUpDownDebFault
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_TimeUpDownDebFault"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A8A4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA13OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA13OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A8A8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA13SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA13SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A8AC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA13SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA13SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A8B0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA14OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA14OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A8B4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA14SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA14SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A8B8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA14SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA14SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A8BC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA21OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA21OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A8C0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA21SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA21SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A8C4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA21SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA21SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A8C8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA22OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA22OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A8CC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA22SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA22SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A8D0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA22SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA22SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A8D4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA23OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA23OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A8D8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA23SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA23SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A8DC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA23SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA23SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A8E0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA24OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA24OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A8E4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA24SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA24SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A8E8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA24SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA24SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A8EC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA25OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA25OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A8F0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA25SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA25SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A8F4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA25SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA25SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A8F8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA26OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA26OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A8FC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA26SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA26SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A900

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA26SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA26SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A904

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA27OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA27OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A908

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA27SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA27SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A90C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA27SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA27SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A910

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA28OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA28OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A914

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA28SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA28SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A918

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA28SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA28SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A91C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA29OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA29OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A920

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA29SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA29SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A924

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA29SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA29SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A928

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA36AicSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA36AicSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A92C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA36AicSCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA36AicSCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A930

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA36OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA36OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A934

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA36SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA36SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A938

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA36SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA36SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A93C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA36ShuntSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA36ShuntSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A940

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA37AicSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA37AicSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A944

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA37AicSCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA37AicSCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A948

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA37OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA37OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A94C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA37SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA37SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A950

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA37SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA37SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A954

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA37ShuntSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA37ShuntSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A958

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA38AicSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA38AicSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A95C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA38AicSCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA38AicSCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A960

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA38OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA38OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A964

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA38SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA38SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A968

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA38SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA38SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A96C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA38ShuntSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA38ShuntSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A970

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA39AicSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA39AicSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A974

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA39AicSCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA39AicSCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A978

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA39OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA39OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A97C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA39SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA39SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A980

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA39SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA39SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A984

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA39ShuntSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA39ShuntSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A988

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA40OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA40OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A98C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA40SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA40SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A990

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA40SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA40SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A994

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA41OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA41OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A998

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA41SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA41SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A99C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA41SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA41SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A9A0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA42OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA42OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A9A4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA42SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA42SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A9A8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA42SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA42SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A9AC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA43AicSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA43AicSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A9B0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA43AicSCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA43AicSCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A9B4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA43OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA43OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A9B8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA43SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA43SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A9BC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA43SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA43SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A9C0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA43ShuntSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA43ShuntSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A9C4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA44OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA44OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A9C8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA44SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA44SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A9CC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA44SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA44SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A9D0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA57OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA57OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A9D4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA57SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA57SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A9D8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA57SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA57SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A9DC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA59OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA59OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A9E0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA59SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA59SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A9E4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA59SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA59SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A9E8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK10OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK10OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A9EC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK10SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK10SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A9F0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK10SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK10SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A9F4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK11OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK11OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A9F8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK11SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK11SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A9FC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK11SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK11SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA00

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK30AicSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK30AicSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA04

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK30AicSCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK30AicSCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA08

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK30OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK30OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA0C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK30SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK30SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA10

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK30SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK30SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA14

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK30ShuntSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK30ShuntSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA18

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK31OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK31OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA1C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK31SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK31SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA20

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK31SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK31SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA24

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK32OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK32OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA28

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK32SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK32SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA2C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK32SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK32SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA30

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK33OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK33OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA34

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK33SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK33SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA38

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK33SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK33SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA3C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK34OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK34OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA40

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK34SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK34SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA44

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK34SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK34SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA48

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK35OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK35OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA4C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK35SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK35SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA50

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK35SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK35SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA54

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK36OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK36OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA58

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK36SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK36SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA5C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK36SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK36SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA60

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK37AicSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK37AicSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA64

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK37AicSCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK37AicSCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA68

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK37OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK37OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA6C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK37SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK37SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA70

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK37SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK37SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA74

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK37ShuntSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK37ShuntSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA78

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK38AicSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK38AicSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA7C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK38AicSCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK38AicSCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA80

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK38OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK38OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA84

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK38SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK38SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA88

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK38SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK38SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA8C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK38ShuntSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK38ShuntSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA90

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK39AicSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK39AicSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA94

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK39AicSCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK39AicSCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA98

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK39OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK39OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA9C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK39SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK39SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AAA0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK39SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK39SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AAA4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK39ShuntSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK39ShuntSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AAA8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK40AicSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK40AicSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AAAC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK40AicSCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK40AicSCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AAB0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK40OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK40OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AAB4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK40SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK40SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AAB8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK40SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK40SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AABC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK40ShuntSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK40ShuntSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AAC0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK41AicSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK41AicSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AAC4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK41AicSCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK41AicSCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AAC8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK41OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK41OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AACC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK41SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK41SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AAD0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK41SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK41SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AAD4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK41ShuntSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK41ShuntSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AAD8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK42AicSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK42AicSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AADC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK42AicSCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK42AicSCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AAE0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK42OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK42OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AAE4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK42SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK42SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AAE8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK42SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK42SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AAEC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK42ShuntSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK42ShuntSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AAF0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK43OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK43OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AAF4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK43SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK43SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AAF8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK43SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK43SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AAFC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK44AicSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK44AicSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB00

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK44AicSCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK44AicSCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB04

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK44OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK44OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB08

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK44SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK44SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB0C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK44SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK44SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB10

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK44ShuntSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK44ShuntSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB14

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK45AicSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK45AicSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB18

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK45AicSCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK45AicSCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB1C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK45OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK45OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB20

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK45SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK45SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB24

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK45SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK45SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB28

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK45ShuntSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK45ShuntSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB2C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK52OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK52OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB30

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK52SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK52SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB34

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK52SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK52SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB38

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK53OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK53OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB3C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK53SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK53SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB40

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK53SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK53SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB44

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK54AicSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK54AicSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB48

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK54AicSCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK54AicSCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB4C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK54OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK54OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB50

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK54SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK54SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB54

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK54SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK54SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB58

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK54ShuntSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK54ShuntSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB5C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK55AicSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK55AicSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB60

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK55AicSCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK55AicSCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB64

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK55OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK55OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB68

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK55SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK55SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB6C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK55SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK55SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB70

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK55ShuntSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK55ShuntSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB74

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK56OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK56OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB78

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK56SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK56SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB7C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK56SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK56SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB80

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK57OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK57OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB84

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK57SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK57SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB88

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK57SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK57SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB8C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK58OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK58OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB90

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK58SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK58SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB94

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK58SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK58SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB98

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK59OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK59OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB9C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK59SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK59SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ABA0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK59SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK59SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ABA4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK60OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK60OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ABA8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK60SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK60SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ABAC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK60SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK60SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ABB0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK61AicSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK61AicSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ABB4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK61AicSCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK61AicSCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ABB8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK61OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK61OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ABBC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK61SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK61SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ABC0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK61SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK61SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ABC4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK61ShuntSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK61ShuntSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ABC8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK62OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK62OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ABCC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK62SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK62SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ABD0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK62SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK62SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ABD4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK63AicSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK63AicSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ABD8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK63AicSCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK63AicSCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ABDC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK63OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK63OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ABE0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK63SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK63SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ABE4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK63SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK63SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ABE8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK63ShuntSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK63ShuntSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ABEC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK64AicSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK64AicSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ABF0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK64AicSCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK64AicSCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ABF4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK64OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK64OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ABF8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK64SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK64SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ABFC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK64SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK64SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC00

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK64ShuntSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK64ShuntSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC04

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK65AicSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK65AicSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC08

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK65AicSCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK65AicSCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC0C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK65OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK65OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC10

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK65SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK65SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC14

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK65SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK65SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC18

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK65ShuntSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK65ShuntSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC1C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK74OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK74OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC20

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK74SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK74SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC24

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK74SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK74SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC28

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK75OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK75OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC2C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK75SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK75SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC30

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK75SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK75SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC34

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK76OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK76OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC38

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK76SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK76SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC3C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK76SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK76SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC40

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK77OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK77OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC44

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK77SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK77SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC48

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK77SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK77SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC4C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK78OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK78OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC50

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK78SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK78SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC54

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK78SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK78SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC58

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_mo_DvUBAT_FWs
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_mo_DvUBAT_FWs"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC5C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_mo_OVErr_VPR6
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_mo_OVErr_VPR6"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC60

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_mo_OVWarn_VPR6
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_mo_OVWarn_VPR6"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC64

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC68

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC6C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_mo_OV_UBAT_MON
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_mo_OV_UBAT_MON"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC70

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_mo_OV_UBRM24_FLEXIN
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_mo_OV_UBRM24_FLEXIN"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC74

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_mo_OV_UBRM24_LOADS
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_mo_OV_UBRM24_LOADS"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC78

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_mo_OV_UBRM24_MON
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_mo_OV_UBRM24_MON"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC7C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_mo_OV_VDD5
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_mo_OV_VDD5"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC80

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_mo_OV_VDD5_IN
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_mo_OV_VDD5_IN"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC84

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_mo_OV_VPR6
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_mo_OV_VPR6"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC88

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_mo_OV_VSS3
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_mo_OV_VSS3"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC8C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_mo_OV_VSS4
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_mo_OV_VSS4"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC90

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_mo_Temp1_HTErr
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_mo_Temp1_HTErr"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC94

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_mo_Temp1_HTWarn
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_mo_Temp1_HTWarn"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC98

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_mo_Temp2_HTErr
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_mo_Temp2_HTErr"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC9C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_mo_Temp2_HTWarn
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_mo_Temp2_HTWarn"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ACA0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ACA4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ACA8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_mo_UV_VDD5
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_mo_UV_VDD5"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ACAC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_mo_UV_VDD5_IN
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_mo_UV_VDD5_IN"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ACB0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_mo_UV_VPR6
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_mo_UV_VPR6"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ACB4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_mo_UV_VSS3
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_mo_UV_VSS3"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ACB8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_mo_UV_VSS4
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_mo_UV_VSS4"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ACBC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA01OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA01OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ACC0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA01OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA01OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ACC4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA01SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA01SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ACC8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA01SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA01SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ACCC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA02OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA02OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ACD0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA02OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA02OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ACD4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA02OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA02OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ACD8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA02SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA02SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ACDC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA02SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA02SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ACE0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA03OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA03OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ACE4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA03OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA03OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ACE8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA03SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA03SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ACEC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA03SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA03SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ACF0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA04OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA04OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ACF4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA04OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA04OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ACF8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA04SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA04SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ACFC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA04SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA04SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD00

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA05OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA05OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD04

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA05OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA05OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD08

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA05OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA05OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD0C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA05SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA05SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD10

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA05SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA05SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD14

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA06OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA06OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD18

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA06OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA06OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD1C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA06OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA06OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD20

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA06SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA06SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD24

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA06SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA06SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD28

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA07OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA07OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD2C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA07OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA07OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD30

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA07SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA07SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD34

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA07SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA07SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD38

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA08OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA08OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD3C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA08OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA08OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD40

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA08SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA08SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD44

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA08SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA08SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD48

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA09OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA09OL"
    ULONG
