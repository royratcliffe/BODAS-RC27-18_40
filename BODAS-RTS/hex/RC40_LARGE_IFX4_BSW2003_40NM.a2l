    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK07Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK07Unintended"
    VAL_BLK
    0x808038FA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK08OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK08OC"
    VAL_BLK
    0x808038FC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK08Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK08Unintended"
    VAL_BLK
    0x808038FE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK09OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK09OC"
    VAL_BLK
    0x80803900
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK09Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK09Unintended"
    VAL_BLK
    0x80803902
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK12OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK12OC"
    VAL_BLK
    0x80803904
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK12Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK12Unintended"
    VAL_BLK
    0x80803906
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK13OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK13OC"
    VAL_BLK
    0x80803908
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK13Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK13Unintended"
    VAL_BLK
    0x8080390A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK14OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK14OC"
    VAL_BLK
    0x8080390C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK14Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK14Unintended"
    VAL_BLK
    0x8080390E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK15OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK15OC"
    VAL_BLK
    0x80803910
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK15Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK15Unintended"
    VAL_BLK
    0x80803912
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK16OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK16OC"
    VAL_BLK
    0x80803914
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK16Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK16Unintended"
    VAL_BLK
    0x80803916
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK17OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK17OC"
    VAL_BLK
    0x80803918
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK17Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK17Unintended"
    VAL_BLK
    0x8080391A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK29OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK29OC"
    VAL_BLK
    0x8080391C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK29Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK29Unintended"
    VAL_BLK
    0x8080391E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK51OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK51OC"
    VAL_BLK
    0x80803920
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK51Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK51Unintended"
    VAL_BLK
    0x80803922
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK73OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK73OC"
    VAL_BLK
    0x80803924
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK73Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK73Unintended"
    VAL_BLK
    0x80803926
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outPo_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outPo"
    VAL_BLK
    0x80803928
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outPoCfg_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outPoCfg"
    VAL_BLK
    0x8080392A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outPoCfgPeriod_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outPoCfgPeriod"
    VAL_BLK
    0x8080392C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outPoCfgPwrLs_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outPoCfgPwrLs"
    VAL_BLK
    0x8080392E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outPoDisable_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outPoDisable"
    VAL_BLK
    0x80803930
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outPoGetCurrent_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outPoGetCurrent"
    VAL_BLK
    0x80803932
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outPoGetStatus_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outPoGetStatus"
    VAL_BLK
    0x80803934
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outPoResetError_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outPoResetError"
    VAL_BLK
    0x80803936
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outPoc_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outPoc"
    VAL_BLK
    0x80803938
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outPocCfg_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outPocCfg"
    VAL_BLK
    0x8080393A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outPocCfgDither_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outPocCfgDither"
    VAL_BLK
    0x8080393C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outPocCfgPI_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outPocCfgPI"
    VAL_BLK
    0x8080393E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outPod_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outPod"
    VAL_BLK
    0x80803940
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outPodCfg_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outPodCfg"
    VAL_BLK
    0x80803942
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outPodCfgPeriod_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outPodCfgPeriod"
    VAL_BLK
    0x80803944
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_rsmFfiApiCallErr_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_rsmFfiApiCallErr"
    VAL_BLK
    0x80803946
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safout_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safout"
    VAL_BLK
    0x80803948
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutCfg_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutCfg"
    VAL_BLK
    0x8080394A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl1_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl1"
    VAL_BLK
    0x8080394C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl10_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl10"
    VAL_BLK
    0x8080394E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl10Dev_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl10Dev"
    VAL_BLK
    0x80803950
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl10OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl10OR"
    VAL_BLK
    0x80803952
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl11_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl11"
    VAL_BLK
    0x80803954
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl11Dev_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl11Dev"
    VAL_BLK
    0x80803956
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl11OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl11OR"
    VAL_BLK
    0x80803958
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl12_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl12"
    VAL_BLK
    0x8080395A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl12Dev_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl12Dev"
    VAL_BLK
    0x8080395C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl12OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl12OR"
    VAL_BLK
    0x8080395E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl13_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl13"
    VAL_BLK
    0x80803960
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl13Dev_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl13Dev"
    VAL_BLK
    0x80803962
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl13OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl13OR"
    VAL_BLK
    0x80803964
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl14_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl14"
    VAL_BLK
    0x80803966
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl14Dev_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl14Dev"
    VAL_BLK
    0x80803968
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl14OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl14OR"
    VAL_BLK
    0x8080396A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl15_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl15"
    VAL_BLK
    0x8080396C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl15Dev_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl15Dev"
    VAL_BLK
    0x8080396E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl15OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl15OR"
    VAL_BLK
    0x80803970
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl16_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl16"
    VAL_BLK
    0x80803972
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl16Dev_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl16Dev"
    VAL_BLK
    0x80803974
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl16OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl16OR"
    VAL_BLK
    0x80803976
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl17_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl17"
    VAL_BLK
    0x80803978
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl17Dev_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl17Dev"
    VAL_BLK
    0x8080397A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl17OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl17OR"
    VAL_BLK
    0x8080397C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl18_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl18"
    VAL_BLK
    0x8080397E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl18Dev_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl18Dev"
    VAL_BLK
    0x80803980
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl18OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl18OR"
    VAL_BLK
    0x80803982
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl1Dev_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl1Dev"
    VAL_BLK
    0x80803984
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl1OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl1OR"
    VAL_BLK
    0x80803986
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl2_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl2"
    VAL_BLK
    0x80803988
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl2Dev_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl2Dev"
    VAL_BLK
    0x8080398A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl2OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl2OR"
    VAL_BLK
    0x8080398C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl3_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl3"
    VAL_BLK
    0x8080398E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl3Dev_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl3Dev"
    VAL_BLK
    0x80803990
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl3OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl3OR"
    VAL_BLK
    0x80803992
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl4_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl4"
    VAL_BLK
    0x80803994
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl4Dev_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl4Dev"
    VAL_BLK
    0x80803996
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl4OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl4OR"
    VAL_BLK
    0x80803998
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl5_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl5"
    VAL_BLK
    0x8080399A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl5Dev_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl5Dev"
    VAL_BLK
    0x8080399C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl5OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl5OR"
    VAL_BLK
    0x8080399E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl6_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl6"
    VAL_BLK
    0x808039A0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl6Dev_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl6Dev"
    VAL_BLK
    0x808039A2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl6OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl6OR"
    VAL_BLK
    0x808039A4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl7_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl7"
    VAL_BLK
    0x808039A6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl7Dev_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl7Dev"
    VAL_BLK
    0x808039A8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl7OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl7OR"
    VAL_BLK
    0x808039AA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl8_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl8"
    VAL_BLK
    0x808039AC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl8Dev_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl8Dev"
    VAL_BLK
    0x808039AE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl8OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl8OR"
    VAL_BLK
    0x808039B0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl9_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl9"
    VAL_BLK
    0x808039B2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl9Dev_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl9Dev"
    VAL_BLK
    0x808039B4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl9OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl9OR"
    VAL_BLK
    0x808039B6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutDevError_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutDevError"
    VAL_BLK
    0x808039B8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutGetStatus_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutGetStatus"
    VAL_BLK
    0x808039BA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutIgnoreError_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutIgnoreError"
    VAL_BLK
    0x808039BC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutResetError_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutResetError"
    VAL_BLK
    0x808039BE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutUnlock_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutUnlock"
    VAL_BLK
    0x808039C0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safout_cfgDiag_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safout_cfgDiag"
    VAL_BLK
    0x808039C2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_secAccessDenied_RC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_secAccessDenied_RC"
    VAL_BLK
    0x808039C4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_secAccessDenied_WDBI_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_secAccessDenied_WDBI"
    VAL_BLK
    0x808039C6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_secEvalRespKey_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_secEvalRespKey"
    VAL_BLK
    0x808039C8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_secFlashingFailure_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_secFlashingFailure"
    VAL_BLK
    0x808039CA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_secGetLevel_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_secGetLevel"
    VAL_BLK
    0x808039CC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_secGetRnd_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_secGetRnd"
    VAL_BLK
    0x808039CE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_secGetSeed_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_secGetSeed"
    VAL_BLK
    0x808039D0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_secInvalidPassword_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_secInvalidPassword"
    VAL_BLK
    0x808039D2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_secIsRequestAllowed_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_secIsRequestAllowed"
    VAL_BLK
    0x808039D4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_secResetLevel_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_secResetLevel"
    VAL_BLK
    0x808039D6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_secSaveSecret_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_secSaveSecret"
    VAL_BLK
    0x808039D8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_secSetLevel_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_secSetLevel"
    VAL_BLK
    0x808039DA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_sysAit_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_sysAit"
    VAL_BLK
    0x808039DC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_sysAiv_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_sysAiv"
    VAL_BLK
    0x808039DE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_sysDi_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_sysDi"
    VAL_BLK
    0x808039E0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_sysDo_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_sysDo"
    VAL_BLK
    0x808039E2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_sysGetVss_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_sysGetVss"
    VAL_BLK
    0x808039E4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_sysInit_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_sysInit"
    VAL_BLK
    0x808039E6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_sysOperHrIntegrityErr_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_sysOperHrIntegrityErr"
    VAL_BLK
    0x808039E8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_sysOperHrsSaturated_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_sysOperHrsSaturated"
    VAL_BLK
    0x808039EA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_sysSetVss_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_sysSetVss"
    VAL_BLK
    0x808039EC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_sys_coreload_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_sys_coreload"
    VAL_BLK
    0x808039EE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_sys_taskload_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_sys_taskload"
    VAL_BLK
    0x808039F0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_OV_VSS1_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_OV_VSS1"
    VAL_BLK
    0x808039F2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_OV_VSS2_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_OV_VSS2"
    VAL_BLK
    0x808039F4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_UV_VSS1_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_UV_VSS1"
    VAL_BLK
    0x808039F6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_UV_VSS2_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_UV_VSS2"
    VAL_BLK
    0x808039F8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_CANSM_E_BUS_OFF_NETWORK_0_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_CANSM_E_BUS_OFF_NETWORK_0"
    VAL_BLK
    0x808039FA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_CANSM_E_BUS_OFF_NETWORK_1_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_CANSM_E_BUS_OFF_NETWORK_1"
    VAL_BLK
    0x808039FC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_CANSM_E_BUS_OFF_NETWORK_2_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_CANSM_E_BUS_OFF_NETWORK_2"
    VAL_BLK
    0x808039FE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_CANSM_E_BUS_OFF_NETWORK_3_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_CANSM_E_BUS_OFF_NETWORK_3"
    VAL_BLK
    0x80803A00
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_CANTRCV_E_NO_TRCV_CONTROL_0_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_CANTRCV_E_NO_TRCV_CONTROL_0"
    VAL_BLK
    0x80803A02
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_CAN_E_TIMEOUT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_CAN_E_TIMEOUT"
    VAL_BLK
    0x80803A04
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_COMM_E_NET_START_IND_CHANNEL_0_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_COMM_E_NET_START_IND_CHANNEL_0"
    VAL_BLK
    0x80803A06
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_COMM_E_NET_START_IND_CHANNEL_1_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_COMM_E_NET_START_IND_CHANNEL_1"
    VAL_BLK
    0x80803A08
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_COMM_E_NET_START_IND_CHANNEL_2_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_COMM_E_NET_START_IND_CHANNEL_2"
    VAL_BLK
    0x80803A0A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_COMM_E_NET_START_IND_CHANNEL_3_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_COMM_E_NET_START_IND_CHANNEL_3"
    VAL_BLK
    0x80803A0C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_COMM_E_NET_START_IND_CHANNEL_4_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_COMM_E_NET_START_IND_CHANNEL_4"
    VAL_BLK
    0x80803A0E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_COMM_E_NET_START_IND_CHANNEL_5_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_COMM_E_NET_START_IND_CHANNEL_5"
    VAL_BLK
    0x80803A10
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_LIN_E_TIMEOUT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_LIN_E_TIMEOUT"
    VAL_BLK
    0x80803A12
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rba_MultiStackTrace_Threshold_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rba_MultiStackTrace_Threshold"
    VAL_BLK
    0x80803A14
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_ETH_E_ACCESS_0_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_ETH_E_ACCESS_0"
    VAL_BLK
    0x80803A16
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_RBA_IOEXTLIB_KEEPALIVE_DRV_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_RBA_IOEXTLIB_KEEPALIVE_DRV"
    VAL_BLK
    0x80803A18
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_RBA_IOEXTLIB_KEEPALIVE_INI_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_RBA_IOEXTLIB_KEEPALIVE_INI"
    VAL_BLK
    0x80803A1A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rba_MRly_Diag_Stk_Event_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rba_MRly_Diag_Stk_Event"
    VAL_BLK
    0x80803A1C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rba_MemDiagExtd_MemReadSngErr_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rba_MemDiagExtd_MemReadSngErr"
    VAL_BLK
    0x80803A1E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rba_MemDiag_MemReadErr_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rba_MemDiag_MemReadErr"
    VAL_BLK
    0x80803A20
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rba_MemDiag_MemWrErr_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rba_MemDiag_MemWrErr"
    VAL_BLK
    0x80803A22
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rba_SyC_IrrSwOffTrigEngRun_Event_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rba_SyC_IrrSwOffTrigEngRun_Event"
    VAL_BLK
    0x80803A24
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rba_T15_Diag_ComInVld_Event_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rba_T15_Diag_ComInVld_Event"
    VAL_BLK
    0x80803A26
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rba_T15_Diag_ComOff_HwOn_Event_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rba_T15_Diag_ComOff_HwOn_Event"
    VAL_BLK
    0x80803A28
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rba_T15_Diag_ComOn_HwOff_Event_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rba_T15_Diag_ComOn_HwOff_Event"
    VAL_BLK
    0x80803A2A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM0_0_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM0_0"
    VAL_BLK
    0x80803A2C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM0_1_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM0_1"
    VAL_BLK
    0x80803A2E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM0_10_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM0_10"
    VAL_BLK
    0x80803A30
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM0_11_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM0_11"
    VAL_BLK
    0x80803A32
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM0_13_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM0_13"
    VAL_BLK
    0x80803A34
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM0_14_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM0_14"
    VAL_BLK
    0x80803A36
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM0_2_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM0_2"
    VAL_BLK
    0x80803A38
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM0_22_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM0_22"
    VAL_BLK
    0x80803A3A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM0_23_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM0_23"
    VAL_BLK
    0x80803A3C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM0_4_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM0_4"
    VAL_BLK
    0x80803A3E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM0_5_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM0_5"
    VAL_BLK
    0x80803A40
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM0_7_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM0_7"
    VAL_BLK
    0x80803A42
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM0_8_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM0_8"
    VAL_BLK
    0x80803A44
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM10_16_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM10_16"
    VAL_BLK
    0x80803A46
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM10_17_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM10_17"
    VAL_BLK
    0x80803A48
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM10_21_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM10_21"
    VAL_BLK
    0x80803A4A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM11_0_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM11_0"
    VAL_BLK
    0x80803A4C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM11_1_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM11_1"
    VAL_BLK
    0x80803A4E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM11_2_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM11_2"
    VAL_BLK
    0x80803A50
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM11_3_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM11_3"
    VAL_BLK
    0x80803A52
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM11_4_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM11_4"
    VAL_BLK
    0x80803A54
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM11_5_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM11_5"
    VAL_BLK
    0x80803A56
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM11_8_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM11_8"
    VAL_BLK
    0x80803A58
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM11_9_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM11_9"
    VAL_BLK
    0x80803A5A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM1_0_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM1_0"
    VAL_BLK
    0x80803A5C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM1_1_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM1_1"
    VAL_BLK
    0x80803A5E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM1_10_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM1_10"
    VAL_BLK
    0x80803A60
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM1_11_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM1_11"
    VAL_BLK
    0x80803A62
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM1_13_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM1_13"
    VAL_BLK
    0x80803A64
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM1_14_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM1_14"
    VAL_BLK
    0x80803A66
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM1_2_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM1_2"
    VAL_BLK
    0x80803A68
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM1_22_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM1_22"
    VAL_BLK
    0x80803A6A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM1_23_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM1_23"
    VAL_BLK
    0x80803A6C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM1_4_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM1_4"
    VAL_BLK
    0x80803A6E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM1_5_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM1_5"
    VAL_BLK
    0x80803A70
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM1_7_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM1_7"
    VAL_BLK
    0x80803A72
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM1_8_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM1_8"
    VAL_BLK
    0x80803A74
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM21_0_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM21_0"
    VAL_BLK
    0x80803A76
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM21_16_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM21_16"
    VAL_BLK
    0x80803A78
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM21_3_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM21_3"
    VAL_BLK
    0x80803A7A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM2_1_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM2_1"
    VAL_BLK
    0x80803A7C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM2_10_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM2_10"
    VAL_BLK
    0x80803A7E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM2_11_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM2_11"
    VAL_BLK
    0x80803A80
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM2_13_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM2_13"
    VAL_BLK
    0x80803A82
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM2_14_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM2_14"
    VAL_BLK
    0x80803A84
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM2_2_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM2_2"
    VAL_BLK
    0x80803A86
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM2_22_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM2_22"
    VAL_BLK
    0x80803A88
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM2_23_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM2_23"
    VAL_BLK
    0x80803A8A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM2_4_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM2_4"
    VAL_BLK
    0x80803A8C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM2_5_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM2_5"
    VAL_BLK
    0x80803A8E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM2_7_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM2_7"
    VAL_BLK
    0x80803A90
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM2_8_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM2_8"
    VAL_BLK
    0x80803A92
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM3_1_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM3_1"
    VAL_BLK
    0x80803A94
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM3_10_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM3_10"
    VAL_BLK
    0x80803A96
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM3_11_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM3_11"
    VAL_BLK
    0x80803A98
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM3_13_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM3_13"
    VAL_BLK
    0x80803A9A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM3_14_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM3_14"
    VAL_BLK
    0x80803A9C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM3_2_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM3_2"
    VAL_BLK
    0x80803A9E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM3_22_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM3_22"
    VAL_BLK
    0x80803AA0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM3_23_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM3_23"
    VAL_BLK
    0x80803AA2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM3_4_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM3_4"
    VAL_BLK
    0x80803AA4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM3_5_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM3_5"
    VAL_BLK
    0x80803AA6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM3_7_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM3_7"
    VAL_BLK
    0x80803AA8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM3_8_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM3_8"
    VAL_BLK
    0x80803AAA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM6_0_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM6_0"
    VAL_BLK
    0x80803AAC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM6_11_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM6_11"
    VAL_BLK
    0x80803AAE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM6_12_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM6_12"
    VAL_BLK
    0x80803AB0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM6_14_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM6_14"
    VAL_BLK
    0x80803AB2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM6_15_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM6_15"
    VAL_BLK
    0x80803AB4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM6_17_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM6_17"
    VAL_BLK
    0x80803AB6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM6_18_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM6_18"
    VAL_BLK
    0x80803AB8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM6_2_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM6_2"
    VAL_BLK
    0x80803ABA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM6_20_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM6_20"
    VAL_BLK
    0x80803ABC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM6_21_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM6_21"
    VAL_BLK
    0x80803ABE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM6_25_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM6_25"
    VAL_BLK
    0x80803AC0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM6_4_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM6_4"
    VAL_BLK
    0x80803AC2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM6_5_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM6_5"
    VAL_BLK
    0x80803AC4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM6_7_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM6_7"
    VAL_BLK
    0x80803AC6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM6_8_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM6_8"
    VAL_BLK
    0x80803AC8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM7_1_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM7_1"
    VAL_BLK
    0x80803ACA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM7_12_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM7_12"
    VAL_BLK
    0x80803ACC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM7_13_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM7_13"
    VAL_BLK
    0x80803ACE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM7_14_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM7_14"
    VAL_BLK
    0x80803AD0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM7_15_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM7_15"
    VAL_BLK
    0x80803AD2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM7_16_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM7_16"
    VAL_BLK
    0x80803AD4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM7_17_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM7_17"
    VAL_BLK
    0x80803AD6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM7_2_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM7_2"
    VAL_BLK
    0x80803AD8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM7_20_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM7_20"
    VAL_BLK
    0x80803ADA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM7_25_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM7_25"
    VAL_BLK
    0x80803ADC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM7_26_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM7_26"
    VAL_BLK
    0x80803ADE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM7_28_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM7_28"
    VAL_BLK
    0x80803AE0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM7_29_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM7_29"
    VAL_BLK
    0x80803AE2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM7_30_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM7_30"
    VAL_BLK
    0x80803AE4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM7_31_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM7_31"
    VAL_BLK
    0x80803AE6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM8_0_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM8_0"
    VAL_BLK
    0x80803AE8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM8_1_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM8_1"
    VAL_BLK
    0x80803AEA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM8_10_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM8_10"
    VAL_BLK
    0x80803AEC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM8_11_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM8_11"
    VAL_BLK
    0x80803AEE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM8_12_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM8_12"
    VAL_BLK
    0x80803AF0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM8_13_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM8_13"
    VAL_BLK
    0x80803AF2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM8_16_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM8_16"
    VAL_BLK
    0x80803AF4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM8_18_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM8_18"
    VAL_BLK
    0x80803AF6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM8_2_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM8_2"
    VAL_BLK
    0x80803AF8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM8_3_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM8_3"
    VAL_BLK
    0x80803AFA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM8_30_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM8_30"
    VAL_BLK
    0x80803AFC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM8_31_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM8_31"
    VAL_BLK
    0x80803AFE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM8_4_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM8_4"
    VAL_BLK
    0x80803B00
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM9_0_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM9_0"
    VAL_BLK
    0x80803B02
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM9_1_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM9_1"
    VAL_BLK
    0x80803B04
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM9_15_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM9_15"
    VAL_BLK
    0x80803B06
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM9_3_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM9_3"
    VAL_BLK
    0x80803B08
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MoCSOPICO_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MoCSOPICO"
    VAL_BLK
    0x80803B0A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MoFVarPostBldSel_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MoFVarPostBldSel"
    VAL_BLK
    0x80803B0C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MoSysCtrlReIni_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MoSysCtrlReIni"
    VAL_BLK
    0x80803B0E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MoXEMMHwLTMCUFW_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MoXEMMHwLTMCUFW"
    VAL_BLK
    0x80803B10
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MoXEMMHwLTMonBIST_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MoXEMMHwLTMonBIST"
    VAL_BLK
    0x80803B12
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MoXEMMHwLTRegMonTest_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MoXEMMHwLTRegMonTest"
    VAL_BLK
    0x80803B14
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MoXEMMHwLTStbySMUAlvTest_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MoXEMMHwLTStbySMUAlvTest"
    VAL_BLK
    0x80803B16
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MoXEMMHwLTTempSens_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MoXEMMHwLTTempSens"
    VAL_BLK
    0x80803B18
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MoXEMMHwLTUCBCfg_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MoXEMMHwLTUCBCfg"
    VAL_BLK
    0x80803B1A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_OCWDAABEActv_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_OCWDAABEActv"
    VAL_BLK
    0x80803B1C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_OCWDACom_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_OCWDACom"
    VAL_BLK
    0x80803B1E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_OCWDAErrPin_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_OCWDAErrPin"
    VAL_BLK
    0x80803B20
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_SWReset_0_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_SWReset_0"
    VAL_BLK
    0x80803B22
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_SWReset_1_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_SWReset_1"
    VAL_BLK
    0x80803B24
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_SWReset_2_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_SWReset_2"
    VAL_BLK
    0x80803B26
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDebFault1_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDebFault1"
    VAL_BLK
    0x80803B28
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 3 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DSQ_DSMInhibitAlways_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DSQ_DSMInhibitAlways"
    VAL_BLK
    0x80803B2B
    ValA_Wu8
    16.0000000000
    DINH_LimDSQVerb
    0.00
    16.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 3 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DSQ_ErrLmpActrMIL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DSQ_ErrLmpActrMIL"
    VAL_BLK
    0x80803B2E
    ValA_Wu8
    16.0000000000
    DINH_LimDSQVerb
    0.00
    16.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DSQ_ErrLmpActrSVS_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DSQ_ErrLmpActrSVS"
    VAL_BLK
    0x80803B30
    ValA_Wu8
    16.0000000000
    DINH_LimDSQVerb
    0.00
    16.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DSQ_StopLmp_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DSQ_StopLmp"
    VAL_BLK
    0x80803B32
    ValA_Wu8
    16.0000000000
    DINH_LimDSQVerb
    0.00
    16.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DSQ_T15TurnOfDly_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DSQ_T15TurnOfDly"
    VAL_BLK
    0x80803B34
    ValA_Wu8
    16.0000000000
    DINH_LimDSQVerb
    0.00
    16.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DSQ_WrnLmp_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DSQ_WrnLmp"
    VAL_BLK
    0x80803B36
    ValA_Wu8
    16.0000000000
    DINH_LimDSQVerb
    0.00
    16.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_tiUpdObsv_C
    "Paging interval time of FId observer"
    VALUE
    0x80804912
    Val_Wu16
    326.6000
    Time_s
    1.0000
    327.6000

    FORMAT "%8.4"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_xFIDObsv_C
    "Function identifier to scan by FId observer"
    VALUE
    0x80804914
    Val_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DIUMPR_Check_CA
    "Assigned fault checks for IUMPR calculation (variant 1)"
    VAL_BLK
    0x80802334
    ValA_Wu16
    1007.
    DFC_Verb
    0.00
    1007.

    FORMAT "%2.0"
    
    MATRIX_DIM 40 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DIUMPR_ctGen.l500MDInc_C
    "criterias to count general denominator and ignition cycle counter / Number of increments of the internal odometer to reach a interval of 10 km"
    VALUE
    0x80802384
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    READ_ONLY

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DIUMPR_ctGen.l500MD_C
    "criterias to count general denominator and ignition cycle counter / minimal driven distance to release special 500 miles denominator"
    VALUE
    0x80802386
    Val_Wu8
    1260.
    DIUMPR_l10km
    0.00
    1260.

    FORMAT "%5.0"
    READ_ONLY

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DIUMPR_ctGen.pEnvMin_C
    "criterias to count general denominator and ignition cycle counter / maximum elevation (represented by minimum air pressure)"
    VALUE
    0x80802390
    Val_Ws16
    65535.00
    Pres_hPa
    -32768.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DIUMPR_ctGen.rAPPMax_C
    "criterias to count general denominator and ignition cycle counter / maximum accelerator pedal position for idle detection"
    VALUE
    0x80802392
    Val_Ws16
    799.9878
    Prc
    -400.0000
    399.9878

    FORMAT "%8.4"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DIUMPR_ctGen.tEnvMin_C
    "criterias to count general denominator and ignition cycle counter / mimimum ambient temperatur"
    VALUE
    0x80802398
    Val_Ws16
    6553.500
    Temp_Cels
    -3549.940
    3003.560

    FORMAT "%8.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DIUMPR_ctGen.tiActrMin_C
    "criterias to count general denominator and ignition cycle counter / minimum activation time of a component to increment denominator"
    VALUE
    0x8080239A
    Val_Wu8
    25.50
    DIUMPR_ti100ms
    0.00
    25.50

    FORMAT "%5.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DIUMPR_ctGen.tiFuEngOpMin_C
    "criterias to count general denominator and ignition cycle counter / Minimal time for fueled engine firm(operation)"
    VALUE
    0x808023A0
    Val_Wu16
    6553.500
    DIUMPR_ti100ms
    0.00
    6553.500

    FORMAT "%8.3"
    READ_ONLY

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DIUMPR_ctGen.tiIdlMin_C
    "criterias to count general denominator and ignition cycle counter / minimum operation time in idle state"
    VALUE
    0x808023A2
    Val_Wu16
    6553.500
    DIUMPR_ti100ms
    0.00
    6553.500

    FORMAT "%8.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DIUMPR_ctGen.tiIgnMin_C
    "criterias to count general denominator and ignition cycle counter / minimum detection time for ignition cycle counter after engine start"
    VALUE
    0x808023A4
    Val_Wu8
    25.50
    DIUMPR_ti100ms
    0.00
    25.50

    FORMAT "%5.2"
    READ_ONLY

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DIUMPR_ctGen.tiOpMin_C
    "criterias to count general denominator and ignition cycle counter / minimum operation time"
    VALUE
    0x808023A6
    Val_Wu16
    6553.500
    DIUMPR_ti100ms
    0.00
    6553.500

    FORMAT "%8.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DIUMPR_ctGen.tiSigContActv_C
    "criterias to count general denominator and ignition cycle counter / minimum energising time twice required for a component to increment the denominator"
    VALUE
    0x808023A8
    Val_Wu8
    3.000
    DIUMPR_ti100ms
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DIUMPR_ctGen.tiSigContSnglActv_C
    "criterias to count general denominator and ignition cycle counter / minimum continuous energizing time required once for a component to increment the denominator"
    VALUE
    0x808023A9
    Val_Wu8
    25.50
    DIUMPR_ti100ms
    0.00
    25.50

    FORMAT "%5.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DIUMPR_ctGen.tiVehSpdMin_C
    "criterias to count general denominator and ignition cycle counter / minimum operation time about 25 miles per hour"
    VALUE
    0x808023AA
    Val_Wu16
    6553.500
    DIUMPR_ti100ms
    0.00
    6553.500

    FORMAT "%8.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DIUMPR_ctGen.vVehIdlMax_C
    "criterias to count general denominator and ignition cycle counter / maximim vehicle speed for idle detection"
    VALUE
    0x808023AC
    Val_Ws16
    655.3500
    Vel
    -327.6800
    327.6700

    FORMAT "%8.4"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DIUMPR_ctGen.vVehMin_C
    "criterias to count general denominator and ignition cycle counter / minimum vehicle speed"
    VALUE
    0x808023AE
    Val_Ws16
    655.3500
    Vel
    -327.6800
    327.6700

    FORMAT "%8.4"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DIUMPR_ctGen.tiIgnCycMin_C
    "criterias to count general denominator and ignition cycle counter / Minimum TIme limit for increment of Ignition cycle counter"
    VALUE
    0x808023B0
    Val_Wu8
    25.50
    DIUMPR_ti100ms
    0.00
    25.50

    FORMAT "%5.2"
    READ_ONLY

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DIUMPR_FID_CA
    "Assigned function identifier for IUMPR calculation (variant 1)"
    VAL_BLK
    0x808023B2
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 40 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DIUMPR_Group_CA
    "Assigned component groups for IUMPR calculation (variant 1)"
    VAL_BLK
    0x80802402
    ValA_Wu8
    8.
    DIUMPR_J1979_GroupVerb
    0.00
    8.

    FORMAT "%2.0"
    
    MATRIX_DIM 40 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DIUMPR_numSigActv_CA
    "Assigned signal for IUMPR calculation to detect physical activity (variant 1)"
    VAL_BLK
    0x8080242A
    ValA_Wu16
    112.000000000
    Signals_IntSigNumVerb
    0.00
    112.000000000

    FORMAT "%13.9"
    
    MATRIX_DIM 40 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DIUMPR_stSigActv_CA
    "Assigned physical activation detection type for IUMPR calculation (variant 1)"
    VAL_BLK
    0x8080247A
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    
    MATRIX_DIM 40 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DIUMPR_valSigActvMax_CA
    "Assigned upper limits of signal to detect physical activity (variant 1)"
    VAL_BLK
    0x808024A2
    ValA_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    
    MATRIX_DIM 40 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DIUMPR_valSigActvMin_CA
    "Assigned lower limits of signal to detect physical activity (variant 1)"
    VAL_BLK
    0x808024F2
    ValA_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    
    MATRIX_DIM 40 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DPSWATCHINDEX
    "Index of the observed output stage (in case of diagnosis problem)"
    VALUE
    0x80807192
    KwUb
    255.0
    dez
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DrvPrgSwt_numCurrCAN_C
    "Calibration for Value of the driving program that is sent on the CAN"
    VALUE
    0x80807302
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DrvPrgSwt_stEffModReqd_C
    "calibration variable"
    VALUE
    0x80807303
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DrvPrgSwt_st_C
    "Calibration for State of the driving program"
    VALUE
    0x80807304
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_BsPrio.FId_InhibitAlways_C
    "base priority / Base priority for scheduled FId FId_InhibitAlways"
    VALUE
    0x80803B38
    Val_Wu16
    8191.000
    DFC_OneToOne
    0.00
    8191.000

    FORMAT "%8.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_DrvModeMsk.FId_InhibitAlways_C
    "drive mode mask / Drive Mode Mask for scheduled FId FId_InhibitAlways"
    VALUE
    0x80803B4A
    Val_Wu16
    65535.00
    DFC_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_FacPhys.FId_InhibitAlways_C
    "weighting physical priority / Factor for physical Prio for scheduled FId FId_InhibitAlways"
    VALUE
    0x80803B3A
    Val_Wu8
    255.0
    DFC_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_JmpActvPrio.FId_InhibitAlways_C
    "priotity bonus while active / Jump Active Prio for scheduled FId FId_InhibitAlways"
    VALUE
    0x80803B3C
    Val_Wu16
    8191.000
    DFC_OneToOne
    0.00
    8191.000

    FORMAT "%8.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_LimPrio.FId_InhibitAlways_C
    "upper priority limit / Upper priority limit if rate calculation is disabled for scheduled FId FId_InhibitAlways"
    VALUE
    0x80803B3E
    Val_Wu16
    8191.000
    DFC_OneToOne
    0.00
    8191.000

    FORMAT "%8.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_OpModeMsk.FId_InhibitAlways_C
    "operation mode mask / Operation Mode Mask for scheduled FId FId_InhibitAlways"
    VALUE
    0x80803B4C
    Val_Wu16
    65535.00
    DFC_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_RmpIniPrio.FId_InhibitAlways_C
    "initial ramp priority / Ramp init Prio for scheduled FId FId_InhibitAlways"
    VALUE
    0x80803B40
    Val_Wu16
    65535.00
    DFC_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_RmpSlpActv.FId_InhibitAlways_C
    "ramp slope active / Ramp Slope Active for scheduled FId FId_InhibitAlways"
    VALUE
    0x80803B42
    Val_Wu16
    327675.0
    DSCHED_RmpSlp
    0.00
    327675.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_RmpSlpPas.FId_InhibitAlways_C
    "ramp slope passive / Ramp slope passive for scheduled FId FId_InhibitAlways"
    VALUE
    0x80803B44
    Val_Wu16
    327675.0
    DSCHED_RmpSlp
    0.00
    327675.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_RmpUpLim.FId_InhibitAlways_C
    "upper ramp limit / Ramp upper Limit for scheduled FId FId_InhibitAlways"
    VALUE
    0x80803B46
    Val_Wu16
    65535.00
    DFC_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_stMode_C
    "Central disable switch for all scheduled FIDs (disabled if set to 0)"
    VALUE
    0x80803B4E
    Val_Wu8
    255.0
    DINH_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_valDflOpMode_C
    "Default request value for operation mode coordinator during disable state (DSCHED_stMode_C = 0)"
    VALUE
    0x80803B50
    Val_Wu16
    65535.00
    DINH_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_valOfsPrioOpMode_C
    "Jump Priority Operation Mode (additional priority if operation mode is compatible to possible operation modes)"
    VALUE
    0x80803B48
    Val_Wu16
    65535.00
    DINH_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMAppl_nEngLim2_C
    ""
    VALUE
    0x80807248
    Val_Ws16
    32767.50
    EngN
    -16384.00
    16383.50

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMAppl_nEngLim_C
    ""
    VALUE
    0x8080724A
    Val_Ws16
    200.0000
    EngN
    100.0000
    300.0000

    FORMAT "%8.4"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMAppl_tiDelAftRun_C
    ""
    VALUE
    0x8080724C
    Val_Wu16
    327460.0
    Time_ms
    0.00
    327460.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMAppl_tiDelBatt_C
    ""
    VALUE
    0x8080724E
    Val_Wu16
    327460.0
    Time_ms
    0.00
    327460.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMAppl_tiDelBusOff_C
    ""
    VALUE
    0x80807250
    Val_Wu16
    327460.0
    Time_ms
    0.00
    327460.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMAppl_tiDelECUInit_C
    ""
    VALUE
    0x80807252
    Val_Wu16
    327460.0
    Time_ms
    0.00
    327460.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMAppl_tiDelEngStrt_C
    ""
    VALUE
    0x80807254
    Val_Wu16
    327460.0
    Time_ms
    0.00
    327460.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMAppl_uBatt_C
    ""
    VALUE
    0x80807256
    Val_Wu16
    36000.00
    Volt_Batt
    0.00
    36000.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMAUX_dtWUCMin_C
    "minimum temperature raise for warm up cycle detection"
    VALUE
    0x80802542
    Val_Ws16
    6553.500
    TempDiff_Kelv
    -3276.800
    3276.700

    FORMAT "%8.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMAUX_nEngDCSMin_C
    ""
    VALUE
    0x80802544
    Val_Ws16
    32767.50
    EngN
    -16384.00
    16383.50

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMAUX_tWUCMin_C
    "minimum temperature for warm up cycle detection"
    VALUE
    0x80802546
    Val_Ws16
    6553.500
    Temp_Cels
    -3549.940
    3003.560

    FORMAT "%8.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMAUX_vVehDCSMin_C
    ""
    VALUE
    0x80802548
    Val_Ws16
    655.3500
    Vel
    -327.6800
    327.6700

    FORMAT "%8.4"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMAUX_xClearMode_C
    "clear mode for clear trigger"
    VALUE
    0x8080254A
    Val_Wu16
    1007.
    DFC_Verb
    0.00
    1007.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMAUX_xClearTrg_C
    "clear trigger to delete diagnostic information"
    VALUE
    0x8080254C
    Val_Wu8
    255.0
    DFC_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMDur_valEvntQntDist_C
    "increment quantization for travelled distance counter"
    VALUE
    0x8080254E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMDur_valEvntQntTi_C
    "increment quantization for operation time counter"
    VALUE
    0x80802550
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMDur_xEnaGlb_CA
    "Enable conditions for global duration counters"
    VAL_BLK
    0x80802552
    ValA_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    
    MATRIX_DIM 4 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMDur_xRstGlb_CA
    "Reset conditions for global duration counters"
    VAL_BLK
    0x8080255A
    ValA_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    
    MATRIX_DIM 4 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMDur_xSelEvntGlb_CA
    "Counting event selection for global duration counters"
    VAL_BLK
    0x8080255E
    ValA_Wu8
    8.00000000000
    DSMDur_EvntSel_Verb
    0.00
    8.00000000000

    FORMAT "%13.11"
    
    MATRIX_DIM 4 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMRdy_Grp.Misf_CA
    "Fault checks for readiness calculation / Checks for group Misf"
    VAL_BLK
    0x80803B52
    ValA_Wu16
    1007.
    DFC_Verb
    0.00
    1007.

    FORMAT "%2.0"
    
    MATRIX_DIM 50 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMRdy_Grp.FlSys_CA
    "Fault checks for readiness calculation / Checks for group FlSys"
    VAL_BLK
    0x80803BB6
    ValA_Wu16
    1007.
    DFC_Verb
    0.00
    1007.

    FORMAT "%2.0"
    
    MATRIX_DIM 50 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMRdy_Grp.ComprCmpnt_CA
    "Fault checks for readiness calculation / Checks for group ComprCmpnt"
    VAL_BLK
    0x80803C1A
    ValA_Wu16
    1007.
    DFC_Verb
    0.00
    1007.

    FORMAT "%2.0"
    
    MATRIX_DIM 100 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMRdy_Grp.HCCat_CA
    "Fault checks for readiness calculation / Checks for group HCCat"
    VAL_BLK
    0x80803CE2
    ValA_Wu16
    1007.
    DFC_Verb
    0.00
    1007.

    FORMAT "%2.0"
    
    MATRIX_DIM 100 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMRdy_Grp.NOxCat_CA
    "Fault checks for readiness calculation / Checks for group NOxCat"
    VAL_BLK
    0x80803DAA
    ValA_Wu16
    1007.
    DFC_Verb
    0.00
    1007.

    FORMAT "%2.0"
    
    MATRIX_DIM 100 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMRdy_Grp.BP_CA
    "Fault checks for readiness calculation / Checks for group BP"
    VAL_BLK
    0x80803E74
    ValA_Wu16
    1007.
    DFC_Verb
    0.00
    1007.

    FORMAT "%2.0"
    
    MATRIX_DIM 100 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMRdy_Grp.EGSens_CA
    "Fault checks for readiness calculation / Checks for group EGSens"
    VAL_BLK
    0x80803F3E
    ValA_Wu16
    1007.
    DFC_Verb
    0.00
    1007.

    FORMAT "%2.0"
    
    MATRIX_DIM 100 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMRdy_Grp.PMFlt_CA
    "Fault checks for readiness calculation / Checks for group PMFlt"
    VAL_BLK
    0x80804006
    ValA_Wu16
    1007.
    DFC_Verb
    0.00
    1007.

    FORMAT "%2.0"
    
    MATRIX_DIM 100 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMRdy_Grp.EGR_CA
    "Fault checks for readiness calculation / Checks for group EGR"
    VAL_BLK
    0x808040CE
    ValA_Wu16
    1007.
    DFC_Verb
    0.00
    1007.

    FORMAT "%2.0"
    
    MATRIX_DIM 50 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMRdy_X.PID1ForceLowMsk_C
    "DSMRdy calibration masks / Enforced zero bits of PID$01 output"
    VALUE
    0x80802564
    Val_Wu32
    4294967295.00
    DSMRdy_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMRdy_X.PID1ForceHighMsk_C
    "DSMRdy calibration masks / Enforced one bits of PID$01 output"
    VALUE
    0x80802568
    Val_Wu32
    4294967295.00
    DSMRdy_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMRdy_X.PID41ForceLowMsk_C
    "DSMRdy calibration masks / Enforced zero bits of PID$41 output"
    VALUE
    0x8080256C
    Val_Wu32
    4294967295.00
    DSMRdy_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMRdy_X.PID41ForceHighMsk_C
    "DSMRdy calibration masks / Enforced one bits of PID$41 output"
    VALUE
    0x80802570
    Val_Wu32
    4294967295.00
    DSMRdy_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DTR_OBDMID.DTR_Dummy_C
    ""
    VALUE
    0x80802574
    Val_Wu8
    255.0
    DFC_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DTR_Suprt.DTR_Dummy_C
    ""
    VALUE
    0x80802575
    Val_Wu8
    1.00000000000
    DTR_Suprt_Compu
    0.00
    1.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DTR_TID.DTR_Dummy_C
    ""
    VALUE
    0x80802576
    Val_Wu8
    255.0
    DFC_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Eep_ClrWrCounter_CW
    "Codeword to clear write counters"
    VALUE
    0x8080028E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Eep_EnFirstInit_CW
    "Codeword to start a first initialization in EEP"
    VALUE
    0x8080028D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Eep_EnvRamClr_CW
    "Codeword to clear contents of ENVRAM"
    VALUE
    0x8080028C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EngDem_stErr_C
    "calibration parameter for application variable"
    VALUE
    0x80807305
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EROTAN
    "Exhaust Regulation or Type Approval Number"
    VAL_BLK
    0x80807170
    ValA_Wu8
    255.0
    dez
    0.00
    255.0

    FORMAT "%5.1"
    
    MATRIX_DIM 17 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmpMIL_ATS.LimitTypeMsk_C
    "Actuator test ErrLmpMIL_ATS / Tester demand monitoring enable mask for actuators"
    VALUE
    0x808071A4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmpMIL_ATS.CnvNorm_C
    "Actuator test ErrLmpMIL_ATS / Conversion norm used for conversion to/from internal scaling"
    VALUE
    0x808071A5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmpMIL_ATS.LowLim_C
    "Actuator test ErrLmpMIL_ATS / Lower limit for monitoring"
    VALUE
    0x808071A6
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmpMIL_ATS.UpLim_C
    "Actuator test ErrLmpMIL_ATS / Upper limit for monitoring"
    VALUE
    0x808071A8
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmpMIL_ATS.CnvFac_C
    "Actuator test ErrLmpMIL_ATS / Factor used for conversion to/from internal scaling"
    VALUE
    0x808071AC
    Val_Ws32
    4294967295.00
    OneToOne
    -2147483648.00
    2147483647.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmpMIL_ATS.CnvOfs_C
    "Actuator test ErrLmpMIL_ATS / Offset used for conversion to/from internal scaling"
    VALUE
    0x808071B0
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmpMIL_ATS.DfltVal_C
    "Actuator test ErrLmpMIL_ATS / Default value for standbytest"
    VALUE
    0x808071B2
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmpSVS_ATS.LimitTypeMsk_C
    "Actuator test ErrLmpSVS_ATS / Tester demand monitoring enable mask for actuators"
    VALUE
    0x808071B4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmpSVS_ATS.CnvNorm_C
    "Actuator test ErrLmpSVS_ATS / Conversion norm used for conversion to/from internal scaling"
    VALUE
    0x808071B5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmpSVS_ATS.LowLim_C
    "Actuator test ErrLmpSVS_ATS / Lower limit for monitoring"
    VALUE
    0x808071B6
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmpSVS_ATS.UpLim_C
    "Actuator test ErrLmpSVS_ATS / Upper limit for monitoring"
    VALUE
    0x808071B8
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmpSVS_ATS.CnvFac_C
    "Actuator test ErrLmpSVS_ATS / Factor used for conversion to/from internal scaling"
    VALUE
    0x808071BC
    Val_Ws32
    4294967295.00
    OneToOne
    -2147483648.00
    2147483647.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmpSVS_ATS.CnvOfs_C
    "Actuator test ErrLmpSVS_ATS / Offset used for conversion to/from internal scaling"
    VALUE
    0x808071C0
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmpSVS_ATS.DfltVal_C
    "Actuator test ErrLmpSVS_ATS / Default value for standbytest"
    VALUE
    0x808071C2
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmp_MIL.nThres_C
    "Parameter structure for MIL-test / Engine speed for switching off error lamp test"
    VALUE
    0x8080734C
    Val_Ws16
    32767.50
    EngN
    -16384.00
    16383.50

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmp_MIL.tiMax_C
    "Parameter structure for MIL-test / Maximum duration for Error lamp test"
    VALUE
    0x8080734E
    Val_Ws16
    655350.0
    Time_ms
    -327680.0
    327670.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmp_MIL.tiTst_C
    "Parameter structure for MIL-test / Maximum duration for error lamp test after engine speed limit was reached"
    VALUE
    0x80807350
    Val_Ws16
    655350.0
    Time_ms
    -327680.0
    327670.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmp_MIL.tiDel_C
    "Parameter structure for MIL-test / Delay for MIL activation due to error, time for Power Stage tests during MIL off"
    VALUE
    0x80807352
    Val_Ws16
    655350.0
    Time_ms
    -327680.0
    327670.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmp_MIL.tiBln_C
    "Parameter structure for MIL-test / Blink period for status MIL blinking"
    VALUE
    0x80807354
    Val_Ws16
    655350.0
    Time_ms
    -327680.0
    327670.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmp_MIL.stEna_C
    "Parameter structure for MIL-test / Enable or disable illumination"
    VALUE
    0x80807356
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmp_MIL.tiFastBlink_C
    "Parameter structure for MIL-test / Lamp test parameters structure"
    VALUE
    0x80807358
    Val_Ws16
    655350.0
    Time_ms
    -327680.0
    327670.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmp_Rdy.st_C
    "Structure for Error lamp Readiness / Status of the readiness functionality"
    VALUE
    0x8080735A
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmp_Rdy.ti_C
    "Structure for Error lamp Readiness / Maximum limit for the blinking phase during the readiness visualization via MIL"
    VALUE
    0x8080735C
    Val_Ws16
    655350.0
    Time_ms
    -327680.0
    327670.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmp_Rdy.tiBlnOn_C
    "Structure for Error lamp Readiness / Blink on period during the blinking phase"
    VALUE
    0x8080735E
    Val_Ws16
    655350.0
    Time_ms
    -327680.0
    327670.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmp_Rdy.tiBlnOff_C
    "Structure for Error lamp Readiness / Blink Off period during the blinking phase"
    VALUE
    0x80807360
    Val_Ws16
    655350.0
    Time_ms
    -327680.0
    327670.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmp_stMIL_b6_C
    "calibration parameter for application variable"
    VALUE
    0x80807306
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmp_stPsMILDisbl_C
    "status word for activation of the power stage"
    VALUE
    0x80807362
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmp_stPsSVSDisbl_C
    "status word for activation of SVS Lamp"
    VALUE
    0x80807364
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmp_SVS.nThres_C
    "Parameter structure for SVS-test / Engine speed for switching off error lamp test"
    VALUE
    0x80807366
    Val_Ws16
    32767.50
    EngN
    -16384.00
    16383.50

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmp_SVS.tiMax_C
    "Parameter structure for SVS-test / Maximum duration for Error lamp test"
    VALUE
    0x80807368
    Val_Ws16
    655350.0
    Time_ms
    -327680.0
    327670.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmp_SVS.tiTst_C
    "Parameter structure for SVS-test / Maximum duration for error lamp test after engine speed limit was reached"
    VALUE
    0x8080736A
    Val_Ws16
    655350.0
    Time_ms
    -327680.0
    327670.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmp_SVS.tiDel_C
    "Parameter structure for SVS-test / Delay for MIL activation due to error, time for Power Stage tests during MIL off"
    VALUE
    0x8080736C
    Val_Ws16
    655350.0
    Time_ms
    -327680.0
    327670.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmp_SVS.tiBln_C
    "Parameter structure for SVS-test / Blink period for status MIL blinking"
    VALUE
    0x8080736E
    Val_Ws16
    655350.0
    Time_ms
    -327680.0
    327670.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmp_SVS.stEna_C
    "Parameter structure for SVS-test / Enable or disable illumination"
    VALUE
    0x80807370
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmp_SVS.tiFastBlink_C
    "Parameter structure for SVS-test / Lamp test parameters structure"
    VALUE
    0x80807372
    Val_Ws16
    655350.0
    Time_ms
    -327680.0
    327670.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmp_swtSVSEqGlwLmp_C
    "Switch for enabling glow lamp instead of SVS lamp"
    VALUE
    0x80807374
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Etc_MaxReqTO_C
    "Maximum time between 2 engine test requests. Value is applicated on 10ms time base (Value of 500 means 5s), but the smallest possible resolution is 100ms. Active tests will be stopped if this times has run out."
    VALUE
    0x8080727C
    Val_Wu16
    32767.00
    OneToOne
    0.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FanCtl_stHotLmp_C
    "calibration variable"
    VALUE
    0x80807307
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FanCtl_stOk_C
    "Calibration for Status defect-free control of KMTR"
    VALUE
    0x80807308
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Fan_r1Ps_C
    ""
    VALUE
    0x8080730A
    Val_Ws16
    655.3500
    DtyCyc
    -327.6800
    327.6700

    FORMAT "%8.4"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Fan_r2Ps_C
    ""
    VALUE
    0x8080730C
    Val_Ws16
    799.9878
    Prc
    -400.0000
    399.9878

    FORMAT "%8.4"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FlSys_volFlConsDspl_C
    "calibration parameter for application variable"
    VALUE
    0x80807310
    Val_Ws32
    4294967295.00
    FlConsum_ul
    -2147483648.00
    2147483647.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    HESrv_swtScndFlwActv_C
    "Calibration parameter to switch off the second flow within a twin-flow system if this feature was enabled"
    VALUE
    0x808073CE
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    HLSDem_nMaxDspl_C
    "Maximum engine speed limit for display (calibratable value)"
    VALUE
    0x80807314
    Val_Ws16
    32767.50
    EngN
    -16384.00
    16383.50

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    HLSDem_nSetPLo_C
    "calibration variable"
    VALUE
    0x80807316
    Val_Ws16
    32767.50
    EngN
    -16384.00
    16383.50

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    HLSDem_stNMaxWarnDspl_C
    "calibration variable"
    VALUE
    0x80807318
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_nMaxSrv4_C
    "Maximum engine speed for Mode$04 Clear Diagnostic Information"
    VALUE
    0x80807376
    Val_Ws16
    10000.00
    EngN
    0.00
    10000.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID13_C
    "Location of oxigen sensor"
    VALUE
    0x80807388
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID1C_C
    "OBD requirements to which vehicle is designed"
    VALUE
    0x80807389
    Val_Wu8
    42.0000000000
    I15031_PID1CVerb
    1.0000000000
    43.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID1D_C
    "Location of oxygen sensors"
    VALUE
    0x8080738A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID4FA_C
    "External Test Equipment Configuration Information. Maximum value for Equivalence Ratio"
    VALUE
    0x8080738B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID4FB_C
    "External Test Equipment Configuration Information. Maximum value for Oxygen Sensor Voltage"
    VALUE
    0x8080738C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID4FC_C
    "External Test Equipment Configuration Information. Maximum value for Oxygen Sensor Current"
    VALUE
    0x8080738D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID4FD_C
    "External Test Equipment Configuration Information. Maximum value for Intake Manifold Absolute Pressure."
    VALUE
    0x8080738E
    Val_Wu8
    2550.
    OneToTenCarb
    0.00
    2550.

    FORMAT "%5.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID50A_C
    "External Test Equipment Configuration Information. Maximum value for ""Air Flow Rate from Mass Air Flow Sensor"""
    VALUE
    0x8080738F
    Val_Wu8
    2550.
    OneToTenCarb
    0.00
    2550.

    FORMAT "%5.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID5F_C
    "OBD requirements to which vehicle is designed"
    VALUE
    0x80807390
    Val_Wu8
    3.00000000000
    I15031_PID5FVerb
    14.0000000000
    17.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID65A_C
    "Shows which Auxiliary Inputs / Outputs are supported in PID65"
    VALUE
    0x80807391
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID66A_C
    "Shows which Mass Air Flow Sensor data are supported in PID66"
    VALUE
    0x80807392
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID67A_C
    "Shows which Engine Coolant Temperature data are supported in PID67"
    VALUE
    0x80807393
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID68A_C
    "Shows which Intake Air Temperature Sensor data are supported in PID68"
    VALUE
    0x80807394
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID69A_C
    "Shows which Commanded EGR System data are supported in PID69"
    VALUE
    0x80807395
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID6AA_C
    "Shows which Commanded Diesel Intake Air Flow Control and Relative Intake Air Flow Position data are supported in PID6A"
    VALUE
    0x80807396
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID6BA_C
    "Shows which Exhaust Gas Recirculation Temperature data are supported in PID6B"
    VALUE
    0x80807397
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID6CA_C
    "Shows which Commanded Throttle Actuator Control and Relative Throttle Position data are supported in PID6C"
    VALUE
    0x80807398
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID6DA_C
    "Shows which Fuel Pressure Control System data are supported in PID6D"
    VALUE
    0x80807399
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID6EA_C
    "Shows which Injection Pressure Control System data are supported in PID6E"
    VALUE
    0x8080739A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID6FA_C
    "Shows which Turbocharger Compressor Inlet Pressure data are supported in PID6F"
    VALUE
    0x8080739B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID70A_C
    "Shows which Boost Pressure Control data are supported in PID70"
    VALUE
    0x8080739C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID71A_C
    "Shows which Variable Geometry Turbo (VGT) Control data are supported in PID71"
    VALUE
    0x8080739D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID72A_C
    "Shows which Wastegate Control data are supported in PID72"
    VALUE
    0x8080739E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID73A_C
    "Shows which Exhaust Pressure data are supported in PID73"
    VALUE
    0x8080739F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID74A_C
    "Shows which Turbocharger RPM data are supported in PID74"
    VALUE
    0x808073A0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID75A_C
    "Shows which Turbocharger A Temperature data are supported in PID75"
    VALUE
    0x808073A1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID76A_C
    "Shows which Turbocharger B Temperature data are supported in PID76"
    VALUE
    0x808073A2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID77A_C
    "Shows which Charge Air Cooler Temperature (CACT) data are supported in PID77"
    VALUE
    0x808073A3
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID78A_C
    "Shows which Exhaust Gas Temperature (EGT) Bank 1 data are supported in PID78"
    VALUE
    0x808073A4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID79A_C
    "Shows which Exhaust Gas Temperature (EGT) Bank 2 data are supported in PID79"
    VALUE
    0x808073A5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID7AA_C
    "Shows which Particulate Filter (PF) Bank 1 data are supported in PID7A"
    VALUE
    0x808073A6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID7BA_C
    "Shows which Particulate Filter (PF) Bank 2 data are supported in PID7B"
    VALUE
    0x808073A7
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID7CA_C
    "Shows which Particulate Filter (PF) Temperature data are supported in PID7C"
    VALUE
    0x808073A8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID7FA_C
    "Shows which Engine Run Time is supported in PID7F"
    VALUE
    0x808073A9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID81A_C
    "Shows which Engine Run Time for AECD #1 - #5 is supported in PID81"
    VALUE
    0x808073AA
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID82A_C
    "Shows which Engine Run Time for AECD #6 - #10 is supported in PID82"
    VALUE
    0x808073AB
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID83A_C
    "Shows which NOx Sensor data are supported in PID83"
    VALUE
    0x808073AC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID85A_C
    "Shows which NOx Control System data are supported in PID85"
    VALUE
    0x808073AD
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID86A_C
    "Shows which Particulate Matter (PM) Sensor data are supported in PID86"
    VALUE
    0x808073AE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID87A_C
    "Shows which Intake Manifold Absolute Pressure data are supported in PID87"
    VALUE
    0x808073AF
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID89A_C
    "Shows which Engine Run Time for AECD #11 - #15 is supported in PID89"
    VALUE
    0x808073B0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID8AA_C
    "Shows which Engine Run Time for AECD #16 - #20 is supported in PID8A"
    VALUE
    0x808073B1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID8BA_C
    "Shows which Aftertreatment Status is supported in PID8B ByteB."
    VALUE
    0x808073B2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID8CA_C
    "Calibration for O2 Sensor Data support information(Sensor 1, Sensor 2)"
    VALUE
    0x808073B3
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID8FA_C
    "Shows which PM (Particulate Matter) Sensor Output is supported in PID8F"
    VALUE
    0x808073B4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID92A_C
    "Calibration for Fuel System Status support information"
    VALUE
    0x808073B5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID93A_C
    "Calibration for WWH B1 counter support information"
    VALUE
    0x808073B6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID94A_C
    "Calibration for Inducement Counters support information"
    VALUE
    0x808073B7
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID97A_C
    ""
    VALUE
    0x808073B8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID98A_C
    "Shows which exhaust gas temperature for bank 1 data are supported in PID98"
    VALUE
    0x808073B9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID99A_C
    "Calibration for Exhaust Gas Temperature Sensor Data support information"
    VALUE
    0x808073BA
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID9AA_C
    "Shows if HybridEV Vehicle State is supported in PID9A"
    VALUE
    0x808073BB
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID9BA_C
    "Diesel exhaust fluid sensor output"
    VALUE
    0x808073BC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID9CA_C
    "Calibration for O2 Sensor Data support information(Sensor 3, Sensor 4)"
    VALUE
    0x808073BD
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID9FA_C
    "Support of fuel system percentage use"
    VALUE
    0x808073BE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PIDA1A_C
    "Displays the NOx Sensor Corrected Data supported in PIDA1"
    VALUE
    0x808073BF
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PIDA3A_C
    "Evap System Vapor Pressure"
    VALUE
    0x808073C0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PIDA4A_C
    "Transmission Actual Gear"
    VALUE
    0x808073C1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PIDA5A_C
    "calibration parameter to update message of byte A ini PIDA5 for Diesel Exhaust Fluid Dosing"
    VALUE
    0x808073C2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PIDA7A_C
    "Support of NOx Sensor Data"
    VALUE
    0x808073C3
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PIDA8A_C
    "NOx Sensor Corrected"
    VALUE
    0x808073C4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PIDA9A_C
    "Motorcycle InputOutput Status"
    VALUE
    0x808073C5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PIDACA_C
    ""
    VALUE
    0x808073C6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_srv9PIDTable.PID0_C
    ""
    VALUE
    0x80807378
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_srv9PIDTable.PID2_C
    ""
    VALUE
    0x8080737A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_srv9PIDTable.PID4_C
    ""
    VALUE
    0x8080737C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_srv9PIDTable.PID6_C
    ""
    VALUE
    0x8080737E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_srv9PIDTable.PID8_C
    ""
    VALUE
    0x80807380
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_srv9PIDTable.PIDA_C
    ""
    VALUE
    0x80807382
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_srv9PIDTable.PIDB_C
    ""
    VALUE
    0x80807383
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_srv9PIDTable.PIDF_C
    ""
    VALUE
    0x80807387
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_srv9_VT_SupprRecent_C
    ""
    VALUE
    0x808073C8
    Val_Wu8
    1.00000000000
    I15031_srv9_VT_SupprRecent_CalVerb
    0.00
    1.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_stRfrshCal_C
    "Start of support calculation for Service0102"
    VALUE
    0x808073C7
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LLim_stMaxActvLvlECU_C
    "Calibration for demand from Lvl ECU for speed limiting"
    VALUE
    0x80807319
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    medc_datasetid
    "Text with the dataset identification"
    ASCII
    0x808071E4
    ValA_Wu8
    255.0
    defaultAscii
    0.00
    255.0
    NUMBER 99
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCCPU_stLockStepTstActv_CW
    ""
    VALUE
    0x808076F0
    Val_Wu8
    1.000
    dez
    0.00
    1.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCGTM_cntrCMPErrbitHealMax_C
    ""
    VALUE
    0x80807650
    Val_Wu8
    255.0
    dez
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCGTM_cntrDebErrMax_C
    ""
    VALUE
    0x80807651
    Val_Wu8
    255.0
    dez
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCGTM_stChksTstActv_CW
    ""
    VALUE
    0x808076F2
    Val_Wu8
    1.000
    dez
    0.00
    1.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCGTM_stSWResetDem_CW
    ""
    VALUE
    0x80807656
    Val_Wu8
    255.0
    dez
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCGTM_stTestActv_CW
    ""
    VALUE
    0x808076F3
    Val_Wu8
    1.000
    dez
    0.00
    1.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCHwLogicTest_stTestActv_CW
    ""
    VALUE
    0x808076F4
    Val_Wu8
    255.0
    dez
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCHwLogicTest_swtDisblErrReactn_CW
    ""
    VALUE
    0x80807658
    Val_Wu8
    255.0
    dez
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCHwLogicTest_swtDisblFwChk_CA
    ""
    VAL_BLK
    0x8080768C
    ValA_Wu32
    4294967295.00
    OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    
    MATRIX_DIM 5 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCIWDH_stPtlRespTstActv_CW
    ""
    VALUE
    0x808076F5
    Val_Wu8
    1.000
    dez
    0.00
    1.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCMemStrtUp_chkRamTest_C
    ""
    VALUE
    0x808076F6
    Val_Wu8
    255.0
    dez
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCMemStrtUp_chkRomTest_C
    ""
    VALUE
    0x808076F7
    Val_Wu8
    255.0
    dez
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCMem_ctDebErrChkRAM_C
    ""
    VALUE
    0x8080765A
    Val_Wu8
    255.0
    dez
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCMem_ctDebErrChkROM_C
    ""
    VALUE
    0x8080765B
    Val_Wu8
    255.0
    dez
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCMem_ctDebHealChkRAMCpl_C
    ""
    VALUE
    0x808076F8
    Val_Wu8
    255.0
    dez
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCMem_ctDebHealChkRAM_C
    ""
    VALUE
    0x8080765C
    Val_Wu8
    255.0
    dez
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCMem_ctDebHealChkROMCpl_C
    ""
    VALUE
    0x808076F9
    Val_Wu8
    255.0
    dez
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCMem_ctDebHealChkROM_C
    ""
    VALUE
    0x8080765D
    Val_Wu8
    255.0
    dez
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCMem_noMEMChkRstCpl_CW
    ""
    VALUE
    0x808076FA
    Val_Wu8
    255.0
    dez
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCMem_noMEMChkRst_CW
    ""
    VALUE
    0x8080765E
    Val_Wu8
    255.0
    dez
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCMem_numRamChk_C
    ""
    VALUE
    0x808076D0
    Val_Wu16
    65535.00
    dez
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCMem_numRomChk_CA
    ""
    VAL_BLK
    0x808076D2
    ValA_Wu16
    65535.00
    dez
    0.00
    65535.00

    FORMAT "%8.2"
    
    MATRIX_DIM 4 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCMem_RamTst_CW
    ""
    VALUE
    0x808076FB
    Val_Wu8
    255.0
    dez
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCMem_RomTst_CW
    ""
    VALUE
    0x808076FC
    Val_Wu8
    255.0
    dez
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCMem_stSwtAutRamChkConf_C
    ""
    VALUE
    0x8080765F
    Val_Wu8
    255.0
    dez
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCMem_stSwtAutRomChkConf_C
    ""
    VALUE
    0x80807660
    Val_Wu8
    255.0
    dez
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCPFC_stPtlRespTestActv_CW
    ""
    VALUE
    0x808076FE
    Val_Wu8
    255.0
    dez
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCSCC_cntrDebMax_C
    ""
    VALUE
    0x80807662
    Val_Wu8
    255.0
    dez
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCSCC_stSCCTstActv_CW
    ""
    VALUE
    0x80807706
    Val_Wu16
    65535.00
    dez
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCSCC_swtDisblEmmChk_CA
    ""
    VAL_BLK
    0x808076A0
    ValA_Wu32
    4294967295.00
    OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    
    MATRIX_DIM 12 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCSCC_swtLfastWrkarndActv_CW
    ""
    VALUE
    0x80807663
    Val_Wu8
    255.0
    dez
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCSOP_cntrDebCtrlLinesActvThd_C
    ""
    VALUE
    0x80807700
    Val_Wu8
    255.0
    dez
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCSOP_ctDebSOPTst_C
    "max. no. responses to the UM for rectification of vehicle in shutdown-path test"
    VALUE
    0x808076DA
    Val_Wu16
    65535.00
    dez
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCSOP_ctDebSycDrv_C
    ""
    VALUE
    0x80807664
    Val_Wu8
    255.0
    dez
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCSOP_ctRst_C
    ""
    VALUE
    0x80807665
    Val_Wu8
    255.0
    dez
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCSOP_nEngMaxOVLthDisbl_C
    ""
    VALUE
    0x808076DC
    Val_Ws16
    32767.50
    EngN
    -16384.00
    16383.50

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCSOP_stCANErrReac_CW
    "codeword for activating the error reaction CAN-driver-disabling"
    VALUE
    0x80807666
    Val_Wu8
    255.0
    dez
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCSOP_stCtrlLineErrReactn_C
    ""
    VALUE
    0x80807667
    Val_Wu8
    1.00000000000
    MoCSOP_stCtrlLineErrReactn_C_Compu
    1.00000000000
    2.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCSOP_stErrReactn_CA
    ""
    VAL_BLK
    0x80807668
    ValA_Wu8
    2.00000000000
    MoCSOP_stErrReactn_CA_Compu
    0.00
    2.00000000000

    FORMAT "%13.11"
    
    MATRIX_DIM 16 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCSOP_stMMErrReac_CW
    "code word for activating the fault reaction MM reset"
    VALUE
    0x80807678
    Val_Wu8
    255.0
    dez
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCSOP_stOVErrReactn_C
    ""
    VALUE
    0x80807679
    Val_Wu8
    1.00000000000
    MoCSOP_stOVErrReactn_C_Compu
    1.00000000000
    2.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCSOP_stSWResetDem_CW
    ""
    VALUE
    0x8080767A
    Val_Wu8
    255.0
    dez
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCSOP_stTestActv_CW
    ""
    VALUE
    0x80807701
    Val_Wu8
    1.000
    dez
    0.00
    1.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCSOP_swtAlwysPsTest_C
    ""
    VALUE
    0x8080767B
    Val_Wu8
    1.000
    dez
    0.00
    1.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoFTrqPtd_cntrActvPostBldCfg_C
    ""
    VALUE
    0x8080767C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoFTrqPtd_cntrNegChkPostBldCfg_C
    ""
    VALUE
    0x8080767D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoFTrqPtd_cntrPosChkPostBldCfg_C
    ""
    VALUE
    0x8080767E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoFTrqPtd_cntrRstPostBldSel_C
    ""
    VALUE
    0x8080767F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoFTrqPtd_cntrStabyChkPostBldCfg_C
    ""
    VALUE
    0x80807680
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoFTrqPtd_cntrTestPostBldSel_C
    ""
    VALUE
    0x80807702
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoFTrqPtd_stSwtPbsChk_C
    ""
    VALUE
    0x80807681
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoSysCtrl_ctErrReIniAllowd_C
    ""
    VALUE
    0x80807682
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoSysCtrl_ctReIniAllowd_C
    ""
    VALUE
    0x80807683
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoSysCtrl_ctReIniTstDeb_C
    ""
    VALUE
    0x80807703
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoSysCtrl_ctT15RsngEdgDetnAllwd_C
    ""
    VALUE
    0x80807684
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoSysCtrl_ctT15RsngEdgDetnPlausy_C
    ""
    VALUE
    0x80807685
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoSysCtrl_ctT15RsngEdgTurnOff_C
    ""
    VALUE
    0x80807686
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoSysCtrl_stSwtT15PlausEna_C
    ""
    VALUE
    0x80807687
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoXEMM_nrHwLTErrSimn_C
    ""
    VALUE
    0x80807182
    RB_Val_Wu16
    65535.0000000
    MoXEMM_HwLTErrorSimnCode_VERB
    0.00
    65535.0000000

    FORMAT "%13.7"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoXEMM_nrSmuAlmErrSimn_C
    ""
    VALUE
    0x80807184
    RB_Val_Wu16
    65535.0000000
    MoXEMM_SMUErrorSimnCode_VERB
    0.00
    65535.0000000

    FORMAT "%13.7"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Mo_cwMstSlave_C
    ""
    VALUE
    0x80807688
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Mo_stSwtHyb_C
    ""
    VALUE
    0x80807689
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Mo_swtClrCntrMax_C
    ""
    VALUE
    0x80807704
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Mo_swtCyclCalUpdt_C
    ""
    VALUE
    0x8080768A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Mo_trqIdcMax_C
    ""
    VALUE
    0x808076DE
    Val_Ws16
    3276.600
    md_q0p1
    0.100
    3276.700

    FORMAT "%8.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    NDECJ
    "Engine speed threshold for power stage diagnosis"
    VALUE
    0x8080718C
    KwWU8
    10200.
    EngN_LRes
    0.00
    10200.

    FORMAT "%5.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    NEngInd_nOpt_C
    "calibration parameter for application variable"
    VALUE
    0x8080731A
    Val_Ws16
    32767.50
    EngN
    -16384.00
    16383.50

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    NMHigh_xSNI_C
    ""
    VALUE
    0x8080731C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    OCWDA_ctDebActvErr_C
    ""
    VALUE
    0x80807186
    RB_Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    OCWDA_stErrSimn_C
    ""
    VALUE
    0x80807187
    RB_Val_Wu8
    8.00000000000
    OCWDA_stErrSimn_C_compu_VERB
    0.00
    8.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    OCWDA_swtOffRst_C
    ""
    VALUE
    0x80807188
    RB_Val_Wu8
    1.00000000000
    OCWDA_swtOffRst_C_compu_VERB
    0.00
    1.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Oil_bPresWarn_C
    "calibration parameter for application variable"
    VALUE
    0x8080731D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCR_pDesVal_C
    "desired boost pressure"
    VALUE
    0x808073D0
    Val_Ws16
    65535.00
    Pres_hPa
    -32768.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PFltRgn_stTxtMsg_C
    "calibration variable"
    VALUE
    0x8080731E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PhyMod_moiEng_C
    "moment of inertia"
    VALUE
    0x80807320
    Val_Ws16
    655.3500
    Moment_Inertia
    -327.6800
    327.6700

    FORMAT "%8.4"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PhyMod_trqDynEng_C
    "calibration variable"
    VALUE
    0x80807322
    Val_Ws16
    6553.500
    Trq
    -3276.800
    3276.700

    FORMAT "%8.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PspCtl_stFlPmpAct_C
    "Calibration for Information auxiliar heater was on"
    VALUE
    0x80807324
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    rba_SvbbEtk_DisableProcExec_KWB
    ""
    VAL_BLK
    0xB93E005C
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    
    MATRIX_DIM 5 
    MAX_REFRESH 3 200

/end CHARACTERISTIC

/begin CHARACTERISTIC

    rba_SvbbEtk_ResIdSrvPt_KWB
    ""
    VAL_BLK
    0xB93E0040
    ValA_Wu16
    4.00000000000
    rba_SvbbEtk_SpName
    0.00
    4.00000000000

    FORMAT "%13.11"
    
    MATRIX_DIM 4 
    MAX_REFRESH 3 200

/end CHARACTERISTIC

/begin CHARACTERISTIC

    rba_SvbbEtk_SrvPtEnabled_KWB
    ""
    VAL_BLK
    0xB93E0058
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    
    MATRIX_DIM 4 
    MAX_REFRESH 3 200

/end CHARACTERISTIC

/begin CHARACTERISTIC

    rba_SvbbEtk_SrvPtResId_KWB
    ""
    VAL_BLK
    0xB93E0061
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    
    MATRIX_DIM 5 
    MAX_REFRESH 3 200

/end CHARACTERISTIC

/begin CHARACTERISTIC

    rba_SvbbEtk_TimeOutPost_KWB
    ""
    VAL_BLK
    0xB93E0050
    ValA_Wu16
    500.0000
    rba_Svbb_Time_us
    0.00
    500.0000

    FORMAT "%8.4"
    
    MATRIX_DIM 4 
    MAX_REFRESH 3 200

/end CHARACTERISTIC

/begin CHARACTERISTIC

    rba_SvbbEtk_TimeOutPre_KWB
    ""
    VAL_BLK
    0xB93E0048
    ValA_Wu16
    500.0000
    rba_Svbb_Time_us
    0.00
    500.0000

    FORMAT "%8.4"
    
    MATRIX_DIM 4 
    MAX_REFRESH 3 200

/end CHARACTERISTIC

/begin CHARACTERISTIC

    RBR_HW_INH_MV_C
    ""
    VALUE
    0x8080718A
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SCRCtl_stAcoustic_C
    "Calibration to SCR acoustic warning information"
    VALUE
    0x80807325
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SCRCtl_stDsplStgy_C
    "Applicationlabel for the calibration of the display strategy"
    VALUE
    0x80807326
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SCRCtl_stWarnText_C
    "Calibration to state of SCR warning text"
    VALUE
    0x80807327
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Signals_Mode1Pid_CA
    "Array welches alle konfigurierten PID Nummer für Signals beinhaltet (read-only für GS)."
    VAL_BLK
    0x808073DC
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    
    MATRIX_DIM 207 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Signals_Mode1SigNum_CA
    "Array welches die zu Signals_Mode1Pid_CA gehörenden Signalnummern beinhaltet (read-only für GS)."
    VAL_BLK
    0x808074AC
    ValA_Wu16
    112.000000000
    Signals_IntSigNumVerb
    0.00
    112.000000000

    FORMAT "%13.9"
    
    MATRIX_DIM 207 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SLmpCtl_rOilLvl_C
    "calibration parameter for application variable"
    VALUE
    0x80807328
    Val_Ws16
    799.9878
    Prc
    -400.0000
    399.9878

    FORMAT "%8.4"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SLmpCtl_stOil_C
    "calibration parameter for application variable"
    VALUE
    0x8080732A
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SLmpCtl_volOil_C
    "calibration variable"
    VALUE
    0x8080732C
    Val_Ws16
    65535.00
    volFilgLvl_ml
    -32768.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SSEUI_stDemNoStopCanMeas_C
    "Calibration to test CAN signal MO_Stoppverbot_Anz"
    VALUE
    0x8080732E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SSEUI_stStrtDesCanMeas_C
    "Calibration to test Status of StartStop-start request for CAN version MQB"
    VALUE
    0x8080732F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    StopLmp_ATS.LimitTypeMsk_C
    "Actuator test StopLmp_ATS / Tester demand monitoring enable mask for actuators"
    VALUE
    0x808071C4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    StopLmp_ATS.CnvNorm_C
    "Actuator test StopLmp_ATS / Conversion norm used for conversion to/from internal scaling"
    VALUE
    0x808071C5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    StopLmp_ATS.LowLim_C
    "Actuator test StopLmp_ATS / Lower limit for monitoring"
    VALUE
    0x808071C6
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    StopLmp_ATS.UpLim_C
    "Actuator test StopLmp_ATS / Upper limit for monitoring"
    VALUE
    0x808071C8
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    StopLmp_ATS.CnvFac_C
    "Actuator test StopLmp_ATS / Factor used for conversion to/from internal scaling"
    VALUE
    0x808071CC
    Val_Ws32
    4294967295.00
    OneToOne
    -2147483648.00
    2147483647.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    StopLmp_ATS.CnvOfs_C
    "Actuator test StopLmp_ATS / Offset used for conversion to/from internal scaling"
    VALUE
    0x808071D0
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    StopLmp_ATS.DfltVal_C
    "Actuator test StopLmp_ATS / Default value for standbytest"
    VALUE
    0x808071D2
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    StopLmp_nThres_C
    ""
    VALUE
    0x808070BC
    Val_Ws16
    32767.50
    EngN
    -16384.00
    16383.50

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    StopLmp_stEna_C
    ""
    VALUE
    0x808070BE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    StopLmp_stPsDisbl_C
    ""
    VALUE
    0x808070C0
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    StopLmp_tiBln_C
    ""
    VALUE
    0x808070C2
    Val_Ws16
    327670.0
    Time_ms
    0.00
    327670.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    StopLmp_tiDel_C
    ""
    VALUE
    0x808070C4
    Val_Ws16
    327670.0
    Time_ms
    0.00
    327670.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    StopLmp_tiMax_C
    ""
    VALUE
    0x808070C6
    Val_Ws16
    327670.0
    Time_ms
    0.00
    327670.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    StopLmp_tiTst_C
    ""
    VALUE
    0x808070C8
    Val_Ws16
    327670.0
    Time_ms
    0.00
    327670.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    StrtCtl_stStrtStopDspl_C
    "Calibration for StrtCtl_stStrtStopDspl"
    VALUE
    0x80807330
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    StrtCtl_stT75_C
    "SwsVW"
    VALUE
    0x80807331
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Strt_st_C
    "Calibration to test the Control signal for the starter relay(Strt_st)"
    VALUE
    0x80807332
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    StSys_stStrtDisengaFrm_C
    "calibration variable"
    VALUE
    0x80807333
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    StSys_stStrtRlsFrm_C
    "calibration variable"
    VALUE
    0x80807334
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SWaPmp_tiHtgPmp_C
    "calibration parameter for application variable"
    VALUE
    0x80807336
    Val_Ws16
    65535.00
    TimeEngOn
    -32768.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SwSVW_bBrkStopReqSupp_C
    "calibration parameter for application variable"
    VALUE
    0x80807338
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SwsVW_bRstrtActv_C
    "calibration variable"
    VALUE
    0x80807339
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SwsVW_bStopActv_C
    "calibration variable"
    VALUE
    0x8080733A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SwSVW_bStopReqEnaIdc_C
    "calibration parameter for application variable"
    VALUE
    0x8080733B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SwsVW_bVlvGbxClgPrs_C
    "calibration variable"
    VALUE
    0x8080733C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SwsVW_bVlvGbxClg_C
    "Calibration for bit valve gearbox cooling open"
    VALUE
    0x8080733D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SwSVW_noSetDrvModStrtStopSwt_C
    "Calibration to test SW sharing interface for StartStop switch charisma driveprogram reply"
    VALUE
    0x8080733E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SwsVW_numGearActDspl_C
    "Calibration for actual gear from shiftup-information"
    VALUE
    0x8080733F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SwsVW_numGearDesDspl_C
    "Calibration for desired gear from shiftup-information"
    VALUE
    0x80807340
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SwSVW_stLmpOutStrtStopSwt_C
    "Calibration to test SW sharing interface for desired StartStop switch lamp status"
    VALUE
    0x80807341
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SwSVW_stStopInhIdcCordStrtStop_C
    "Calibration for binary output of stop inhibition reasons from startstop coordinator for external display"
    VALUE
    0x80807342
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SwSVW_stStrtReqIdcCordStrtStop_C
    "Calibration for binary output of start request reasons from startstop coordinator for external display"
    VALUE
    0x80807344
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SwSVW_stStrtStopCharStrtStopSwt_C
    "Calibration to test SW sharing interface for StartStop charisma status"
    VALUE
    0x80807345
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SwsVW_stStrtStopDrv_C
    "Calibration for Driver stop request for CAN"
    VALUE
    0x80807346
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SwsVW_stStrtStopSys_C
    "Calibration for system status for startstop"
    VALUE
    0x80807347
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SwsVW_stVlvHeat_C
    "Calibration for status of valve heating-closing"
    VALUE
    0x80807348
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SwsVW_stWtPmpEng_C
    "calibration parameter for application variable"
    VALUE
    0x80807349
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    test_bypass_rbaBypDrv_u16_C
    ""
    VALUE
    0x808073D2
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    test_bypass_rbaBypDrv_u32_C
    ""
    VALUE
    0x808073D4
    Val_Wu32
    4294967295.00
    OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    test_bypass_rbaBypDrv_u8_C
    ""
    VALUE
    0x808073D8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    THP
    "delay time failure heiling powerstage diagnosis"
    VALUE
    0x80807193
    KwUb
    25.00
    t_q0p1
    0.50
    25.50

    FORMAT "%5.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    TVP
    "delay time failure verification powerstage diagnosis ME(D) 9"
    VALUE
    0x80807194
    KwUb
    25.00
    t_q0p1
    0.50
    25.50

    FORMAT "%5.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    UBCJMN
    "Min. Ubat-threshold for release of the power stage diagnosis"
    VALUE
    0x8080718E
    KwWU16
    15000.00
    Volt_Batt
    0.00
    15000.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    UBCJMX
    "Max. Ubat-threshold f. release of the BSP 752 R-power stage diagnosis"
    VALUE
    0x80807190
    KwWU16
    25500.00
    Volt_Batt
    0.00
    25500.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    WaPmp_stInfoSysExt_C
    "calibration variable"
    VALUE
    0x8080734A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    WrnLmp_ATS.LimitTypeMsk_C
    "Actuator test WrnLmp_ATS / Tester demand monitoring enable mask for actuators"
    VALUE
    0x808071D4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    WrnLmp_ATS.CnvNorm_C
    "Actuator test WrnLmp_ATS / Conversion norm used for conversion to/from internal scaling"
    VALUE
    0x808071D5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    WrnLmp_ATS.LowLim_C
    "Actuator test WrnLmp_ATS / Lower limit for monitoring"
    VALUE
    0x808071D6
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    WrnLmp_ATS.UpLim_C
    "Actuator test WrnLmp_ATS / Upper limit for monitoring"
    VALUE
    0x808071D8
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    WrnLmp_ATS.CnvFac_C
    "Actuator test WrnLmp_ATS / Factor used for conversion to/from internal scaling"
    VALUE
    0x808071DC
    Val_Ws32
    4294967295.00
    OneToOne
    -2147483648.00
    2147483647.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    WrnLmp_ATS.CnvOfs_C
    "Actuator test WrnLmp_ATS / Offset used for conversion to/from internal scaling"
    VALUE
    0x808071E0
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    WrnLmp_ATS.DfltVal_C
    "Actuator test WrnLmp_ATS / Default value for standbytest"
    VALUE
    0x808071E2
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    WrnLmp_nThres_C
    ""
    VALUE
    0x808070CA
    Val_Ws16
    32767.50
    EngN
    -16384.00
    16383.50

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    WrnLmp_stEna_C
    ""
    VALUE
    0x808070CC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    WrnLmp_stPsDisbl_C
    ""
    VALUE
    0x808070CE
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    WrnLmp_tiBln_C
    ""
    VALUE
    0x808070D0
    Val_Ws16
    327670.0
    Time_ms
    0.00
    327670.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    WrnLmp_tiDel_C
    ""
    VALUE
    0x808070D2
    Val_Ws16
    327670.0
    Time_ms
    0.00
    327670.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    WrnLmp_tiMax_C
    ""
    VALUE
    0x808070D4
    Val_Ws16
    327670.0
    Time_ms
    0.00
    327670.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    WrnLmp_tiTst_C
    ""
    VALUE
    0x808070D6
    Val_Ws16
    327670.0
    Time_ms
    0.00
    327670.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC



/***********   Start of merged MEASUREMENT blocks    ***********/


/begin MEASUREMENT

    CanIf_Prv_ControllerState_ast[0].Ctrl_Pdu_mode
    "Can Interface controller State[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600105BC


/end MEASUREMENT




/begin MEASUREMENT

    CanIf_Prv_ControllerState_ast[1].Ctrl_Pdu_mode
    "Can Interface controller State[1]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600105C0


/end MEASUREMENT




/begin MEASUREMENT

    CanIf_Prv_ControllerState_ast[2].Ctrl_Pdu_mode
    "Can Interface controller State[2]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600105C4


/end MEASUREMENT




/begin MEASUREMENT

    CanIf_Prv_ControllerState_ast[3].Ctrl_Pdu_mode
    "Can Interface controller State[3]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600105C8


/end MEASUREMENT




/begin MEASUREMENT

    CanIf_Prv_InitStatus_b
    "Flag to check if CANIF is Initialized(TRUE) or Not Initialized (FALSE)"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    1.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600105CC


/end MEASUREMENT




/begin MEASUREMENT

    CanIf_Prv_TxBufferRam_ast[0].last_index
    "Can Interface Buffer Status[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011E9C


/end MEASUREMENT




/begin MEASUREMENT

    CanIf_Prv_TxBufferRam_ast[1].last_index
    "Can Interface Buffer Status[1]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011E9E


/end MEASUREMENT




/begin MEASUREMENT

    CanIf_Prv_TxBufferRam_ast[2].last_index
    "Can Interface Buffer Status[2]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011EA0


/end MEASUREMENT




/begin MEASUREMENT

    CanIf_Prv_TxBufferRam_ast[3].last_index
    "Can Interface Buffer Status[3]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011EA2


/end MEASUREMENT




/begin MEASUREMENT

    CanIf_Prv_TxBufferRam_ast[4].last_index
    "Can Interface Buffer Status[4]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011EA4


/end MEASUREMENT




/begin MEASUREMENT

    CanIf_Prv_TxBufferRam_ast[5].last_index
    "Can Interface Buffer Status[5]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011EA6


/end MEASUREMENT




/begin MEASUREMENT

    CanIf_Prv_TxBufferRam_ast[6].last_index
    "Can Interface Buffer Status[6]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011EA8


/end MEASUREMENT




/begin MEASUREMENT

    CanIf_Prv_TxBufferRam_ast[7].last_index
    "Can Interface Buffer Status[7]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011EAA


/end MEASUREMENT




/begin MEASUREMENT

    CanIf_Prv_TxBufferRam_ast[8].last_index
    "Can Interface Buffer Status[8]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011EAC


/end MEASUREMENT




/begin MEASUREMENT

    CanIf_Prv_TxBufferRam_ast[9].last_index
    "Can Interface Buffer Status[9]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011EAE


/end MEASUREMENT




/begin MEASUREMENT

    CanIf_Prv_TxBufferRam_ast[10].last_index
    "Can Interface Buffer Status[10]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011EB0


/end MEASUREMENT




/begin MEASUREMENT

    CanIf_Prv_TxBufferRam_ast[11].last_index
    "Can Interface Buffer Status[11]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011EB2


/end MEASUREMENT




/begin MEASUREMENT

    CanIf_Prv_TxBufferRam_ast[12].last_index
    "Can Interface Buffer Status[12]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011EB4


/end MEASUREMENT




/begin MEASUREMENT

    CanIf_Prv_TxBufferRam_ast[13].last_index
    "Can Interface Buffer Status[13]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011EB6


/end MEASUREMENT




/begin MEASUREMENT

    CanIf_Prv_TxBufferRam_ast[0].bufferstatus
    "Can Interface Buffer Status[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011E9D


/end MEASUREMENT




/begin MEASUREMENT

    CanIf_Prv_TxBufferRam_ast[1].bufferstatus
    "Can Interface Buffer Status[1]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011E9F


/end MEASUREMENT




/begin MEASUREMENT

    CanIf_Prv_TxBufferRam_ast[2].bufferstatus
    "Can Interface Buffer Status[2]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011EA1


/end MEASUREMENT




/begin MEASUREMENT

    CanIf_Prv_TxBufferRam_ast[3].bufferstatus
    "Can Interface Buffer Status[3]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011EA3


/end MEASUREMENT




/begin MEASUREMENT

    CanIf_Prv_TxBufferRam_ast[4].bufferstatus
    "Can Interface Buffer Status[4]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011EA5


/end MEASUREMENT




/begin MEASUREMENT

    CanIf_Prv_TxBufferRam_ast[5].bufferstatus
    "Can Interface Buffer Status[5]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011EA7


/end MEASUREMENT




/begin MEASUREMENT

    CanIf_Prv_TxBufferRam_ast[6].bufferstatus
    "Can Interface Buffer Status[6]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011EA9


/end MEASUREMENT




/begin MEASUREMENT

    CanIf_Prv_TxBufferRam_ast[7].bufferstatus
    "Can Interface Buffer Status[7]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011EAB


/end MEASUREMENT




/begin MEASUREMENT

    CanIf_Prv_TxBufferRam_ast[8].bufferstatus
    "Can Interface Buffer Status[8]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011EAD


/end MEASUREMENT




/begin MEASUREMENT

    CanIf_Prv_TxBufferRam_ast[9].bufferstatus
    "Can Interface Buffer Status[9]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011EAF


/end MEASUREMENT




/begin MEASUREMENT

    CanIf_Prv_TxBufferRam_ast[10].bufferstatus
    "Can Interface Buffer Status[10]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011EB1


/end MEASUREMENT




/begin MEASUREMENT

    CanIf_Prv_TxBufferRam_ast[11].bufferstatus
    "Can Interface Buffer Status[11]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011EB3


/end MEASUREMENT




/begin MEASUREMENT

    CanIf_Prv_TxBufferRam_ast[12].bufferstatus
    "Can Interface Buffer Status[12]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011EB5


/end MEASUREMENT




/begin MEASUREMENT

    CanIf_Prv_TxBufferRam_ast[13].bufferstatus
    "Can Interface Buffer Status[13]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011EB7


/end MEASUREMENT




/begin MEASUREMENT

    CanSM_BORMode_au8
    "Variable to SET/RESET the BOR mode"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D145
    MATRIX_DIM 4 


/end MEASUREMENT




/begin MEASUREMENT

    CanSM_BusOffISRPend_ab
    "To Set the BOR ISR Pending Request to True or False"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011F60
    MATRIX_DIM 4 


/end MEASUREMENT




/begin MEASUREMENT

    CanSM_BusOff_Cntr_au8
    "Bus-Off counter for CanSM"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D149
    MATRIX_DIM 4 


/end MEASUREMENT




/begin MEASUREMENT

    CanSM_CurrNw_Mode_en
    "current ComM mode"
    UBYTE
    AUTOSAR_CanSM_CompuMethods_CanSM_NetworkModeStateType_Enum_comp
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011F74
    MATRIX_DIM 4 


/end MEASUREMENT




/begin MEASUREMENT

    CanSM_MutexMode_au8
    "Used to set"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D141
    MATRIX_DIM 4 


/end MEASUREMENT




/begin MEASUREMENT

    CanSM_Network_Init_ab
    "Setting this leads to initialisation of the network"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011F34
    MATRIX_DIM 4 


/end MEASUREMENT




/begin MEASUREMENT

    CanSM_ReqComM_Mode_en
    "stores the requested communication mode"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011F68
    MATRIX_DIM 4 


/end MEASUREMENT




/begin MEASUREMENT

    CanSM_TimerConfig_ast[0].cntTick_u16
    "CanSM timer configuration[0]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011F7C


/end MEASUREMENT




/begin MEASUREMENT

    CanSM_TimerConfig_ast[1].cntTick_u16
    "CanSM timer configuration[1]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011F80


/end MEASUREMENT




/begin MEASUREMENT

    CanSM_TimerConfig_ast[2].cntTick_u16
    "CanSM timer configuration[2]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011F84


/end MEASUREMENT




/begin MEASUREMENT

    CanSM_TimerConfig_ast[3].cntTick_u16
    "CanSM timer configuration[3]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011F88


/end MEASUREMENT




/begin MEASUREMENT

    CanSM_TimerConfig_ast[0].stTimer
    "CanSM timer configuration[0]/"
    UBYTE
    AUTOSAR_CanSM_CompuMethods_CanSM_TimerStateType_Enum_comp
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011F7A


/end MEASUREMENT




/begin MEASUREMENT

    CanSM_TimerConfig_ast[1].stTimer
    "CanSM timer configuration[1]/"
    UBYTE
    AUTOSAR_CanSM_CompuMethods_CanSM_TimerStateType_Enum_comp
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011F7E


/end MEASUREMENT




/begin MEASUREMENT

    CanSM_TimerConfig_ast[2].stTimer
    "CanSM timer configuration[2]/"
    UBYTE
    AUTOSAR_CanSM_CompuMethods_CanSM_TimerStateType_Enum_comp
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011F82


/end MEASUREMENT




/begin MEASUREMENT

    CanSM_TimerConfig_ast[3].stTimer
    "CanSM timer configuration[3]/"
    UBYTE
    AUTOSAR_CanSM_CompuMethods_CanSM_TimerStateType_Enum_comp
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011F86


/end MEASUREMENT




/begin MEASUREMENT

    CanSM_currBOR_State_en
    "Current Bus-Off recovery state for CanSM"
    UBYTE
    AUTOSAR_CanSM_CompuMethods_CanSM_BusOffRecoveryStateType_Enum_comp
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011F70
    MATRIX_DIM 4 


/end MEASUREMENT




/begin MEASUREMENT

    CanTp_MainState
    "MainState of CanTp indicating whether Tp Communication on CanStack is possible."
    UBYTE
    DefaultIdenticalCompu
    1
    100
    0.0
    255.
    FORMAT "%5.1"
    ECU_ADDRESS 0x6000D14D


/end MEASUREMENT




/begin MEASUREMENT

    Com_SigType_u16
    "Measurement variable for Signals of type - uint16,sint16. To refer Individual element in the Buffer array, Fetch Buffer Index from Com_PBcfg.c for each signal."
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000B75E
    MATRIX_DIM 2 


/end MEASUREMENT




/begin MEASUREMENT

    Com_SigType_u32
    "Measurement variable for Signals of type - uint32,sint32. To refer Individual element in the Buffer array, Fetch Buffer Index from Com_PBcfg.c for each signal."
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x60004BA4
    MATRIX_DIM 1 


/end MEASUREMENT




/begin MEASUREMENT

    Com_SigType_u64
    "Measurement variable for Signals of type - uint64,sint64. To refer Individual element in the Buffer array, Fetch Buffer Index from Com_PBcfg.c for each signal."
    A_UINT64
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    9.223372036854776E18
    FORMAT "%5.0"
    ECU_ADDRESS 0x600105D0
    MATRIX_DIM 1 


/end MEASUREMENT




/begin MEASUREMENT

    Com_SigType_u8
    "Measurement variable for Signals of type - uint8,sint8,boolean,uint8_n. To refer Individual element in the Buffer array, Fetch Buffer Index from Com_PBcfg.c for each signal."
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000CA85
    MATRIX_DIM 2 


/end MEASUREMENT




/begin MEASUREMENT

    Com_dComIPdu_C_xRxByte
    "Rx Local Ipdu buffer of IPdu -ComIPdu_C_xRx- as a Measurement parameter"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000CAD9
    MATRIX_DIM 8 


/end MEASUREMENT




/begin MEASUREMENT

    Com_dComIPdu_C_xTxByte
    "Tx Ipdu buffer of IPdu -ComIPdu_C_xTx- as a Measurement parameter"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000CAF0
    MATRIX_DIM 8 


/end MEASUREMENT




/begin MEASUREMENT

    Com_dComIPdu_D_xRxByte
    "Rx Local Ipdu buffer of IPdu -ComIPdu_D_xRx- as a Measurement parameter"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000CAD1
    MATRIX_DIM 8 


/end MEASUREMENT




/begin MEASUREMENT

    Com_dComIPdu_D_xTxByte
    "Tx Ipdu buffer of IPdu -ComIPdu_D_xTx- as a Measurement parameter"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000CAE8
    MATRIX_DIM 8 


/end MEASUREMENT




/begin MEASUREMENT

    Com_dComIPdu_canFd_1_xRxByte
    "Rx Local Ipdu buffer of IPdu -ComIPdu_canFd_1_xRx- as a Measurement parameter"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000CA91
    MATRIX_DIM 64 


/end MEASUREMENT




/begin MEASUREMENT

    Com_dComIPdu_canFd_1_xTxByte
    "Tx Ipdu buffer of IPdu -ComIPdu_canFd_1_xTx- as a Measurement parameter"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000CAF8
    MATRIX_DIM 64 


/end MEASUREMENT




/begin MEASUREMENT

    Com_dNM_TX_FAByte
    "Tx Ipdu buffer of IPdu -NM_TX_FA- as a Measurement parameter"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000CAE1
    MATRIX_DIM 7 


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[0].ChannelState_e
    "ComM Channel structure[0]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011FE8


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[1].ChannelState_e
    "ComM Channel structure[1]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012008


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[2].ChannelState_e
    "ComM Channel structure[2]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012028


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[3].ChannelState_e
    "ComM Channel structure[3]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012048


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[4].ChannelState_e
    "ComM Channel structure[4]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012068


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[5].ChannelState_e
    "ComM Channel structure[5]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012088


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[0].LightTimeoutCtr_u32
    "ComM Channel structure[0]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011FEC


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[1].LightTimeoutCtr_u32
    "ComM Channel structure[1]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001200C


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[2].LightTimeoutCtr_u32
    "ComM Channel structure[2]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001202C


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[3].LightTimeoutCtr_u32
    "ComM Channel structure[3]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001204C


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[4].LightTimeoutCtr_u32
    "ComM Channel structure[4]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001206C


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[5].LightTimeoutCtr_u32
    "ComM Channel structure[5]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001208C


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[0].MinFullComTimeoutCtr_u16
    "ComM Channel structure[0]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011FF0


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[1].MinFullComTimeoutCtr_u16
    "ComM Channel structure[1]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012010


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[2].MinFullComTimeoutCtr_u16
    "ComM Channel structure[2]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012030


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[3].MinFullComTimeoutCtr_u16
    "ComM Channel structure[3]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012050


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[4].MinFullComTimeoutCtr_u16
    "ComM Channel structure[4]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012070


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[5].MinFullComTimeoutCtr_u16
    "ComM Channel structure[5]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012090


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[0].UserRequestCtr_u16
    "ComM Channel structure[0]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011FF2


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[1].UserRequestCtr_u16
    "ComM Channel structure[1]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012012


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[2].UserRequestCtr_u16
    "ComM Channel structure[2]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012032


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[3].UserRequestCtr_u16
    "ComM Channel structure[3]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012052


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[4].UserRequestCtr_u16
    "ComM Channel structure[4]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012072


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[5].UserRequestCtr_u16
    "ComM Channel structure[5]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012092


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[0].ChannelMode_u8
    "ComM Channel structure[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011FF4


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[1].ChannelMode_u8
    "ComM Channel structure[1]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012014


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[2].ChannelMode_u8
    "ComM Channel structure[2]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012034


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[3].ChannelMode_u8
    "ComM Channel structure[3]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012054


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[4].ChannelMode_u8
    "ComM Channel structure[4]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012074


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[5].ChannelMode_u8
    "ComM Channel structure[5]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012094


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[0].BusSmMode_u8
    "ComM Channel structure[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011FF5


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[1].BusSmMode_u8
    "ComM Channel structure[1]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012015


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[2].BusSmMode_u8
    "ComM Channel structure[2]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012035


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[3].BusSmMode_u8
    "ComM Channel structure[3]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012055


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[4].BusSmMode_u8
    "ComM Channel structure[4]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012075


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[5].BusSmMode_u8
    "ComM Channel structure[5]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012095


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[0].PassiveRequestState_u8
    "ComM Channel structure[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011FF6


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[1].PassiveRequestState_u8
    "ComM Channel structure[1]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012016


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[2].PassiveRequestState_u8
    "ComM Channel structure[2]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012036


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[3].PassiveRequestState_u8
    "ComM Channel structure[3]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012056


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[4].PassiveRequestState_u8
    "ComM Channel structure[4]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012076


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[5].PassiveRequestState_u8
    "ComM Channel structure[5]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012096


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[0].PncRequestCtr_u8
    "ComM Channel structure[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011FF7


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[1].PncRequestCtr_u8
    "ComM Channel structure[1]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012017


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[2].PncRequestCtr_u8
    "ComM Channel structure[2]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012037


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[3].PncRequestCtr_u8
    "ComM Channel structure[3]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012057


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[4].PncRequestCtr_u8
    "ComM Channel structure[4]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012077


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[5].PncRequestCtr_u8
    "ComM Channel structure[5]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012097


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[0].InhibitionReqStatus_u8
    "ComM Channel structure[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011FF8


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[1].InhibitionReqStatus_u8
    "ComM Channel structure[1]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012018


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[2].InhibitionReqStatus_u8
    "ComM Channel structure[2]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012038


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[3].InhibitionReqStatus_u8
    "ComM Channel structure[3]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012058


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[4].InhibitionReqStatus_u8
    "ComM Channel structure[4]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012078


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[5].InhibitionReqStatus_u8
    "ComM Channel structure[5]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012098


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[0].NmNetworkRequestStatus_b
    "ComM Channel structure[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011FF9


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[1].NmNetworkRequestStatus_b
    "ComM Channel structure[1]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012019


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[2].NmNetworkRequestStatus_b
    "ComM Channel structure[2]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012039


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[3].NmNetworkRequestStatus_b
    "ComM Channel structure[3]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012059


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[4].NmNetworkRequestStatus_b
    "ComM Channel structure[4]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012079


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[5].NmNetworkRequestStatus_b
    "ComM Channel structure[5]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012099


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[0].DiagnosticRequestState_b
    "ComM Channel structure[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011FFA


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[1].DiagnosticRequestState_b
    "ComM Channel structure[1]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001201A


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[2].DiagnosticRequestState_b
    "ComM Channel structure[2]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001203A


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[3].DiagnosticRequestState_b
    "ComM Channel structure[3]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001205A


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[4].DiagnosticRequestState_b
    "ComM Channel structure[4]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001207A


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[5].DiagnosticRequestState_b
    "ComM Channel structure[5]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001209A


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[0].CommunicationAllowed_b
    "ComM Channel structure[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011FFB


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[1].CommunicationAllowed_b
    "ComM Channel structure[1]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001201B


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[2].CommunicationAllowed_b
    "ComM Channel structure[2]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001203B


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[3].CommunicationAllowed_b
    "ComM Channel structure[3]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001205B


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[4].CommunicationAllowed_b
    "ComM Channel structure[4]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001207B


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[5].CommunicationAllowed_b
    "ComM Channel structure[5]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001209B


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[0].NmBusSleepIndicationStatus_b
    "ComM Channel structure[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011FFC


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[1].NmBusSleepIndicationStatus_b
    "ComM Channel structure[1]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001201C


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[2].NmBusSleepIndicationStatus_b
    "ComM Channel structure[2]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001203C


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[3].NmBusSleepIndicationStatus_b
    "ComM Channel structure[3]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001205C


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[4].NmBusSleepIndicationStatus_b
    "ComM Channel structure[4]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001207C


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[5].NmBusSleepIndicationStatus_b
    "ComM Channel structure[5]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001209C


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[0].NmPrepareBusSleepIndicationStatus_b
    "ComM Channel structure[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011FFD


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[1].NmPrepareBusSleepIndicationStatus_b
    "ComM Channel structure[1]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001201D


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[2].NmPrepareBusSleepIndicationStatus_b
    "ComM Channel structure[2]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001203D


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[3].NmPrepareBusSleepIndicationStatus_b
    "ComM Channel structure[3]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001205D


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[4].NmPrepareBusSleepIndicationStatus_b
    "ComM Channel structure[4]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001207D


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[5].NmPrepareBusSleepIndicationStatus_b
    "ComM Channel structure[5]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001209D


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[0].NmNetworkModeStatus_b
    "ComM Channel structure[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011FFE


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[1].NmNetworkModeStatus_b
    "ComM Channel structure[1]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001201E


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[2].NmNetworkModeStatus_b
    "ComM Channel structure[2]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001203E


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[3].NmNetworkModeStatus_b
    "ComM Channel structure[3]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001205E


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[4].NmNetworkModeStatus_b
    "ComM Channel structure[4]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001207E


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[5].NmNetworkModeStatus_b
    "ComM Channel structure[5]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001209E


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[0].WakeUpInhibitionCtr_u16
    "ComM user structure[0]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120A0


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[1].WakeUpInhibitionCtr_u16
    "ComM user structure[1]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120AA


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[2].WakeUpInhibitionCtr_u16
    "ComM user structure[2]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120B4


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[3].WakeUpInhibitionCtr_u16
    "ComM user structure[3]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120BE


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[4].WakeUpInhibitionCtr_u16
    "ComM user structure[4]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120C8


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[5].WakeUpInhibitionCtr_u16
    "ComM user structure[5]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120D2


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[6].WakeUpInhibitionCtr_u16
    "ComM user structure[6]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120DC


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[0].LimitToNoComCtr_u16
    "ComM user structure[0]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120A2


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[1].LimitToNoComCtr_u16
    "ComM user structure[1]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120AC


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[2].LimitToNoComCtr_u16
    "ComM user structure[2]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120B6


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[3].LimitToNoComCtr_u16
    "ComM user structure[3]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120C0


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[4].LimitToNoComCtr_u16
    "ComM user structure[4]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120CA


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[5].LimitToNoComCtr_u16
    "ComM user structure[5]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120D4


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[6].LimitToNoComCtr_u16
    "ComM user structure[6]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120DE


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[0].RequestedUserMode_t
    "ComM user structure[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120A4


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[1].RequestedUserMode_t
    "ComM user structure[1]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120AE


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[2].RequestedUserMode_t
    "ComM user structure[2]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120B8


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[3].RequestedUserMode_t
    "ComM user structure[3]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120C2


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[4].RequestedUserMode_t
    "ComM user structure[4]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120CC


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[5].RequestedUserMode_t
    "ComM user structure[5]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120D6


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[6].RequestedUserMode_t
    "ComM user structure[6]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120E0


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[0].IndicatedUserMode_t
    "ComM user structure[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120A5


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[1].IndicatedUserMode_t
    "ComM user structure[1]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120AF


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[2].IndicatedUserMode_t
    "ComM user structure[2]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120B9


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[3].IndicatedUserMode_t
    "ComM user structure[3]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120C3


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[4].IndicatedUserMode_t
    "ComM user structure[4]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120CD


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[5].IndicatedUserMode_t
    "ComM user structure[5]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120D7


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[6].IndicatedUserMode_t
    "ComM user structure[6]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120E1


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[0].numChannelsInFullCom_u8
    "ComM user structure[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120A6


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[1].numChannelsInFullCom_u8
    "ComM user structure[1]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120B0


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[2].numChannelsInFullCom_u8
    "ComM user structure[2]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120BA


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[3].numChannelsInFullCom_u8
    "ComM user structure[3]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120C4


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[4].numChannelsInFullCom_u8
    "ComM user structure[4]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120CE


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[5].numChannelsInFullCom_u8
    "ComM user structure[5]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120D8


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[6].numChannelsInFullCom_u8
    "ComM user structure[6]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120E2


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[0].numChannelsInSilentCom_u8
    "ComM user structure[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120A7


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[1].numChannelsInSilentCom_u8
    "ComM user structure[1]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120B1


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[2].numChannelsInSilentCom_u8
    "ComM user structure[2]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120BB


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[3].numChannelsInSilentCom_u8
    "ComM user structure[3]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120C5


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[4].numChannelsInSilentCom_u8
    "ComM user structure[4]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120CF


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[5].numChannelsInSilentCom_u8
    "ComM user structure[5]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120D9


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[6].numChannelsInSilentCom_u8
    "ComM user structure[6]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120E3


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[0].numChannelsInNoCom_u8
    "ComM user structure[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120A8


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[1].numChannelsInNoCom_u8
    "ComM user structure[1]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120B2


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[2].numChannelsInNoCom_u8
    "ComM user structure[2]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120BC


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[3].numChannelsInNoCom_u8
    "ComM user structure[3]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120C6


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[4].numChannelsInNoCom_u8
    "ComM user structure[4]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120D0


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[5].numChannelsInNoCom_u8
    "ComM user structure[5]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120DA


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[6].numChannelsInNoCom_u8
    "ComM user structure[6]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120E4


/end MEASUREMENT




/begin MEASUREMENT

    EthSM_NetState_aen
    "Gives information about states defined internally for EthSM Networks (ETHSM_STATE_OFFLINE - EthSM is initialized in this state, ETHSM_STATE_WAIT_TRCVLINK - ComM requests COMM_FULL_COMMUNICATION in this state, Ctrl and Trcv will be initialized and set to ACTIVE. EthSM waits for transceiver link state (ACTIVE),ETHSM_STATE_WAIT_ONLINE - Transceiver link state is ACTIVE. EthSM waits for IP communication (TcpIP state = ONLINE), ETHSM_STATE_ONLINE - IP communication is availabe ComM state COMM_FULL_COMMUNICATION is reached, ETHSM_STATE_ONHOLD - EthSM lost active transceiver link state, TcpIP state is still online, ETHSM_STATE_WAIT_OFFLINE - ComM requests COMM_NO_COMMUNICATION in this state)"
    UBYTE
    AUTOSAR_EthSM_CompuMethods_EthSM_Enum_NetworkModeStateType
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70006E91
    MATRIX_DIM 1 


/end MEASUREMENT




/begin MEASUREMENT

    LinIf_ChnlVar_as[0].ChannelStateFlag_u8
    "Lin Interface channel status structure[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600121A0


/end MEASUREMENT




/begin MEASUREMENT

    LinIf_ChnlVar_as[0].ChannelStatusFlags_u8
    "Lin Interface channel status structure[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600121A1


/end MEASUREMENT




/begin MEASUREMENT

    LinIf_ChnlVar_as[0].DelayCount_u8
    "Lin Interface channel status structure[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600121A2


/end MEASUREMENT




/begin MEASUREMENT

    LinIf_ChnlVar_as[0].CurrentScheduleTable_u8
    "Lin Interface channel status structure[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600121A3


/end MEASUREMENT




/begin MEASUREMENT

    LinIf_ChnlVar_as[0].CurrentIndex_u8
    "Lin Interface channel status structure[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600121A5


/end MEASUREMENT




/begin MEASUREMENT

    LinIf_ChnlVar_as[0].SavedScheduleTable_u8
    "Lin Interface channel status structure[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600121A6


/end MEASUREMENT




/begin MEASUREMENT

    LinIf_ChnlVar_as[0].SavedIndex_u8
    "Lin Interface channel status structure[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600121A7


/end MEASUREMENT




/begin MEASUREMENT

    LinIf_ChnlVar_as[0].Temp_SpoFrmCount_u8
    "Lin Interface channel status structure[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600121A8


/end MEASUREMENT




/begin MEASUREMENT

    LinIf_ChnlVar_as[0].SpoETIndex_u8
    "Lin Interface channel status structure[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600121A9


/end MEASUREMENT




/begin MEASUREMENT

    LinIf_ChnlVar_as[0].Wakeup_u8
    "Lin Interface channel status structure[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600121AC


/end MEASUREMENT




/begin MEASUREMENT

    LinIf_ChnlVar_as[0].TransmitSRF_u8
    "Lin Interface channel status structure[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600121AF


/end MEASUREMENT




/begin MEASUREMENT

    LinIf_ChnlVar_as[0].SlpGetStatus_u8
    "Lin Interface channel status structure[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600121B0


/end MEASUREMENT




/begin MEASUREMENT

    LinIf_ChnlVar_as[0].NewScheduleTable_u8
    "Lin Interface channel status structure[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600121A4


/end MEASUREMENT




/begin MEASUREMENT

    LinIf_ChnlVar_as[0].GotoSleepCtr
    "Lin Interface channel status structure[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600121AB


/end MEASUREMENT




/begin MEASUREMENT

    LinIf_Status_u8
    "Lin Interface status variable"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012198


/end MEASUREMENT




/begin MEASUREMENT

    LinSM_ModeRepeatReq_Max_u8
    "Maximum Tries for Same Mode Request Possible in LinSM"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000CE9A


/end MEASUREMENT




/begin MEASUREMENT

    LinSM_RamVar_ast[0].ChnlState
    "LinSM type variable[0]/"
    UBYTE
    AUTOSAR_LinSM_CompuMethods_LinSM_CompuMethod_OperationalMode
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600121F0


/end MEASUREMENT




/begin MEASUREMENT

    LinSM_RamVar_ast[0].TimeOutCounter
    "LinSM type variable[0]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x600121F4


/end MEASUREMENT




/begin MEASUREMENT

    LinSM_RamVar_ast[0].TimeoutFlag
    "LinSM type variable[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600121F8


/end MEASUREMENT




/begin MEASUREMENT

    LinSM_RamVar_ast[0].StoredSchdTab
    "LinSM type variable[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600121F9


/end MEASUREMENT




/begin MEASUREMENT

    LinSM_RamVar_ast[0].LinSm_SchdReq_E_NOT_OK
    "LinSM type variable[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600121FA


/end MEASUREMENT




/begin MEASUREMENT

    LinSM_RamVar_ast[0].LinSm_Conf_Status
    "LinSM type variable[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600121FB


/end MEASUREMENT




/begin MEASUREMENT

    LinSM_RamVar_ast[0].LinSm_Request_Status
    "LinSM type variable[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600121FC


/end MEASUREMENT




/begin MEASUREMENT

    LinSM_RamVar_ast[0].LinSm_Sleep_Status
    "LinSM type variable[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600121FD


/end MEASUREMENT




/begin MEASUREMENT

    LinSM_RamVar_ast[0].LinSmModReqRepMax
    "LinSM type variable[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600121FE


/end MEASUREMENT




/begin MEASUREMENT

    LinSM_State_en
    "State variable of LINSM"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012200


/end MEASUREMENT




/begin MEASUREMENT

    PduR_State
    "State information of Pdur module"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012214


/end MEASUREMENT




/begin MEASUREMENT

    TcpIp_EthIfCtrlSt_aen
    "Gives Information about TCP/IP stack state for a specific EthIf controller (TCPIP_STATE_ONLINE i.e. communication via at least one IP address is possible, TCPIP_STATE_ONHOLD i.e. no communication is currently possible (e.g. link down), TCPIP_STATE_OFFLINE i.e. no communication is possible, TCPIP_STATE_STARTUP i.e. IP address assignment in progress or ready for manual start communication is currently not possible, TCPIP_STATE_SHUTDOWN i.e. release of resources using the EthIf controller, release of IP address assignment.)"
    UBYTE
    AUTOSAR_TcpIp_CompuMethods_TcpIp_Enum_StateType
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70006D9E
    MATRIX_DIM 1 


/end MEASUREMENT




/begin MEASUREMENT

    rba_CanMcan_DriverState_MP
    "Flag to check if CAN driver is Initialized(CAN_READY(TRUE)) or Not Initialized (CAN_UNINIT(FALSE))"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    1.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70006C54


/end MEASUREMENT




/begin MEASUREMENT

    rba_CanMcan_MsgStatus_MP
    "This variable value describes the CAN message buffer status. The value is 1 if the message transmission is initiated and is reset(value 0) after the confirmation is given for the same."
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D10E
    MATRIX_DIM 14 


/end MEASUREMENT




/begin MEASUREMENT

    rba_IoDiagHlfBr_dataDiagInfo_MP
    "Array of 32-bit diagnosis information"
    ULONG
    DefaultIdenticalCompu
    1
    100
    0.0
    4.294967295E9
    ECU_ADDRESS 0x6000B0F8


/end MEASUREMENT




/begin MEASUREMENT

    rba_IoDiagHlfBr_idDbgSignal
    "Signal Id of half-bridge signal that needs to be debugged"
    UWORD
    DefaultIdenticalCompu
    1
    100
    0.0
    65535.0
    ECU_ADDRESS 0x700059C4


/end MEASUREMENT




/begin MEASUREMENT

    rba_IoDiagHlfBr_stDiagCtrl_MP
    "The status of diagnosis control"
    UBYTE
    DefaultIdenticalCompu
    1
    100
    0.0
    255.0
    ECU_ADDRESS 0x6000D17D


/end MEASUREMENT




/begin MEASUREMENT

    rba_IoDiagHlfBr_stDiagDi_MP
    "The status of diagnosis disabled"
    UBYTE
    AUTOSAR_Platform_CompuMethods_boolean
    1
    100
    0.0
    255.0
    ECU_ADDRESS 0x6000D17E


/end MEASUREMENT




/begin MEASUREMENT

    rba_IoDiagHlfBr_stSwtOffDiag_MP
    "The status of switch-off mode diagnosis"
    UBYTE
    RB_RBA_rba_IoDiagHlfBr_CompuMethods_rba_IoDiagHlfBr_SwtOffDiagSts_tu8_CompuMethod
    1
    100
    0.0
    5.
    FORMAT "%9.0"
    ECU_ADDRESS 0x6000D17C


/end MEASUREMENT




/begin MEASUREMENT

    rba_IoDiagHlfBr_stTstPlsReq_MP
    "The status of test pulse request"
    UBYTE
    DefaultIdenticalCompu
    1
    100
    0.0
    255.0
    ECU_ADDRESS 0x6000D17B


/end MEASUREMENT




/begin MEASUREMENT

    rba_IoDiagHlfBr_xReasSwtOffDiagAbort_MP
    "The reason for switch-off mode diagnosis aborted"
    UBYTE
    DefaultIdenticalCompu
    1
    100
    0.0
    255.0
    ECU_ADDRESS 0x6000D17A


/end MEASUREMENT




/begin MEASUREMENT

    rba_MRly_Ctrl_State_MP
    "Current control state of Main Relay"
    UBYTE
    RB_RBA_rba_MRly_BswModuleDescriptions_rba_MRly_Ctrl_States_CompuMethod
    1
    100
    0.0
    1.
    FORMAT "%8.3"
    ECU_ADDRESS 0x700303F8

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Current control state of Main Relay\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_MultiStackTrace_ThresholdTable
    "Threshold table for Configured Limits"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x700059C6
    MATRIX_DIM 6 


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_CoreLoad[0].current
    "Core load Os measurement for each core[0]/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x700016AC


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_CoreLoad[1].current
    "Core load Os measurement for each core[1]/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x700016B2


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_CoreLoad[2].current
    "Core load Os measurement for each core[2]/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x700016B8


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_CoreLoad[3].current
    "Core load Os measurement for each core[3]/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x700016BE


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_CoreLoad[0].curCycleMax
    "Core load Os measurement for each core[0]/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x700016AE


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_CoreLoad[1].curCycleMax
    "Core load Os measurement for each core[1]/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x700016B4


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_CoreLoad[2].curCycleMax
    "Core load Os measurement for each core[2]/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x700016BA


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_CoreLoad[3].curCycleMax
    "Core load Os measurement for each core[3]/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x700016C0


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_CoreLoad[0].lifeTimeMax
    "Core load Os measurement for each core[0]/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x700016B0


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_CoreLoad[1].lifeTimeMax
    "Core load Os measurement for each core[1]/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x700016B6


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_CoreLoad[2].lifeTimeMax
    "Core load Os measurement for each core[2]/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x700016BC


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_CoreLoad[3].lifeTimeMax
    "Core load Os measurement for each core[3]/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x700016C2


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_1000ms_Task.RespTimeCurrent
    "Task response time monitoring for OS_1000ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x60013170


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_1000ms_Task.RespTimeCycleMax
    "Task response time monitoring for OS_1000ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x60013174


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_1000ms_Task.RespTimeLifetimeMax
    "Task response time monitoring for OS_1000ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x60013178


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_1000ms_Task.CETCurrent
    "Task response time monitoring for OS_1000ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_CET_T1_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x6001317C


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_1000ms_Task.CETCycleMax
    "Task response time monitoring for OS_1000ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_CET_T1_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x60013180


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_1000ms_Task.CETCurrentLoad
    "Task response time monitoring for OS_1000ms_Task/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_T1_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x60013184


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_1000ms_Task.CETCurrentLoadMax
    "Task response time monitoring for OS_1000ms_Task/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_T1_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x60013186


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_100ms_Task.RespTimeCurrent
    "Task response time monitoring for OS_100ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x60013158


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_100ms_Task.RespTimeCycleMax
    "Task response time monitoring for OS_100ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x6001315C


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_100ms_Task.RespTimeLifetimeMax
    "Task response time monitoring for OS_100ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x60013160


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_100ms_Task.CETCurrent
    "Task response time monitoring for OS_100ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_CET_T1_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x60013164


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_100ms_Task.CETCycleMax
    "Task response time monitoring for OS_100ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_CET_T1_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x60013168


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_100ms_Task.CETCurrentLoad
    "Task response time monitoring for OS_100ms_Task/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_T1_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x6001316C


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_100ms_Task.CETCurrentLoadMax
    "Task response time monitoring for OS_100ms_Task/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_T1_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x6001316E


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_10ms_Task.RespTimeCurrent
    "Task response time monitoring for OS_10ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x60013140


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_10ms_Task.RespTimeCycleMax
    "Task response time monitoring for OS_10ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x60013144


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_10ms_Task.RespTimeLifetimeMax
    "Task response time monitoring for OS_10ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x60013148


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_10ms_Task.CETCurrent
    "Task response time monitoring for OS_10ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_CET_T1_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x6001314C


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_10ms_Task.CETCycleMax
    "Task response time monitoring for OS_10ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_CET_T1_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x60013150


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_10ms_Task.CETCurrentLoad
    "Task response time monitoring for OS_10ms_Task/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_T1_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x60013154


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_10ms_Task.CETCurrentLoadMax
    "Task response time monitoring for OS_10ms_Task/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_T1_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x60013156


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_1ms_Task.RespTimeCurrent
    "Task response time monitoring for OS_1ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x60013128


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_1ms_Task.RespTimeCycleMax
    "Task response time monitoring for OS_1ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x6001312C


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_1ms_Task.RespTimeLifetimeMax
    "Task response time monitoring for OS_1ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x60013130


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_1ms_Task.CETCurrent
    "Task response time monitoring for OS_1ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_CET_T1_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x60013134


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_1ms_Task.CETCycleMax
    "Task response time monitoring for OS_1ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_CET_T1_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x60013138


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_1ms_Task.CETCurrentLoad
    "Task response time monitoring for OS_1ms_Task/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_T1_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x6001313C


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_1ms_Task.CETCurrentLoadMax
    "Task response time monitoring for OS_1ms_Task/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_T1_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x6001313E


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_200ms_Task.RespTimeCurrent
    "Task response time monitoring for OS_200ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x60013110


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_200ms_Task.RespTimeCycleMax
    "Task response time monitoring for OS_200ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x60013114


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_200ms_Task.RespTimeLifetimeMax
    "Task response time monitoring for OS_200ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x60013118


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_200ms_Task.CETCurrent
    "Task response time monitoring for OS_200ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_CET_T1_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x6001311C


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_200ms_Task.CETCycleMax
    "Task response time monitoring for OS_200ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_CET_T1_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x60013120


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_200ms_Task.CETCurrentLoad
    "Task response time monitoring for OS_200ms_Task/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_T1_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x60013124


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_200ms_Task.CETCurrentLoadMax
    "Task response time monitoring for OS_200ms_Task/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_T1_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x60013126


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_20ms_Task.RespTimeCurrent
    "Task response time monitoring for OS_20ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x600130F8


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_20ms_Task.RespTimeCycleMax
    "Task response time monitoring for OS_20ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x600130FC


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_20ms_Task.RespTimeLifetimeMax
    "Task response time monitoring for OS_20ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x60013100


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_20ms_Task.CETCurrent
    "Task response time monitoring for OS_20ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_CET_T1_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x60013104


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_20ms_Task.CETCycleMax
    "Task response time monitoring for OS_20ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_CET_T1_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x60013108


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_20ms_Task.CETCurrentLoad
    "Task response time monitoring for OS_20ms_Task/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_T1_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x6001310C


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_20ms_Task.CETCurrentLoadMax
    "Task response time monitoring for OS_20ms_Task/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_T1_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x6001310E


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_2ms_Task.RespTimeCurrent
    "Task response time monitoring for OS_2ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x600130E0


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_2ms_Task.RespTimeCycleMax
    "Task response time monitoring for OS_2ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x600130E4


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_2ms_Task.RespTimeLifetimeMax
    "Task response time monitoring for OS_2ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x600130E8


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_2ms_Task.CETCurrent
    "Task response time monitoring for OS_2ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_CET_T1_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x600130EC


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_2ms_Task.CETCycleMax
    "Task response time monitoring for OS_2ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_CET_T1_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x600130F0


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_2ms_Task.CETCurrentLoad
    "Task response time monitoring for OS_2ms_Task/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_T1_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x600130F4


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_2ms_Task.CETCurrentLoadMax
    "Task response time monitoring for OS_2ms_Task/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_T1_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x600130F6


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_40ms_Task.RespTimeCurrent
    "Task response time monitoring for OS_40ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x600130C8


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_40ms_Task.RespTimeCycleMax
    "Task response time monitoring for OS_40ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x600130CC


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_40ms_Task.RespTimeLifetimeMax
    "Task response time monitoring for OS_40ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x600130D0


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_40ms_Task.CETCurrent
    "Task response time monitoring for OS_40ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_CET_T1_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x600130D4


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_40ms_Task.CETCycleMax
    "Task response time monitoring for OS_40ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_CET_T1_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x600130D8


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_40ms_Task.CETCurrentLoad
    "Task response time monitoring for OS_40ms_Task/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_T1_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x600130DC


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_40ms_Task.CETCurrentLoadMax
    "Task response time monitoring for OS_40ms_Task/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_T1_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x600130DE


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_50ms_Task.RespTimeCurrent
    "Task response time monitoring for OS_50ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x600130B0


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_50ms_Task.RespTimeCycleMax
    "Task response time monitoring for OS_50ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x600130B4


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_50ms_Task.RespTimeLifetimeMax
    "Task response time monitoring for OS_50ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x600130B8


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_50ms_Task.CETCurrent
    "Task response time monitoring for OS_50ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_CET_T1_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x600130BC


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_50ms_Task.CETCycleMax
    "Task response time monitoring for OS_50ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_CET_T1_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x600130C0


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_50ms_Task.CETCurrentLoad
    "Task response time monitoring for OS_50ms_Task/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_T1_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x600130C4


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_50ms_Task.CETCurrentLoadMax
    "Task response time monitoring for OS_50ms_Task/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_T1_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x600130C6


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_5ms_Task.RespTimeCurrent
    "Task response time monitoring for OS_5ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x60013098


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_5ms_Task.RespTimeCycleMax
    "Task response time monitoring for OS_5ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x6001309C


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_5ms_Task.RespTimeLifetimeMax
    "Task response time monitoring for OS_5ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x600130A0


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_5ms_Task.CETCurrent
    "Task response time monitoring for OS_5ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_CET_T1_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x600130A4


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_5ms_Task.CETCycleMax
    "Task response time monitoring for OS_5ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_CET_T1_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x600130A8


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_5ms_Task.CETCurrentLoad
    "Task response time monitoring for OS_5ms_Task/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_T1_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x600130AC


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_5ms_Task.CETCurrentLoadMax
    "Task response time monitoring for OS_5ms_Task/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_T1_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x600130AE


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_80ms_Task.RespTimeCurrent
    "Task response time monitoring for OS_80ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x60013080


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_80ms_Task.RespTimeCycleMax
    "Task response time monitoring for OS_80ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x60013084


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_80ms_Task.RespTimeLifetimeMax
    "Task response time monitoring for OS_80ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x60013088


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_80ms_Task.CETCurrent
    "Task response time monitoring for OS_80ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_CET_T1_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x6001308C


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_80ms_Task.CETCycleMax
    "Task response time monitoring for OS_80ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_CET_T1_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x60013090


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_80ms_Task.CETCurrentLoad
    "Task response time monitoring for OS_80ms_Task/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_T1_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x60013094


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_80ms_Task.CETCurrentLoadMax
    "Task response time monitoring for OS_80ms_Task/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_T1_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x60013096


/end MEASUREMENT




/begin MEASUREMENT

    rba_MultiStackTrace_CurrentCycleMaxUsage_CSA0
    "Current Cycle Max Usage stack Csa0"
    UWORD
    RB_RBA_rba_OsShell_CompuMethods_rba_OsShell_ResourceConversion
    1
    100
    0.0
    655.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000C3B0


/end MEASUREMENT




/begin MEASUREMENT

    rba_MultiStackTrace_CurrentCycleMaxUsage_CSA1
    "Current Cycle Max Usage stack Csa1"
    UWORD
    RB_RBA_rba_OsShell_CompuMethods_rba_OsShell_ResourceConversion
    1
    100
    0.0
    655.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000C3AE


/end MEASUREMENT




/begin MEASUREMENT

    rba_MultiStackTrace_CurrentCycleMaxUsage_CSA2
    "Current Cycle Max Usage stack Csa2"
    UWORD
    RB_RBA_rba_OsShell_CompuMethods_rba_OsShell_ResourceConversion
    1
    100
    0.0
    655.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000C3AC


/end MEASUREMENT




/begin MEASUREMENT

    rba_MultiStackTrace_CurrentCycleMaxUsage_User0
    "Current Cycle Max Usage stack User0"
    UWORD
    RB_RBA_rba_OsShell_CompuMethods_rba_OsShell_ResourceConversion
    1
    100
    0.0
    655.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000C3B8


/end MEASUREMENT




/begin MEASUREMENT

    rba_MultiStackTrace_CurrentCycleMaxUsage_User1
    "Current Cycle Max Usage stack User1"
    UWORD
    RB_RBA_rba_OsShell_CompuMethods_rba_OsShell_ResourceConversion
    1
    100
    0.0
    655.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000C3B6


/end MEASUREMENT




/begin MEASUREMENT

    rba_MultiStackTrace_CurrentCycleMaxUsage_User2
    "Current Cycle Max Usage stack User2"
    UWORD
    RB_RBA_rba_OsShell_CompuMethods_rba_OsShell_ResourceConversion
    1
    100
    0.0
    655.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000C3B4


/end MEASUREMENT




/begin MEASUREMENT

    rba_MultiStackTrace_LifeTimeMaxUsage_CSA0
    "Life Time Max Usage stack CSA0"
    UWORD
    RB_RBA_rba_OsShell_CompuMethods_rba_OsShell_ResourceConversion
    1
    100
    0.0
    655.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60036830


/end MEASUREMENT




/begin MEASUREMENT

    rba_MultiStackTrace_LifeTimeMaxUsage_CSA1
    "Life Time Max Usage stack CSA1"
    UWORD
    RB_RBA_rba_OsShell_CompuMethods_rba_OsShell_ResourceConversion
    1
    100
    0.0
    655.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6003682E


/end MEASUREMENT




/begin MEASUREMENT

    rba_MultiStackTrace_LifeTimeMaxUsage_CSA2
    "Life Time Max Usage stack CSA2"
    UWORD
    RB_RBA_rba_OsShell_CompuMethods_rba_OsShell_ResourceConversion
    1
    100
    0.0
    655.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6003682C


/end MEASUREMENT




/begin MEASUREMENT

    rba_MultiStackTrace_LifeTimeMaxUsage_User0
    "Life Time Max Usage stack User0"
    UWORD
    RB_RBA_rba_OsShell_CompuMethods_rba_OsShell_ResourceConversion
    1
    100
    0.0
    655.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60036838


/end MEASUREMENT




/begin MEASUREMENT

    rba_MultiStackTrace_LifeTimeMaxUsage_User1
    "Life Time Max Usage stack User1"
    UWORD
    RB_RBA_rba_OsShell_CompuMethods_rba_OsShell_ResourceConversion
    1
    100
    0.0
    655.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60036836


/end MEASUREMENT




/begin MEASUREMENT

    rba_MultiStackTrace_LifeTimeMaxUsage_User2
    "Life Time Max Usage stack User2"
    UWORD
    RB_RBA_rba_OsShell_CompuMethods_rba_OsShell_ResourceConversion
    1
    100
    0.0
    655.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60036834


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntr1000msTask
    "OS task counter for the OS_1000ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C948


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntr100msTask
    "OS task counter for the OS_100ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C944


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntr100msTaskUntrusted
    "OS task counter for the OS_100ms_Task_Untrusted"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C942


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntr10msTask
    "OS task counter for the OS_10ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C930


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntr10msTaskUntrusted
    "OS task counter for the OS_10ms_Task_Untrusted"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C92E


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntr1msTask
    "OS task counter for the OS_1ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C920


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntr1msTaskUntrusted
    "OS task counter for the OS_1ms_Task_Untrusted"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C91E


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntr200msTask
    "OS task counter for the OS_200ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C946


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntr20msTask
    "OS task counter for the OS_20ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C934


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntr20msTaskUntrusted
    "OS task counter for the OS_20ms_Task_Untrusted"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C932


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntr2msTask
    "OS task counter for the OS_2ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C924


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntr2msTaskUntrusted
    "OS task counter for the OS_2ms_Task_Untrusted"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C922


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntr40msTask
    "OS task counter for the OS_40ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C938


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntr40msTaskUntrusted
    "OS task counter for the OS_40ms_Task_Untrusted"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C936


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntr50msTask
    "OS task counter for the OS_50ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C93C


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntr50msTaskUntrusted
    "OS task counter for the OS_50ms_Task_Untrusted"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C93A


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntr5msTask
    "OS task counter for the OS_5ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C92A


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntr5msTaskUntrusted
    "OS task counter for the OS_5ms_Task_Untrusted"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C928


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntr80msTask
    "OS task counter for the OS_80ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C940


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntr80msTaskUntrusted
    "OS task counter for the OS_80ms_Task_Untrusted"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C93E


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrAsw1BgTask
    "OS task counter for the OS_Asw1Bg_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C95E


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrAswBgTaskUntrusted
    "OS task counter for the OS_AswBg_Task_Untrusted"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C95C


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrAswShutdownTaskUntrusted
    "OS task counter for the OS_AswShutdown_Task_Untrusted"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C95A


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrBswBgTask
    "OS task counter for the OS_BswBg_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70009D6C


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrCalWup100msTask
    "OS task counter for the OS_CalWup_100ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70009D64


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrCalWup10msTask
    "OS task counter for the OS_CalWup_10ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70009D60


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrCalWup20msTask
    "OS task counter for the OS_CalWup_20ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70009D62


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrCalWup2msTask
    "OS task counter for the OS_CalWup_2ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70009D5C


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrCalWupAsw110msTask
    "OS task counter for the OS_CalWupAsw1_10ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C926


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrCalWupAsw210msTask
    "OS task counter for the OS_CalWupAsw2_10ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x500000D4


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrCalWupAsw310msTask
    "OS task counter for the OS_CalWupAsw3_10ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x40000526


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrCalWupBgTask
    "OS task counter for the OS_CalWup_Bg_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70009D6A


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrCalWupIniEndTask
    "OS task counter for the OS_CalWup_IniEnd_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70009D68


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrCalWupIniTask
    "OS task counter for the OS_CalWup_Ini_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70009D66


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrDSMClearTask
    "OS task counter for the OS_DSM_Clear_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x40000538


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrDSMReiniTask
    "OS task counter for the OS_DSM_Reini_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x40000540


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrEngReStrtModeMTask
    "OS task counter for the OS_EngReStrtModeM_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x500000EA


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrEngReStrtTask
    "OS task counter for the OS_EngReStrt_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x500000CC


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrEpmNoSyncTask
    "OS task counter for the OS_EpmNoSync_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x500000CE


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimit1000msTask
    "Limit error counter for OS_1000ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D211


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimit100msTask
    "Limit error counter for OS_100ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D20F


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimit100msTaskUntrusted
    "Limit error counter for OS_100ms_Task_Untrusted"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D20E


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimit10msTask
    "Limit error counter for OS_10ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1F9


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimit10msTaskUntrusted
    "Limit error counter for OS_10ms_Task_Untrusted"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1F8


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimit1msTask
    "Limit error counter for OS_1ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1E2


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimit1msTaskUntrusted
    "Limit error counter for OS_1ms_Task_Untrusted"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1E1


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimit200msTask
    "Limit error counter for OS_200ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D210


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimit20msTask
    "Limit error counter for OS_20ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1FE


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimit20msTaskUntrusted
    "Limit error counter for OS_20ms_Task_Untrusted"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1FD


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimit2msTask
    "Limit error counter for OS_2ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1E9


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimit2msTaskUntrusted
    "Limit error counter for OS_2ms_Task_Untrusted"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1E8


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimit40msTask
    "Limit error counter for OS_40ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D202


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimit40msTaskUntrusted
    "Limit error counter for OS_40ms_Task_Untrusted"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D201


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimit50msTask
    "Limit error counter for OS_50ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D206


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimit50msTaskUntrusted
    "Limit error counter for OS_50ms_Task_Untrusted"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D205


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimit5msTask
    "Limit error counter for OS_5ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1F0


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimit5msTaskUntrusted
    "Limit error counter for OS_5ms_Task_Untrusted"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1EF


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimit80msTask
    "Limit error counter for OS_80ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D20A


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimit80msTaskUntrusted
    "Limit error counter for OS_80ms_Task_Untrusted"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D209


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitAsw1BgTask
    "Limit error counter for OS_Asw1Bg_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D229


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitAswBgTaskUntrusted
    "Limit error counter for OS_AswBg_Task_Untrusted"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D228


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitAswShutdownTaskUntrusted
    "Limit error counter for OS_AswShutdown_Task_Untrusted"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D227


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitBswBgTask
    "Limit error counter for OS_BswBg_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D226


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitCalWup100msTask
    "Limit error counter for OS_CalWup_100ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D20D


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitCalWup10msTask
    "Limit error counter for OS_CalWup_10ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1F6


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitCalWup20msTask
    "Limit error counter for OS_CalWup_20ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1FA


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitCalWup2msTask
    "Limit error counter for OS_CalWup_2ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1E4


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitCalWupAsw110msTask
    "Limit error counter for OS_CalWupAsw1_10ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1EE


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitCalWupAsw210msTask
    "Limit error counter for OS_CalWupAsw2_10ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1ED


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitCalWupAsw310msTask
    "Limit error counter for OS_CalWupAsw3_10ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1E7


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitCalWupBgTask
    "Limit error counter for OS_CalWup_Bg_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D225


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitCalWupIniEndTask
    "Limit error counter for OS_CalWup_IniEnd_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D224


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitCalWupIniTask
    "Limit error counter for OS_CalWup_Ini_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D223


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitDSMClearTask
    "Limit error counter for OS_DSM_Clear_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D214


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitDSMReiniTask
    "Limit error counter for OS_DSM_Reini_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D222


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitEngReStrtModeMTask
    "Limit error counter for OS_EngReStrtModeM_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D221


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitEngReStrtTask
    "Limit error counter for OS_EngReStrt_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1E3


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitEpmNoSyncTask
    "Limit error counter for OS_EpmNoSync_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1E5


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitInfraAsw1App10msTask
    "Limit error counter for OS_InfraAsw1App_10ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1F5


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitInfraAsw2App10msTask
    "Limit error counter for OS_InfraAsw2App_10ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1F4


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitInfraAsw3App10msTask
    "Limit error counter for OS_InfraAsw3App_10ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1F3


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitInfraBswApp10msTask
    "Limit error counter for OS_InfraBswApp_10ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1F2


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitIniDrvTask
    "Limit error counter for OS_IniDrv_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D213


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitIniDrvTaskUntrusted
    "Limit error counter for OS_IniDrv_Task_Untrusted"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D220


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitIniEndTask
    "Limit error counter for OS_IniEnd_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D21F


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitIniTask
    "Limit error counter for OS_Ini_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D21E


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitMoTask
    "Limit error counter for OS_Mo_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1DE


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitPreIniDrvTask
    "Limit error counter for OS_PreIniDrv_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D212


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitRbrAfterRunTask
    "Limit error counter for OS_RbrAfterRun_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D21D


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitReIniModeMTask
    "Limit error counter for OS_ReIniModeM_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D21C


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitReIniTask
    "Limit error counter for OS_ReIni_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D215


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitShutdown10msTask
    "Limit error counter for OS_Shutdown_10ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1D7


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitShutdownAsw1Task
    "Limit error counter for OS_Shutdown_Asw1_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1DA


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitShutdownAsw2Task
    "Limit error counter for OS_Shutdown_Asw2_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1DB


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitShutdownAsw3Task
    "Limit error counter for OS_Shutdown_Asw3_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1DC


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitShutdownBswTask
    "Limit error counter for OS_Shutdown_Bsw_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1D9


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitShutdownSeqTask
    "Limit error counter for OS_Shutdown_Seq_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1D8


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitWdgMTask
    "Limit error counter for OS_WdgM_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1DD


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitcore2100msTask
    "Limit error counter for OS_core2_100ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D20C


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitcore210msTask
    "Limit error counter for OS_core2_10ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1F7


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitcore21msTask
    "Limit error counter for OS_core2_1ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1E0


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitcore220msTask
    "Limit error counter for OS_core2_20ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1FC


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitcore22msTask
    "Limit error counter for OS_core2_2ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1EC


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitcore240msTask
    "Limit error counter for OS_core2_40ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D200


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitcore250msTask
    "Limit error counter for OS_core2_50ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D204


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitcore25msTask
    "Limit error counter for OS_core2_5ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1EB


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitcore280msTask
    "Limit error counter for OS_core2_80ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D208


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitcore2AswBgTask
    "Limit error counter for OS_core2_AswBg_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D21B


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitcore2AswShutdownTask
    "Limit error counter for OS_core2_AswShutdown_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D21A


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitcore2IniDrvTask
    "Limit error counter for OS_core2_IniDrv_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D219


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitcore3100msTask
    "Limit error counter for OS_core3_100ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D20B


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitcore310msTask
    "Limit error counter for OS_core3_10ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1F1


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitcore31msTask
    "Limit error counter for OS_core3_1ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1DF


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitcore320msTask
    "Limit error counter for OS_core3_20ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1FB


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitcore32msTask
    "Limit error counter for OS_core3_2ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1E6


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitcore340msTask
    "Limit error counter for OS_core3_40ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1FF


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitcore350msTask
    "Limit error counter for OS_core3_50ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D203


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitcore35msTask
    "Limit error counter for OS_core3_5ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1EA


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitcore380msTask
    "Limit error counter for OS_core3_80ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D207


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitcore3AswBgTask
    "Limit error counter for OS_core3_AswBg_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D218


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitcore3AswShutdownTask
    "Limit error counter for OS_core3_AswShutdown_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D217


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitcore3IniDrvTask
    "Limit error counter for OS_core3_IniDrv_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D216


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrInfraAsw1App10msTask
    "OS task counter for the OS_InfraAsw1App_10ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C92C


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrInfraAsw2App10msTask
    "OS task counter for the OS_InfraAsw2App_10ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x500000D6


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrInfraAsw3App10msTask
    "OS task counter for the OS_InfraAsw3App_10ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x4000052C


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrInfraBswApp10msTask
    "OS task counter for the OS_InfraBswApp_10ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70009D5E


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrIniDrvTask
    "OS task counter for the OS_IniDrv_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C94C


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrIniDrvTaskUntrusted
    "OS task counter for the OS_IniDrv_Task_Untrusted"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C958


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrIniEndTask
    "OS task counter for the OS_IniEnd_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C956


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrIniTask
    "OS task counter for the OS_Ini_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C954


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrMoTask
    "OS task counter for the OS_Mo_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C91C


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrPreIniDrvTask
    "OS task counter for the OS_PreIniDrv_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C94A


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrRbrAfterRunTask
    "OS task counter for the OS_RbrAfterRun_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C952


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrReIniModeMTask
    "OS task counter for the OS_ReIniModeM_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C950


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrReIniTask
    "OS task counter for the OS_ReIni_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C94E


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrShutdown10msTask
    "OS task counter for the OS_Shutdown_10ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70009D56


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrShutdownAsw1Task
    "OS task counter for the OS_Shutdown_Asw1_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C918


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrShutdownAsw2Task
    "OS task counter for the OS_Shutdown_Asw2_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x500000C8


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrShutdownAsw3Task
    "OS task counter for the OS_Shutdown_Asw3_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x40000520


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrShutdownBswTask
    "OS task counter for the OS_Shutdown_Bsw_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70009D5A


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrShutdownSeqTask
    "OS task counter for the OS_Shutdown_Seq_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70009D58


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrWdgMTask
    "OS task counter for the OS_WdgM_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C91A


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntrcore2100msTask
    "OS task counter for the OS_core2_100ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x500000E2


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntrcore210msTask
    "OS task counter for the OS_core2_10ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x500000D8


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntrcore21msTask
    "OS task counter for the OS_core2_1ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x500000CA


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntrcore220msTask
    "OS task counter for the OS_core2_20ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x500000DA


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntrcore22msTask
    "OS task counter for the OS_core2_2ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x500000D2


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntrcore240msTask
    "OS task counter for the OS_core2_40ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x500000DC


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntrcore250msTask
    "OS task counter for the OS_core2_50ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x500000DE


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntrcore25msTask
    "OS task counter for the OS_core2_5ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x500000D0


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntrcore280msTask
    "OS task counter for the OS_core2_80ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x500000E0


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntrcore2AswBgTask
    "OS task counter for the OS_core2_AswBg_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x500000E8


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntrcore2AswShutdownTask
    "OS task counter for the OS_core2_AswShutdown_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x500000E6


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntrcore2IniDrvTask
    "OS task counter for the OS_core2_IniDrv_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x500000E4


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntrcore3100msTask
    "OS task counter for the OS_core3_100ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x40000536


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntrcore310msTask
    "OS task counter for the OS_core3_10ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x4000052A


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntrcore31msTask
    "OS task counter for the OS_core3_1ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x40000522


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntrcore320msTask
    "OS task counter for the OS_core3_20ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x4000052E


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntrcore32msTask
    "OS task counter for the OS_core3_2ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x40000524


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntrcore340msTask
    "OS task counter for the OS_core3_40ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x40000530


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntrcore350msTask
    "OS task counter for the OS_core3_50ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x40000532


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntrcore35msTask
    "OS task counter for the OS_core3_5ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x40000528


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntrcore380msTask
    "OS task counter for the OS_core3_80ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x40000534


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntrcore3AswBgTask
    "OS task counter for the OS_core3_AswBg_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x4000053E


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntrcore3AswShutdownTask
    "OS task counter for the OS_core3_AswShutdown_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x4000053C


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntrcore3IniDrvTask
    "OS task counter for the OS_core3_IniDrv_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x4000053A


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_cntrErrAccess
    "OS E_OS_ACCESS error counter"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1D5


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_cntrErrCallevel
    "OS E_OS_CALLEVEL error counter"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1D4


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_cntrErrId
    "OS E_OS_ID error counter"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1D3


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_cntrErrLimitSum
    "OS E_OS_LIMIT error counter"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1D2


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_cntrErrNoFunc
    "OS E_OS_NOFUNC error counter"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1D1


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_cntrErrResource
    "OS E_OS_RESOURCE error counter"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1D0


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_cntrErrState
    "OS E_OS_STATE error counter"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1CF


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_cntrErrSum
    "OS overall error counter"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1BA


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_cntrErrValue
    "OS E_OS_VALUE error counter"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1CE


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_tiPowerOnFrst10ms
    "Time from last Power on Reset to first 10ms-Raster"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000C3C0


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_tiResetFrst10ms
    "Time from last Reset to first 10ms-Raster"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000C3C2


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ApplEnv_st.Loc_u32
    "reset application environment/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x600031F4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ApplEnv_st.UserValue_u32
    "reset application environment/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x600031F8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ApplEnv_st.Id_en
    "reset application environment/"
    UWORD
    RB_RBA_rba_Reset_CompuMethods_rba_Reset_Id_ten
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600031FC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ApplEnv_st.Grp_en
    "reset application environment/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600031FE


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ApplEnv_st.CntrRst_u8
    "reset application environment/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600031FF


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[0].ResetId_en
    "extended Reset history buffer[0]/"
    UWORD
    RB_RBA_rba_Reset_CompuMethods_rba_Reset_Id_ten
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039AE0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[1].ResetId_en
    "extended Reset history buffer[1]/"
    UWORD
    RB_RBA_rba_Reset_CompuMethods_rba_Reset_Id_ten
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039AF0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[2].ResetId_en
    "extended Reset history buffer[2]/"
    UWORD
    RB_RBA_rba_Reset_CompuMethods_rba_Reset_Id_ten
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B00


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[3].ResetId_en
    "extended Reset history buffer[3]/"
    UWORD
    RB_RBA_rba_Reset_CompuMethods_rba_Reset_Id_ten
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B10


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[4].ResetId_en
    "extended Reset history buffer[4]/"
    UWORD
    RB_RBA_rba_Reset_CompuMethods_rba_Reset_Id_ten
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B20


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[5].ResetId_en
    "extended Reset history buffer[5]/"
    UWORD
    RB_RBA_rba_Reset_CompuMethods_rba_Reset_Id_ten
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B30


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[6].ResetId_en
    "extended Reset history buffer[6]/"
    UWORD
    RB_RBA_rba_Reset_CompuMethods_rba_Reset_Id_ten
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B40


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[7].ResetId_en
    "extended Reset history buffer[7]/"
    UWORD
    RB_RBA_rba_Reset_CompuMethods_rba_Reset_Id_ten
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B50


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[8].ResetId_en
    "extended Reset history buffer[8]/"
    UWORD
    RB_RBA_rba_Reset_CompuMethods_rba_Reset_Id_ten
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B60


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[9].ResetId_en
    "extended Reset history buffer[9]/"
    UWORD
    RB_RBA_rba_Reset_CompuMethods_rba_Reset_Id_ten
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B70


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[0].Cntr_u16
    "extended Reset history buffer[0]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039AE2


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[1].Cntr_u16
    "extended Reset history buffer[1]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039AF2


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[2].Cntr_u16
    "extended Reset history buffer[2]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B02


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[3].Cntr_u16
    "extended Reset history buffer[3]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B12


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[4].Cntr_u16
    "extended Reset history buffer[4]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B22


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[5].Cntr_u16
    "extended Reset history buffer[5]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B32


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[6].Cntr_u16
    "extended Reset history buffer[6]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B42


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[7].Cntr_u16
    "extended Reset history buffer[7]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B52


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[8].Cntr_u16
    "extended Reset history buffer[8]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B62


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[9].Cntr_u16
    "extended Reset history buffer[9]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B72


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[0].Addr_u32
    "extended Reset history buffer[0]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039AE4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[1].Addr_u32
    "extended Reset history buffer[1]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039AF4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[2].Addr_u32
    "extended Reset history buffer[2]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B04


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[3].Addr_u32
    "extended Reset history buffer[3]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B14


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[4].Addr_u32
    "extended Reset history buffer[4]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B24


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[5].Addr_u32
    "extended Reset history buffer[5]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B34


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[6].Addr_u32
    "extended Reset history buffer[6]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B44


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[7].Addr_u32
    "extended Reset history buffer[7]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B54


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[8].Addr_u32
    "extended Reset history buffer[8]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B64


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[9].Addr_u32
    "extended Reset history buffer[9]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B74


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[0].SwId_u32_1
    "extended Reset history buffer[0]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039AE8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[1].SwId_u32_1
    "extended Reset history buffer[1]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039AF8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[2].SwId_u32_1
    "extended Reset history buffer[2]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B08


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[3].SwId_u32_1
    "extended Reset history buffer[3]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B18


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[4].SwId_u32_1
    "extended Reset history buffer[4]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B28


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[5].SwId_u32_1
    "extended Reset history buffer[5]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B38


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[6].SwId_u32_1
    "extended Reset history buffer[6]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B48


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[7].SwId_u32_1
    "extended Reset history buffer[7]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B58


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[8].SwId_u32_1
    "extended Reset history buffer[8]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B68


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[9].SwId_u32_1
    "extended Reset history buffer[9]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B78


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[0].SwId_u32_2
    "extended Reset history buffer[0]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039AEC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[1].SwId_u32_2
    "extended Reset history buffer[1]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039AFC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[2].SwId_u32_2
    "extended Reset history buffer[2]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B0C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[3].SwId_u32_2
    "extended Reset history buffer[3]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B1C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[4].SwId_u32_2
    "extended Reset history buffer[4]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B2C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[5].SwId_u32_2
    "extended Reset history buffer[5]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B3C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[6].SwId_u32_2
    "extended Reset history buffer[6]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B4C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[7].SwId_u32_2
    "extended Reset history buffer[7]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B5C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[8].SwId_u32_2
    "extended Reset history buffer[8]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B6C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[9].SwId_u32_2
    "extended Reset history buffer[9]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B7C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_HistBuf_a
    "reset history buffer"
    UWORD
    RB_RBA_rba_Reset_CompuMethods_rba_Reset_Id_ten
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B80
    MATRIX_DIM 8 


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Input_st.configs_ast[0].idElement_u32
    "rba_Runtime Measurement Variable/[0]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001860


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Input_st.configs_ast[0].idTask_u16
    "rba_Runtime Measurement Variable/[0]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001864


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Input_st.tiSampleTime_u8
    "rba_Runtime Measurement Variable/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001868


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Input_st.ctTrigger_u8
    "rba_Runtime Measurement Variable/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001869


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[0].tiCurRT_u32
    "rba_Runtime Measurement Variable[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001C34


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[1].tiCurRT_u32
    "rba_Runtime Measurement Variable[1]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001C5C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[2].tiCurRT_u32
    "rba_Runtime Measurement Variable[2]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001C84


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[0].tiMinRT_u32
    "rba_Runtime Measurement Variable[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001C38


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[1].tiMinRT_u32
    "rba_Runtime Measurement Variable[1]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001C60


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[2].tiMinRT_u32
    "rba_Runtime Measurement Variable[2]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001C88


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[0].tiMaxRT_u32
    "rba_Runtime Measurement Variable[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001C3C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[1].tiMaxRT_u32
    "rba_Runtime Measurement Variable[1]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001C64


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[2].tiMaxRT_u32
    "rba_Runtime Measurement Variable[2]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001C8C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[0].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[0]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001C40


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[1].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[1]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001C68


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[2].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[2]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001C90


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[0].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001C44


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[1].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[1]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001C6C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[2].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[2]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001C94


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[0].ctCalls_u32
    "rba_Runtime Measurement Variable[0]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001C48


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[1].ctCalls_u32
    "rba_Runtime Measurement Variable[1]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001C70


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[2].ctCalls_u32
    "rba_Runtime Measurement Variable[2]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001C98


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[0].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[0]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001C4C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[1].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[1]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001C74


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[2].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[2]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001C9C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[0].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[0]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001C50


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[1].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[1]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001C78


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[2].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[2]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001CA0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[0].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[0]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001C54


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[1].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[1]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001C7C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[2].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[2]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001CA4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[0].loadPer64k_u16
    "rba_Runtime Measurement Variable[0]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001C58


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[1].loadPer64k_u16
    "rba_Runtime Measurement Variable[1]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001C80


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[2].loadPer64k_u16
    "rba_Runtime Measurement Variable[2]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001CA8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[0].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001C5A


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[1].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[1]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001C82


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[2].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[2]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001CAA


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonSystemLoadPer64k_au16
    "Core Load"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x700029E0
    MATRIX_DIM 4 


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[0].tiCurRT_u32
    "rba_Runtime Measurement Variable[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001CAC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[1].tiCurRT_u32
    "rba_Runtime Measurement Variable[1]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001CE0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[2].tiCurRT_u32
    "rba_Runtime Measurement Variable[2]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D14


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[3].tiCurRT_u32
    "rba_Runtime Measurement Variable[3]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D48


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[4].tiCurRT_u32
    "rba_Runtime Measurement Variable[4]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D7C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[5].tiCurRT_u32
    "rba_Runtime Measurement Variable[5]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001DB0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[6].tiCurRT_u32
    "rba_Runtime Measurement Variable[6]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001DE4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[7].tiCurRT_u32
    "rba_Runtime Measurement Variable[7]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E18


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[8].tiCurRT_u32
    "rba_Runtime Measurement Variable[8]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E4C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[9].tiCurRT_u32
    "rba_Runtime Measurement Variable[9]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E80


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[10].tiCurRT_u32
    "rba_Runtime Measurement Variable[10]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001EB4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[11].tiCurRT_u32
    "rba_Runtime Measurement Variable[11]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001EE8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[12].tiCurRT_u32
    "rba_Runtime Measurement Variable[12]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F1C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[13].tiCurRT_u32
    "rba_Runtime Measurement Variable[13]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F50


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[14].tiCurRT_u32
    "rba_Runtime Measurement Variable[14]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F84


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[15].tiCurRT_u32
    "rba_Runtime Measurement Variable[15]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001FB8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[16].tiCurRT_u32
    "rba_Runtime Measurement Variable[16]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001FEC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[17].tiCurRT_u32
    "rba_Runtime Measurement Variable[17]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002020


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[18].tiCurRT_u32
    "rba_Runtime Measurement Variable[18]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002054


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[19].tiCurRT_u32
    "rba_Runtime Measurement Variable[19]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002088


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[20].tiCurRT_u32
    "rba_Runtime Measurement Variable[20]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700020BC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[21].tiCurRT_u32
    "rba_Runtime Measurement Variable[21]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700020F0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[22].tiCurRT_u32
    "rba_Runtime Measurement Variable[22]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002124


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[23].tiCurRT_u32
    "rba_Runtime Measurement Variable[23]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002158


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[24].tiCurRT_u32
    "rba_Runtime Measurement Variable[24]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000218C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[25].tiCurRT_u32
    "rba_Runtime Measurement Variable[25]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700021C0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[26].tiCurRT_u32
    "rba_Runtime Measurement Variable[26]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700021F4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[27].tiCurRT_u32
    "rba_Runtime Measurement Variable[27]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002228


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[28].tiCurRT_u32
    "rba_Runtime Measurement Variable[28]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000225C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[29].tiCurRT_u32
    "rba_Runtime Measurement Variable[29]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002290


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[30].tiCurRT_u32
    "rba_Runtime Measurement Variable[30]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700022C4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[31].tiCurRT_u32
    "rba_Runtime Measurement Variable[31]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700022F8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[32].tiCurRT_u32
    "rba_Runtime Measurement Variable[32]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000232C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[33].tiCurRT_u32
    "rba_Runtime Measurement Variable[33]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002360


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[34].tiCurRT_u32
    "rba_Runtime Measurement Variable[34]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002394


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[35].tiCurRT_u32
    "rba_Runtime Measurement Variable[35]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700023C8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[36].tiCurRT_u32
    "rba_Runtime Measurement Variable[36]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700023FC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[37].tiCurRT_u32
    "rba_Runtime Measurement Variable[37]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002430


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[38].tiCurRT_u32
    "rba_Runtime Measurement Variable[38]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002464


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[39].tiCurRT_u32
    "rba_Runtime Measurement Variable[39]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002498


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[40].tiCurRT_u32
    "rba_Runtime Measurement Variable[40]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700024CC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[41].tiCurRT_u32
    "rba_Runtime Measurement Variable[41]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002500


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[42].tiCurRT_u32
    "rba_Runtime Measurement Variable[42]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002534


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[43].tiCurRT_u32
    "rba_Runtime Measurement Variable[43]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002568


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[44].tiCurRT_u32
    "rba_Runtime Measurement Variable[44]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000259C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[45].tiCurRT_u32
    "rba_Runtime Measurement Variable[45]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700025D0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[46].tiCurRT_u32
    "rba_Runtime Measurement Variable[46]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002604


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[47].tiCurRT_u32
    "rba_Runtime Measurement Variable[47]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002638


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[48].tiCurRT_u32
    "rba_Runtime Measurement Variable[48]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000266C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[49].tiCurRT_u32
    "rba_Runtime Measurement Variable[49]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700026A0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[50].tiCurRT_u32
    "rba_Runtime Measurement Variable[50]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700026D4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[51].tiCurRT_u32
    "rba_Runtime Measurement Variable[51]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002708


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[52].tiCurRT_u32
    "rba_Runtime Measurement Variable[52]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000273C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[53].tiCurRT_u32
    "rba_Runtime Measurement Variable[53]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002770


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[54].tiCurRT_u32
    "rba_Runtime Measurement Variable[54]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700027A4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[55].tiCurRT_u32
    "rba_Runtime Measurement Variable[55]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700027D8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[56].tiCurRT_u32
    "rba_Runtime Measurement Variable[56]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000280C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[57].tiCurRT_u32
    "rba_Runtime Measurement Variable[57]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002840


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[58].tiCurRT_u32
    "rba_Runtime Measurement Variable[58]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002874


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[59].tiCurRT_u32
    "rba_Runtime Measurement Variable[59]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700028A8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[60].tiCurRT_u32
    "rba_Runtime Measurement Variable[60]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700028DC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[61].tiCurRT_u32
    "rba_Runtime Measurement Variable[61]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002910


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[62].tiCurRT_u32
    "rba_Runtime Measurement Variable[62]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002944


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[63].tiCurRT_u32
    "rba_Runtime Measurement Variable[63]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002978


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[64].tiCurRT_u32
    "rba_Runtime Measurement Variable[64]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700029AC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[0].tiMinRT_u32
    "rba_Runtime Measurement Variable[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001CB0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[1].tiMinRT_u32
    "rba_Runtime Measurement Variable[1]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001CE4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[2].tiMinRT_u32
    "rba_Runtime Measurement Variable[2]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D18


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[3].tiMinRT_u32
    "rba_Runtime Measurement Variable[3]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D4C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[4].tiMinRT_u32
    "rba_Runtime Measurement Variable[4]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D80


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[5].tiMinRT_u32
    "rba_Runtime Measurement Variable[5]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001DB4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[6].tiMinRT_u32
    "rba_Runtime Measurement Variable[6]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001DE8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[7].tiMinRT_u32
    "rba_Runtime Measurement Variable[7]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E1C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[8].tiMinRT_u32
    "rba_Runtime Measurement Variable[8]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E50


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[9].tiMinRT_u32
    "rba_Runtime Measurement Variable[9]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E84


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[10].tiMinRT_u32
    "rba_Runtime Measurement Variable[10]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001EB8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[11].tiMinRT_u32
    "rba_Runtime Measurement Variable[11]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001EEC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[12].tiMinRT_u32
    "rba_Runtime Measurement Variable[12]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F20


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[13].tiMinRT_u32
    "rba_Runtime Measurement Variable[13]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F54


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[14].tiMinRT_u32
    "rba_Runtime Measurement Variable[14]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F88


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[15].tiMinRT_u32
    "rba_Runtime Measurement Variable[15]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001FBC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[16].tiMinRT_u32
    "rba_Runtime Measurement Variable[16]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001FF0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[17].tiMinRT_u32
    "rba_Runtime Measurement Variable[17]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002024


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[18].tiMinRT_u32
    "rba_Runtime Measurement Variable[18]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002058


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[19].tiMinRT_u32
    "rba_Runtime Measurement Variable[19]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000208C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[20].tiMinRT_u32
    "rba_Runtime Measurement Variable[20]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700020C0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[21].tiMinRT_u32
    "rba_Runtime Measurement Variable[21]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700020F4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[22].tiMinRT_u32
    "rba_Runtime Measurement Variable[22]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002128


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[23].tiMinRT_u32
    "rba_Runtime Measurement Variable[23]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000215C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[24].tiMinRT_u32
    "rba_Runtime Measurement Variable[24]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002190


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[25].tiMinRT_u32
    "rba_Runtime Measurement Variable[25]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700021C4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[26].tiMinRT_u32
    "rba_Runtime Measurement Variable[26]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700021F8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[27].tiMinRT_u32
    "rba_Runtime Measurement Variable[27]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000222C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[28].tiMinRT_u32
    "rba_Runtime Measurement Variable[28]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002260


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[29].tiMinRT_u32
    "rba_Runtime Measurement Variable[29]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002294


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[30].tiMinRT_u32
    "rba_Runtime Measurement Variable[30]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700022C8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[31].tiMinRT_u32
    "rba_Runtime Measurement Variable[31]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700022FC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[32].tiMinRT_u32
    "rba_Runtime Measurement Variable[32]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002330


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[33].tiMinRT_u32
    "rba_Runtime Measurement Variable[33]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002364


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[34].tiMinRT_u32
    "rba_Runtime Measurement Variable[34]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002398


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[35].tiMinRT_u32
    "rba_Runtime Measurement Variable[35]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700023CC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[36].tiMinRT_u32
    "rba_Runtime Measurement Variable[36]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002400


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[37].tiMinRT_u32
    "rba_Runtime Measurement Variable[37]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002434


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[38].tiMinRT_u32
    "rba_Runtime Measurement Variable[38]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002468


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[39].tiMinRT_u32
    "rba_Runtime Measurement Variable[39]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000249C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[40].tiMinRT_u32
    "rba_Runtime Measurement Variable[40]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700024D0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[41].tiMinRT_u32
    "rba_Runtime Measurement Variable[41]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002504


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[42].tiMinRT_u32
    "rba_Runtime Measurement Variable[42]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002538


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[43].tiMinRT_u32
    "rba_Runtime Measurement Variable[43]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000256C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[44].tiMinRT_u32
    "rba_Runtime Measurement Variable[44]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700025A0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[45].tiMinRT_u32
    "rba_Runtime Measurement Variable[45]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700025D4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[46].tiMinRT_u32
    "rba_Runtime Measurement Variable[46]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002608


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[47].tiMinRT_u32
    "rba_Runtime Measurement Variable[47]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000263C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[48].tiMinRT_u32
    "rba_Runtime Measurement Variable[48]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002670


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[49].tiMinRT_u32
    "rba_Runtime Measurement Variable[49]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700026A4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[50].tiMinRT_u32
    "rba_Runtime Measurement Variable[50]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700026D8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[51].tiMinRT_u32
    "rba_Runtime Measurement Variable[51]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000270C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[52].tiMinRT_u32
    "rba_Runtime Measurement Variable[52]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002740


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[53].tiMinRT_u32
    "rba_Runtime Measurement Variable[53]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002774


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[54].tiMinRT_u32
    "rba_Runtime Measurement Variable[54]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700027A8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[55].tiMinRT_u32
    "rba_Runtime Measurement Variable[55]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700027DC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[56].tiMinRT_u32
    "rba_Runtime Measurement Variable[56]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002810


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[57].tiMinRT_u32
    "rba_Runtime Measurement Variable[57]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002844


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[58].tiMinRT_u32
    "rba_Runtime Measurement Variable[58]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002878


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[59].tiMinRT_u32
    "rba_Runtime Measurement Variable[59]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700028AC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[60].tiMinRT_u32
    "rba_Runtime Measurement Variable[60]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700028E0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[61].tiMinRT_u32
    "rba_Runtime Measurement Variable[61]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002914


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[62].tiMinRT_u32
    "rba_Runtime Measurement Variable[62]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002948


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[63].tiMinRT_u32
    "rba_Runtime Measurement Variable[63]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000297C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[64].tiMinRT_u32
    "rba_Runtime Measurement Variable[64]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700029B0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[0].tiMaxRT_u32
    "rba_Runtime Measurement Variable[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001CB4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[1].tiMaxRT_u32
    "rba_Runtime Measurement Variable[1]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001CE8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[2].tiMaxRT_u32
    "rba_Runtime Measurement Variable[2]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D1C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[3].tiMaxRT_u32
    "rba_Runtime Measurement Variable[3]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D50


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[4].tiMaxRT_u32
    "rba_Runtime Measurement Variable[4]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D84


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[5].tiMaxRT_u32
    "rba_Runtime Measurement Variable[5]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001DB8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[6].tiMaxRT_u32
    "rba_Runtime Measurement Variable[6]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001DEC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[7].tiMaxRT_u32
    "rba_Runtime Measurement Variable[7]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E20


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[8].tiMaxRT_u32
    "rba_Runtime Measurement Variable[8]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E54


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[9].tiMaxRT_u32
    "rba_Runtime Measurement Variable[9]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E88


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[10].tiMaxRT_u32
    "rba_Runtime Measurement Variable[10]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001EBC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[11].tiMaxRT_u32
    "rba_Runtime Measurement Variable[11]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001EF0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[12].tiMaxRT_u32
    "rba_Runtime Measurement Variable[12]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F24


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[13].tiMaxRT_u32
    "rba_Runtime Measurement Variable[13]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F58


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[14].tiMaxRT_u32
    "rba_Runtime Measurement Variable[14]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F8C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[15].tiMaxRT_u32
    "rba_Runtime Measurement Variable[15]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001FC0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[16].tiMaxRT_u32
    "rba_Runtime Measurement Variable[16]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001FF4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[17].tiMaxRT_u32
    "rba_Runtime Measurement Variable[17]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002028


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[18].tiMaxRT_u32
    "rba_Runtime Measurement Variable[18]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000205C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[19].tiMaxRT_u32
    "rba_Runtime Measurement Variable[19]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002090


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[20].tiMaxRT_u32
    "rba_Runtime Measurement Variable[20]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700020C4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[21].tiMaxRT_u32
    "rba_Runtime Measurement Variable[21]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700020F8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[22].tiMaxRT_u32
    "rba_Runtime Measurement Variable[22]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000212C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[23].tiMaxRT_u32
    "rba_Runtime Measurement Variable[23]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002160


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[24].tiMaxRT_u32
    "rba_Runtime Measurement Variable[24]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002194


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[25].tiMaxRT_u32
    "rba_Runtime Measurement Variable[25]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700021C8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[26].tiMaxRT_u32
    "rba_Runtime Measurement Variable[26]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700021FC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[27].tiMaxRT_u32
    "rba_Runtime Measurement Variable[27]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002230


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[28].tiMaxRT_u32
    "rba_Runtime Measurement Variable[28]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002264


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[29].tiMaxRT_u32
    "rba_Runtime Measurement Variable[29]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002298


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[30].tiMaxRT_u32
    "rba_Runtime Measurement Variable[30]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700022CC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[31].tiMaxRT_u32
    "rba_Runtime Measurement Variable[31]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002300


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[32].tiMaxRT_u32
    "rba_Runtime Measurement Variable[32]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002334


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[33].tiMaxRT_u32
    "rba_Runtime Measurement Variable[33]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002368


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[34].tiMaxRT_u32
    "rba_Runtime Measurement Variable[34]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000239C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[35].tiMaxRT_u32
    "rba_Runtime Measurement Variable[35]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700023D0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[36].tiMaxRT_u32
    "rba_Runtime Measurement Variable[36]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002404


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[37].tiMaxRT_u32
    "rba_Runtime Measurement Variable[37]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002438


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[38].tiMaxRT_u32
    "rba_Runtime Measurement Variable[38]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000246C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[39].tiMaxRT_u32
    "rba_Runtime Measurement Variable[39]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700024A0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[40].tiMaxRT_u32
    "rba_Runtime Measurement Variable[40]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700024D4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[41].tiMaxRT_u32
    "rba_Runtime Measurement Variable[41]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002508


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[42].tiMaxRT_u32
    "rba_Runtime Measurement Variable[42]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000253C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[43].tiMaxRT_u32
    "rba_Runtime Measurement Variable[43]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002570


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[44].tiMaxRT_u32
    "rba_Runtime Measurement Variable[44]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700025A4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[45].tiMaxRT_u32
    "rba_Runtime Measurement Variable[45]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700025D8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[46].tiMaxRT_u32
    "rba_Runtime Measurement Variable[46]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000260C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[47].tiMaxRT_u32
    "rba_Runtime Measurement Variable[47]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002640


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[48].tiMaxRT_u32
    "rba_Runtime Measurement Variable[48]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002674


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[49].tiMaxRT_u32
    "rba_Runtime Measurement Variable[49]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700026A8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[50].tiMaxRT_u32
    "rba_Runtime Measurement Variable[50]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700026DC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[51].tiMaxRT_u32
    "rba_Runtime Measurement Variable[51]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002710


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[52].tiMaxRT_u32
    "rba_Runtime Measurement Variable[52]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002744


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[53].tiMaxRT_u32
    "rba_Runtime Measurement Variable[53]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002778


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[54].tiMaxRT_u32
    "rba_Runtime Measurement Variable[54]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700027AC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[55].tiMaxRT_u32
    "rba_Runtime Measurement Variable[55]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700027E0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[56].tiMaxRT_u32
    "rba_Runtime Measurement Variable[56]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002814


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[57].tiMaxRT_u32
    "rba_Runtime Measurement Variable[57]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002848


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[58].tiMaxRT_u32
    "rba_Runtime Measurement Variable[58]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000287C


/end MEASUREMENT




