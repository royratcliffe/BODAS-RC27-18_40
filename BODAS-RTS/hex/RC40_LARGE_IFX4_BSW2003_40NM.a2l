    29313 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BS_CPU5_DMI_NONESAFE_E"
    29314 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU5_DMI_NONESAFE_E"
    29315 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_LPB_CPU5_DMI_NONESAFE_E"
    29316 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU5_DMI_NONESAFE_E"
    29317 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IED_CPU5_DMI_SAFE_E"
    29318 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_T_CPU5_DMI_SAFE_E"
    29319 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_C_CPU5_DMI_SAFE_E"
    29320 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_S_CPU5_DMI_SAFE_E"
    29321 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BI_CPU5_DMI_SAFE_E"
    29322 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_UNC_CPU5_DMI_SAFE_E"
    29323 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_SP_CPU5_DMI_SAFE_E"
    29324 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BS_CPU5_DMI_SAFE_E"
    29325 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU5_DMI_SAFE_E"
    29326 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_LPB_CPU5_DMI_SAFE_E"
    29327 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU5_DMI_SAFE_E"
    29328 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IED_CERBERUS_IOC32P_E"
    29329 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_T_CERBERUS_IOC32P_E"
    29330 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_C_CERBERUS_IOC32P_E"
    29331 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_S_CERBERUS_IOC32P_E"
    29332 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BI_CERBERUS_IOC32P_E"
    29333 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_UNC_CERBERUS_IOC32P_E"
    29334 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_SP_CERBERUS_IOC32P_E"
    29335 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BS_CERBERUS_IOC32P_E"
    29336 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_ADDR_CERBERUS_IOC32P_E"
    29337 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_LPB_CERBERUS_IOC32P_E"
    29338 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_MTMV_CERBERUS_IOC32P_E"
    29339 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IED_IOC32E_E"
    29340 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_T_IOC32E_E"
    29341 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_C_IOC32E_E"
    29342 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_S_IOC32E_E"
    29343 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BI_IOC32E_E"
    29344 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_UNC_IOC32E_E"
    29345 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_SP_IOC32E_E"
    29346 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BS_IOC32E_E"
    29347 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_ADDR_IOC32E_E"
    29348 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_LPB_IOC32E_E"
    29349 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_MTMV_IOC32E_E"
    29350 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IED_CPU0_PMI_PMBI_E"
    29351 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_T_CPU0_PMI_PMBI_E"
    29352 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_C_CPU0_PMI_PMBI_E"
    29353 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_S_CPU0_PMI_PMBI_E"
    29354 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BI_CPU0_PMI_PMBI_E"
    29355 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_UNC_CPU0_PMI_PMBI_E"
    29356 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_SP_CPU0_PMI_PMBI_E"
    29357 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BS_CPU0_PMI_PMBI_E"
    29358 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU0_PMI_PMBI_E"
    29359 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_LPB_CPU0_PMI_PMBI_E"
    29360 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU0_PMI_PMBI_E"
    29361 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IED_CPU1_PMI_PMBI_E"
    29362 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_T_CPU1_PMI_PMBI_E"
    29363 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_C_CPU1_PMI_PMBI_E"
    29364 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_S_CPU1_PMI_PMBI_E"
    29365 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BI_CPU1_PMI_PMBI_E"
    29366 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_UNC_CPU1_PMI_PMBI_E"
    29367 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_SP_CPU1_PMI_PMBI_E"
    29368 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BS_CPU1_PMI_PMBI_E"
    29369 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU1_PMI_PMBI_E"
    29370 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_LPB_CPU1_PMI_PMBI_E"
    29371 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU1_PMI_PMBI_E"
    29372 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IED_CPU2_PMI_PMBI_E"
    29373 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_T_CPU2_PMI_PMBI_E"
    29374 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_C_CPU2_PMI_PMBI_E"
    29375 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_S_CPU2_PMI_PMBI_E"
    29376 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BI_CPU2_PMI_PMBI_E"
    29377 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_UNC_CPU2_PMI_PMBI_E"
    29378 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_SP_CPU2_PMI_PMBI_E"
    29379 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BS_CPU2_PMI_PMBI_E"
    29380 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU2_PMI_PMBI_E"
    29381 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_LPB_CPU2_PMI_PMBI_E"
    29382 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU2_PMI_PMBI_E"
    29383 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IED_CPU3_PMI_PMBI_E"
    29384 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_T_CPU3_PMI_PMBI_E"
    29385 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_C_CPU3_PMI_PMBI_E"
    29386 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_S_CPU3_PMI_PMBI_E"
    29387 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BI_CPU3_PMI_PMBI_E"
    29388 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_UNC_CPU3_PMI_PMBI_E"
    29389 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_SP_CPU3_PMI_PMBI_E"
    29390 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BS_CPU3_PMI_PMBI_E"
    29391 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU3_PMI_PMBI_E"
    29392 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_LPB_CPU3_PMI_PMBI_E"
    29393 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU3_PMI_PMBI_E"
    29394 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IED_CPU4_PMI_PMBI_E"
    29395 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_T_CPU4_PMI_PMBI_E"
    29396 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_C_CPU4_PMI_PMBI_E"
    29397 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_S_CPU4_PMI_PMBI_E"
    29398 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BI_CPU4_PMI_PMBI_E"
    29399 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_UNC_CPU4_PMI_PMBI_E"
    29400 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_SP_CPU4_PMI_PMBI_E"
    29401 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BS_CPU4_PMI_PMBI_E"
    29402 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU4_PMI_PMBI_E"
    29403 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_LPB_CPU4_PMI_PMBI_E"
    29404 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU4_PMI_PMBI_E"
    29405 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IED_CPU5_PMI_PMBI_E"
    29406 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_T_CPU5_PMI_PMBI_E"
    29407 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_C_CPU5_PMI_PMBI_E"
    29408 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_S_CPU5_PMI_PMBI_E"
    29409 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BI_CPU5_PMI_PMBI_E"
    29410 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_UNC_CPU5_PMI_PMBI_E"
    29411 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_SP_CPU5_PMI_PMBI_E"
    29412 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BS_CPU5_PMI_PMBI_E"
    29413 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU5_PMI_PMBI_E"
    29414 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_LPB_CPU5_PMI_PMBI_E"
    29415 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU5_PMI_PMBI_E"
    29416 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IED_GETH_DMA0_E"
    29417 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_T_GETH_DMA0_E"
    29418 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_C_GETH_DMA0_E"
    29419 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_S_GETH_DMA0_E"
    29420 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BI_GETH_DMA0_E"
    29421 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_UNC_GETH_DMA0_E"
    29422 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_SP_GETH_DMA0_E"
    29423 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BS_GETH_DMA0_E"
    29424 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_ADDR_GETH_DMA0_E"
    29425 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_LPB_GETH_DMA0_E"
    29426 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_MTMV_GETH_DMA0_E"
    29427 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IED_GETH_DMA1_E"
    29428 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_T_GETH_DMA1_E"
    29429 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_C_GETH_DMA1_E"
    29430 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_S_GETH_DMA1_E"
    29431 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BI_GETH_DMA1_E"
    29432 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_UNC_GETH_DMA1_E"
    29433 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_SP_GETH_DMA1_E"
    29434 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BS_GETH_DMA1_E"
    29435 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_ADDR_GETH_DMA1_E"
    29436 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_LPB_GETH_DMA1_E"
    29437 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_MTMV_GETH_DMA1_E"
    29438 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IED_GETH_DMA2_E"
    29439 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_T_GETH_DMA2_E"
    29440 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_C_GETH_DMA2_E"
    29441 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_S_GETH_DMA2_E"
    29442 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BI_GETH_DMA2_E"
    29443 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_UNC_GETH_DMA2_E"
    29444 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_SP_GETH_DMA2_E"
    29445 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BS_GETH_DMA2_E"
    29446 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_ADDR_GETH_DMA2_E"
    29447 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_LPB_GETH_DMA2_E"
    29448 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_MTMV_GETH_DMA2_E"
    29449 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IED_GETH_DMA3_E"
    29450 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_T_GETH_DMA3_E"
    29451 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_C_GETH_DMA3_E"
    29452 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_S_GETH_DMA3_E"
    29453 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BI_GETH_DMA3_E"
    29454 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_UNC_GETH_DMA3_E"
    29455 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_SP_GETH_DMA3_E"
    29456 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BS_GETH_DMA3_E"
    29457 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_ADDR_GETH_DMA3_E"
    29458 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_LPB_GETH_DMA3_E"
    29459 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_MTMV_GETH_DMA3_E"
    29460 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IED_DAM0_E"
    29461 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_T_DAM0_E"
    29462 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_C_DAM0_E"
    29463 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_S_DAM0_E"
    29464 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BI_DAM0_E"
    29465 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_UNC_DAM0_E"
    29466 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_SP_DAM0_E"
    29467 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BS_DAM0_E"
    29468 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_ADDR_DAM0_E"
    29469 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_LPB_DAM0_E"
    29470 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_MTMV_DAM0_E"
    29471 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IED_DAM1_E"
    29472 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_T_DAM1_E"
    29473 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_C_DAM1_E"
    29474 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_S_DAM1_E"
    29475 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BI_DAM1_E"
    29476 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_UNC_DAM1_E"
    29477 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_SP_DAM1_E"
    29478 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_BS_DAM1_E"
    29479 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_ADDR_DAM1_E"
    29480 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_LPB_DAM1_E"
    29481 "RBA_RESET_CPU2_TRAP_SYSBUSERR_DIE_IE_MTMV_DAM1_E"
    29482 "RBA_RESET_CPU2_TRAP_TCN4_UNKNOWN_E"
    29483 "RBA_RESET_CPU2_TRAP_TCN5_TIN0_E"
    29484 "RBA_RESET_CPU2_TRAP_ASSTRAP_OVF_E"
    29485 "RBA_RESET_CPU2_TRAP_ASSTRAP_SOVF_E"
    29486 "RBA_RESET_CPU2_TRAP_TCN5_UNKNOWN_E"
    29487 "RBA_RESET_CPU2_TRAP_SYSCALL_SYS_E"
    29488 "RBA_RESET_CPU2_TRAP_NMI_UNKNOWN_E"
    29489 "RBA_RESET_CPU2_TRAP_NMI_ESR0_E"
    29490 "RBA_RESET_CPU2_TRAP_NMI_ESR1_E"
    29491 "RBA_RESET_CPU2_TRAP_NMI_SMUT_E"
    29492 "RBA_RESET_CPU2_TRAP_NMI_SMU_CPU0_MPU_E"
    29493 "RBA_RESET_CPU2_TRAP_NMI_SMU_CPU1_MPU_E"
    29494 "RBA_RESET_CPU2_TRAP_NMI_SMU_CPU2_MPU_E"
    29495 "RBA_RESET_CPU2_TRAP_NMI_SMU_IR_E"
    29496 "RBA_RESET_CPU2_TRAP_NMI_SMU_CGU_WDT_E"
    29497 "RBA_RESET_CPU2_TRAP_NMI_SMU_CGU_PLLLOL_E"
    29498 "RBA_RESET_CPU2_TRAP_NMI_SMU_CGU_PLLERAYLOL_E"
    29499 "RBA_RESET_CPU2_TRAP_NMI_SMU_CGU_STM_E"
    29500 "RBA_RESET_CPU2_TRAP_NMI_SMU_CGU_PLLERAY_E"
    29501 "RBA_RESET_CPU2_TRAP_NMI_SMU_CGU_PLL_E"
    29502 "RBA_RESET_CPU2_TRAP_NMI_SMU_CGU_SRI_E"
    29503 "RBA_RESET_CPU2_TRAP_NMI_SMU_CGU_SPB_E"
    29504 "RBA_RESET_CPU2_TRAP_NMI_SMU_CGU_CPU0_E"
    29505 "RBA_RESET_CPU2_TRAP_NMI_SMU_SCUEVR_12UV_E"
    29506 "RBA_RESET_CPU2_TRAP_NMI_SMU_SCUEVR_12OV_E"
    29507 "RBA_RESET_CPU2_TRAP_NMI_SMU_SCUEVR_33UV_E"
    29508 "RBA_RESET_CPU2_TRAP_NMI_SMU_SCUEVR_33OV_E"
    29509 "RBA_RESET_CPU2_TRAP_NMI_SMU_SCUEVR_5UV_E"
    29510 "RBA_RESET_CPU2_TRAP_NMI_SMU_SCUEVR_5OV_E"
    29511 "RBA_RESET_CPU2_TRAP_NMI_SMU_SWDT_E"
    29512 "RBA_RESET_CPU2_TRAP_NMI_SMU_WDT0_E"
    29513 "RBA_RESET_CPU2_TRAP_NMI_SMU_WDT1_E"
    29514 "RBA_RESET_CPU2_TRAP_NMI_SMU_WDT2_E"
    29515 "RBA_RESET_CPU2_TRAP_NMI_SMU_WDT3_E"
    29516 "RBA_RESET_CPU2_TRAP_NMI_SMU_WDT4_E"
    29517 "RBA_RESET_CPU2_TRAP_NMI_SMU_WDT5_E"
    29518 "RBA_RESET_CPU2_TRAP_TCN7_UNKNOWN_E"
    32768 "RBA_RESET_CPU3_TRAP_MMU_VAF_E"
    32769 "RBA_RESET_CPU3_TRAP_MMU_VAP_E"
    32770 "RBA_RESET_CPU3_TRAP_TCN0_UNKNOWN_E"
    32771 "RBA_RESET_CPU3_TRAP_TCN1_TIN0_E"
    32772 "RBA_RESET_CPU3_TRAP_INTPROT_PRIV_E"
    32773 "RBA_RESET_CPU3_TRAP_INTPROT_MPR_E"
    32774 "RBA_RESET_CPU3_TRAP_INTPROT_MPW_E"
    32775 "RBA_RESET_CPU3_TRAP_INTPROT_MPX_E"
    32776 "RBA_RESET_CPU3_TRAP_INTPROT_MPP_E"
    32777 "RBA_RESET_CPU3_TRAP_INTPROT_MPN_E"
    32778 "RBA_RESET_CPU3_TRAP_INTPROT_GRWP_E"
    32779 "RBA_RESET_CPU3_TRAP_TCN1_UNKNOWN_E"
    32780 "RBA_RESET_CPU3_TRAP_TCN2_TIN0_E"
    32781 "RBA_RESET_CPU3_TRAP_INSTRERR_IOPC_E"
    32782 "RBA_RESET_CPU3_TRAP_INSTRERR_UOPC_E"
    32783 "RBA_RESET_CPU3_TRAP_INSTRERR_OPD_E"
    32784 "RBA_RESET_CPU3_TRAP_INSTRERR_ALN_E"
    32785 "RBA_RESET_CPU3_TRAP_INSTRERR_MEM_E"
    32786 "RBA_RESET_CPU3_TRAP_TCN2_UNKNOWN_E"
    32787 "RBA_RESET_CPU3_TRAP_TCN3_TIN0_E"
    32788 "RBA_RESET_CPU3_TRAP_CONTMANA_FCD_E"
    32789 "RBA_RESET_CPU3_TRAP_CONTMANA_CDO_E"
    32790 "RBA_RESET_CPU3_TRAP_CONTMANA_CDU_E"
    32791 "RBA_RESET_CPU3_TRAP_CONTMANA_FCU_E"
    32792 "RBA_RESET_CPU3_TRAP_CONTMANA_CSU_E"
    32793 "RBA_RESET_CPU3_TRAP_CONTMANA_CTYP_E"
    32794 "RBA_RESET_CPU3_TRAP_CONTMANA_NEST_E"
    32795 "RBA_RESET_CPU3_TRAP_TCN3_UNKNOWN_E"
    32796 "RBA_RESET_CPU3_TRAP_TCN4_TIN0_E"
    32797 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PSE_E"
    32798 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DSE_E"
    32799 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DAE_E"
    32800 "RBA_RESET_CPU3_TRAP_SYSBUSERR_CAE_E"
    32801 "RBA_RESET_CPU3_TRAP_FPU_INEXACT_E"
    32802 "RBA_RESET_CPU3_TRAP_FPU_UNRFLW_E"
    32803 "RBA_RESET_CPU3_TRAP_FPU_DIVZRO_E"
    32804 "RBA_RESET_CPU3_TRAP_FPU_OVRFLW_E"
    32805 "RBA_RESET_CPU3_TRAP_FPU_INVOPR_E"
    32806 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_UNKNOWN_E"
    32807 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IED_DMA_PARTITION_0_E"
    32808 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_T_DMA_PARTITION_0_E"
    32809 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_C_DMA_PARTITION_0_E"
    32810 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_S_DMA_PARTITION_0_E"
    32811 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BI_DMA_PARTITION_0_E"
    32812 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_UNC_DMA_PARTITION_0_E"
    32813 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_SP_DMA_PARTITION_0_E"
    32814 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BS_DMA_PARTITION_0_E"
    32815 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_ADDR_DMA_PARTITION_0_E"
    32816 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_LPB_DMA_PARTITION_0_E"
    32817 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_MTMV_DMA_PARTITION_0_E"
    32818 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IED_CPU0_DMI_NONESAFE_E"
    32819 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_T_CPU0_DMI_NONESAFE_E"
    32820 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_C_CPU0_DMI_NONESAFE_E"
    32821 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_S_CPU0_DMI_NONESAFE_E"
    32822 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BI_CPU0_DMI_NONESAFE_E"
    32823 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_UNC_CPU0_DMI_NONESAFE_E"
    32824 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_SP_CPU0_DMI_NONESAFE_E"
    32825 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BS_CPU0_DMI_NONESAFE_E"
    32826 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU0_DMI_NONESAFE_E"
    32827 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_LPB_CPU0_DMI_NONESAFE_E"
    32828 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU0_DMI_NONESAFE_E"
    32829 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IED_CPU0_DMI_SAFE_E"
    32830 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_T_CPU0_DMI_SAFE_E"
    32831 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_C_CPU0_DMI_SAFE_E"
    32832 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_S_CPU0_DMI_SAFE_E"
    32833 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BI_CPU0_DMI_SAFE_E"
    32834 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_UNC_CPU0_DMI_SAFE_E"
    32835 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_SP_CPU0_DMI_SAFE_E"
    32836 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BS_CPU0_DMI_SAFE_E"
    32837 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU0_DMI_SAFE_E"
    32838 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_LPB_CPU0_DMI_SAFE_E"
    32839 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU0_DMI_SAFE_E"
    32840 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IED_HSMCMI_HSMRMI_E"
    32841 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_T_HSMCMI_HSMRMI_E"
    32842 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_C_HSMCMI_HSMRMI_E"
    32843 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_S_HSMCMI_HSMRMI_E"
    32844 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BI_HSMCMI_HSMRMI_E"
    32845 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_UNC_HSMCMI_HSMRMI_E"
    32846 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_SP_HSMCMI_HSMRMI_E"
    32847 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BS_HSMCMI_HSMRMI_E"
    32848 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_ADDR_HSMCMI_HSMRMI_E"
    32849 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_LPB_HSMCMI_HSMRMI_E"
    32850 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_MTMV_HSMCMI_HSMRMI_E"
    32851 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IED_DMA_PARTITION_1_E"
    32852 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_T_DMA_PARTITION_1_E"
    32853 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_C_DMA_PARTITION_1_E"
    32854 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_S_DMA_PARTITION_1_E"
    32855 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BI_DMA_PARTITION_1_E"
    32856 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_UNC_DMA_PARTITION_1_E"
    32857 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_SP_DMA_PARTITION_1_E"
    32858 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BS_DMA_PARTITION_1_E"
    32859 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_ADDR_DMA_PARTITION_1_E"
    32860 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_LPB_DMA_PARTITION_1_E"
    32861 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_MTMV_DMA_PARTITION_1_E"
    32862 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IED_CPU1_DMI_NONESAFE_E"
    32863 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_T_CPU1_DMI_NONESAFE_E"
    32864 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_C_CPU1_DMI_NONESAFE_E"
    32865 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_S_CPU1_DMI_NONESAFE_E"
    32866 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BI_CPU1_DMI_NONESAFE_E"
    32867 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_UNC_CPU1_DMI_NONESAFE_E"
    32868 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_SP_CPU1_DMI_NONESAFE_E"
    32869 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BS_CPU1_DMI_NONESAFE_E"
    32870 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU1_DMI_NONESAFE_E"
    32871 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_LPB_CPU1_DMI_NONESAFE_E"
    32872 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU1_DMI_NONESAFE_E"
    32873 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IED_CPU1_DMI_SAFE_E"
    32874 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_T_CPU1_DMI_SAFE_E"
    32875 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_C_CPU1_DMI_SAFE_E"
    32876 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_S_CPU1_DMI_SAFE_E"
    32877 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BI_CPU1_DMI_SAFE_E"
    32878 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_UNC_CPU1_DMI_SAFE_E"
    32879 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_SP_CPU1_DMI_SAFE_E"
    32880 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BS_CPU1_DMI_SAFE_E"
    32881 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU1_DMI_SAFE_E"
    32882 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_LPB_CPU1_DMI_SAFE_E"
    32883 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU1_DMI_SAFE_E"
    32884 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IED_SDMMC_E"
    32885 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_T_SDMMC_E"
    32886 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_C_SDMMC_E"
    32887 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_S_SDMMC_E"
    32888 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BI_SDMMC_E"
    32889 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_UNC_SDMMC_E"
    32890 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_SP_SDMMC_E"
    32891 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BS_SDMMC_E"
    32892 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_ADDR_SDMMC_E"
    32893 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_LPB_SDMMC_E"
    32894 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_MTMV_SDMMC_E"
    32895 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IED_DMA_PARTITION_2_E"
    32896 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_T_DMA_PARTITION_2_E"
    32897 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_C_DMA_PARTITION_2_E"
    32898 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_S_DMA_PARTITION_2_E"
    32899 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BI_DMA_PARTITION_2_E"
    32900 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_UNC_DMA_PARTITION_2_E"
    32901 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_SP_DMA_PARTITION_2_E"
    32902 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BS_DMA_PARTITION_2_E"
    32903 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_ADDR_DMA_PARTITION_2_E"
    32904 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_LPB_DMA_PARTITION_2_E"
    32905 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_MTMV_DMA_PARTITION_2_E"
    32906 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IED_CPU2_DMI_NONESAFE_E"
    32907 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_T_CPU2_DMI_NONESAFE_E"
    32908 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_C_CPU2_DMI_NONESAFE_E"
    32909 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_S_CPU2_DMI_NONESAFE_E"
    32910 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BI_CPU2_DMI_NONESAFE_E"
    32911 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_UNC_CPU2_DMI_NONESAFE_E"
    32912 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_SP_CPU2_DMI_NONESAFE_E"
    32913 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BS_CPU2_DMI_NONESAFE_E"
    32914 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU2_DMI_NONESAFE_E"
    32915 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_LPB_CPU2_DMI_NONESAFE_E"
    32916 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU2_DMI_NONESAFE_E"
    32917 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IED_CPU2_DMI_SAFE_E"
    32918 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_T_CPU2_DMI_SAFE_E"
    32919 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_C_CPU2_DMI_SAFE_E"
    32920 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_S_CPU2_DMI_SAFE_E"
    32921 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BI_CPU2_DMI_SAFE_E"
    32922 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_UNC_CPU2_DMI_SAFE_E"
    32923 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_SP_CPU2_DMI_SAFE_E"
    32924 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BS_CPU2_DMI_SAFE_E"
    32925 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU2_DMI_SAFE_E"
    32926 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_LPB_CPU2_DMI_SAFE_E"
    32927 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU2_DMI_SAFE_E"
    32928 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IED_HSSL0_E"
    32929 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_T_HSSL0_E"
    32930 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_C_HSSL0_E"
    32931 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_S_HSSL0_E"
    32932 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BI_HSSL0_E"
    32933 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_UNC_HSSL0_E"
    32934 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_SP_HSSL0_E"
    32935 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BS_HSSL0_E"
    32936 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_ADDR_HSSL0_E"
    32937 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_LPB_HSSL0_E"
    32938 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_MTMV_HSSL0_E"
    32939 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IED_DMA_PARTITION_3_E"
    32940 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_T_DMA_PARTITION_3_E"
    32941 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_C_DMA_PARTITION_3_E"
    32942 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_S_DMA_PARTITION_3_E"
    32943 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BI_DMA_PARTITION_3_E"
    32944 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_UNC_DMA_PARTITION_3_E"
    32945 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_SP_DMA_PARTITION_3_E"
    32946 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BS_DMA_PARTITION_3_E"
    32947 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_ADDR_DMA_PARTITION_3_E"
    32948 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_LPB_DMA_PARTITION_3_E"
    32949 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_MTMV_DMA_PARTITION_3_E"
    32950 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IED_CPU3_DMI_NONESAFE_E"
    32951 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_T_CPU3_DMI_NONESAFE_E"
    32952 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_C_CPU3_DMI_NONESAFE_E"
    32953 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_S_CPU3_DMI_NONESAFE_E"
    32954 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BI_CPU3_DMI_NONESAFE_E"
    32955 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_UNC_CPU3_DMI_NONESAFE_E"
    32956 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_SP_CPU3_DMI_NONESAFE_E"
    32957 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BS_CPU3_DMI_NONESAFE_E"
    32958 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU3_DMI_NONESAFE_E"
    32959 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_LPB_CPU3_DMI_NONESAFE_E"
    32960 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU3_DMI_NONESAFE_E"
    32961 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IED_CPU3_DMI_SAFE_E"
    32962 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_T_CPU3_DMI_SAFE_E"
    32963 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_C_CPU3_DMI_SAFE_E"
    32964 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_S_CPU3_DMI_SAFE_E"
    32965 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BI_CPU3_DMI_SAFE_E"
    32966 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_UNC_CPU3_DMI_SAFE_E"
    32967 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_SP_CPU3_DMI_SAFE_E"
    32968 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BS_CPU3_DMI_SAFE_E"
    32969 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU3_DMI_SAFE_E"
    32970 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_LPB_CPU3_DMI_SAFE_E"
    32971 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU3_DMI_SAFE_E"
    32972 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IED_HSSL1_E"
    32973 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_T_HSSL1_E"
    32974 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_C_HSSL1_E"
    32975 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_S_HSSL1_E"
    32976 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BI_HSSL1_E"
    32977 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_UNC_HSSL1_E"
    32978 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_SP_HSSL1_E"
    32979 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BS_HSSL1_E"
    32980 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_ADDR_HSSL1_E"
    32981 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_LPB_HSSL1_E"
    32982 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_MTMV_HSSL1_E"
    32983 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IED_CPU4_DMI_NONESAFE_E"
    32984 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_T_CPU4_DMI_NONESAFE_E"
    32985 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_C_CPU4_DMI_NONESAFE_E"
    32986 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_S_CPU4_DMI_NONESAFE_E"
    32987 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BI_CPU4_DMI_NONESAFE_E"
    32988 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_UNC_CPU4_DMI_NONESAFE_E"
    32989 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_SP_CPU4_DMI_NONESAFE_E"
    32990 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BS_CPU4_DMI_NONESAFE_E"
    32991 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU4_DMI_NONESAFE_E"
    32992 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_LPB_CPU4_DMI_NONESAFE_E"
    32993 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU4_DMI_NONESAFE_E"
    32994 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IED_CPU4_DMI_SAFE_E"
    32995 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_T_CPU4_DMI_SAFE_E"
    32996 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_C_CPU4_DMI_SAFE_E"
    32997 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_S_CPU4_DMI_SAFE_E"
    32998 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BI_CPU4_DMI_SAFE_E"
    32999 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_UNC_CPU4_DMI_SAFE_E"
    33000 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_SP_CPU4_DMI_SAFE_E"
    33001 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BS_CPU4_DMI_SAFE_E"
    33002 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU4_DMI_SAFE_E"
    33003 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_LPB_CPU4_DMI_SAFE_E"
    33004 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU4_DMI_SAFE_E"
    33005 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IED_CIF1_E"
    33006 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_T_CIF1_E"
    33007 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_C_CIF1_E"
    33008 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_S_CIF1_E"
    33009 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BI_CIF1_E"
    33010 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_UNC_CIF1_E"
    33011 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_SP_CIF1_E"
    33012 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BS_CIF1_E"
    33013 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_ADDR_CIF1_E"
    33014 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_LPB_CIF1_E"
    33015 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_MTMV_CIF1_E"
    33016 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IED_CPU5_DMI_NONESAFE_E"
    33017 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_T_CPU5_DMI_NONESAFE_E"
    33018 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_C_CPU5_DMI_NONESAFE_E"
    33019 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_S_CPU5_DMI_NONESAFE_E"
    33020 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BI_CPU5_DMI_NONESAFE_E"
    33021 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_UNC_CPU5_DMI_NONESAFE_E"
    33022 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_SP_CPU5_DMI_NONESAFE_E"
    33023 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BS_CPU5_DMI_NONESAFE_E"
    33024 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU5_DMI_NONESAFE_E"
    33025 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_LPB_CPU5_DMI_NONESAFE_E"
    33026 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU5_DMI_NONESAFE_E"
    33027 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IED_CPU5_DMI_SAFE_E"
    33028 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_T_CPU5_DMI_SAFE_E"
    33029 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_C_CPU5_DMI_SAFE_E"
    33030 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_S_CPU5_DMI_SAFE_E"
    33031 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BI_CPU5_DMI_SAFE_E"
    33032 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_UNC_CPU5_DMI_SAFE_E"
    33033 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_SP_CPU5_DMI_SAFE_E"
    33034 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BS_CPU5_DMI_SAFE_E"
    33035 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU5_DMI_SAFE_E"
    33036 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_LPB_CPU5_DMI_SAFE_E"
    33037 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU5_DMI_SAFE_E"
    33038 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IED_CERBERUS_IOC32P_E"
    33039 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_T_CERBERUS_IOC32P_E"
    33040 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_C_CERBERUS_IOC32P_E"
    33041 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_S_CERBERUS_IOC32P_E"
    33042 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BI_CERBERUS_IOC32P_E"
    33043 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_UNC_CERBERUS_IOC32P_E"
    33044 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_SP_CERBERUS_IOC32P_E"
    33045 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BS_CERBERUS_IOC32P_E"
    33046 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_ADDR_CERBERUS_IOC32P_E"
    33047 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_LPB_CERBERUS_IOC32P_E"
    33048 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_MTMV_CERBERUS_IOC32P_E"
    33049 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IED_IOC32E_E"
    33050 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_T_IOC32E_E"
    33051 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_C_IOC32E_E"
    33052 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_S_IOC32E_E"
    33053 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BI_IOC32E_E"
    33054 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_UNC_IOC32E_E"
    33055 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_SP_IOC32E_E"
    33056 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BS_IOC32E_E"
    33057 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_ADDR_IOC32E_E"
    33058 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_LPB_IOC32E_E"
    33059 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_MTMV_IOC32E_E"
    33060 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IED_CPU0_PMI_PMBI_E"
    33061 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_T_CPU0_PMI_PMBI_E"
    33062 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_C_CPU0_PMI_PMBI_E"
    33063 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_S_CPU0_PMI_PMBI_E"
    33064 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BI_CPU0_PMI_PMBI_E"
    33065 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_UNC_CPU0_PMI_PMBI_E"
    33066 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_SP_CPU0_PMI_PMBI_E"
    33067 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BS_CPU0_PMI_PMBI_E"
    33068 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU0_PMI_PMBI_E"
    33069 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_LPB_CPU0_PMI_PMBI_E"
    33070 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU0_PMI_PMBI_E"
    33071 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IED_CPU1_PMI_PMBI_E"
    33072 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_T_CPU1_PMI_PMBI_E"
    33073 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_C_CPU1_PMI_PMBI_E"
    33074 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_S_CPU1_PMI_PMBI_E"
    33075 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BI_CPU1_PMI_PMBI_E"
    33076 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_UNC_CPU1_PMI_PMBI_E"
    33077 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_SP_CPU1_PMI_PMBI_E"
    33078 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BS_CPU1_PMI_PMBI_E"
    33079 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU1_PMI_PMBI_E"
    33080 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_LPB_CPU1_PMI_PMBI_E"
    33081 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU1_PMI_PMBI_E"
    33082 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IED_CPU2_PMI_PMBI_E"
    33083 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_T_CPU2_PMI_PMBI_E"
    33084 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_C_CPU2_PMI_PMBI_E"
    33085 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_S_CPU2_PMI_PMBI_E"
    33086 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BI_CPU2_PMI_PMBI_E"
    33087 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_UNC_CPU2_PMI_PMBI_E"
    33088 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_SP_CPU2_PMI_PMBI_E"
    33089 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BS_CPU2_PMI_PMBI_E"
    33090 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU2_PMI_PMBI_E"
    33091 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_LPB_CPU2_PMI_PMBI_E"
    33092 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU2_PMI_PMBI_E"
    33093 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IED_CPU3_PMI_PMBI_E"
    33094 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_T_CPU3_PMI_PMBI_E"
    33095 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_C_CPU3_PMI_PMBI_E"
    33096 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_S_CPU3_PMI_PMBI_E"
    33097 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BI_CPU3_PMI_PMBI_E"
    33098 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_UNC_CPU3_PMI_PMBI_E"
    33099 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_SP_CPU3_PMI_PMBI_E"
    33100 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BS_CPU3_PMI_PMBI_E"
    33101 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU3_PMI_PMBI_E"
    33102 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_LPB_CPU3_PMI_PMBI_E"
    33103 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU3_PMI_PMBI_E"
    33104 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IED_CPU4_PMI_PMBI_E"
    33105 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_T_CPU4_PMI_PMBI_E"
    33106 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_C_CPU4_PMI_PMBI_E"
    33107 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_S_CPU4_PMI_PMBI_E"
    33108 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BI_CPU4_PMI_PMBI_E"
    33109 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_UNC_CPU4_PMI_PMBI_E"
    33110 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_SP_CPU4_PMI_PMBI_E"
    33111 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BS_CPU4_PMI_PMBI_E"
    33112 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU4_PMI_PMBI_E"
    33113 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_LPB_CPU4_PMI_PMBI_E"
    33114 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU4_PMI_PMBI_E"
    33115 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IED_CPU5_PMI_PMBI_E"
    33116 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_T_CPU5_PMI_PMBI_E"
    33117 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_C_CPU5_PMI_PMBI_E"
    33118 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_S_CPU5_PMI_PMBI_E"
    33119 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BI_CPU5_PMI_PMBI_E"
    33120 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_UNC_CPU5_PMI_PMBI_E"
    33121 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_SP_CPU5_PMI_PMBI_E"
    33122 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BS_CPU5_PMI_PMBI_E"
    33123 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_ADDR_CPU5_PMI_PMBI_E"
    33124 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_LPB_CPU5_PMI_PMBI_E"
    33125 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_MTMV_CPU5_PMI_PMBI_E"
    33126 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IED_GETH_DMA0_E"
    33127 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_T_GETH_DMA0_E"
    33128 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_C_GETH_DMA0_E"
    33129 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_S_GETH_DMA0_E"
    33130 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BI_GETH_DMA0_E"
    33131 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_UNC_GETH_DMA0_E"
    33132 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_SP_GETH_DMA0_E"
    33133 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BS_GETH_DMA0_E"
    33134 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_ADDR_GETH_DMA0_E"
    33135 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_LPB_GETH_DMA0_E"
    33136 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_MTMV_GETH_DMA0_E"
    33137 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IED_GETH_DMA1_E"
    33138 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_T_GETH_DMA1_E"
    33139 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_C_GETH_DMA1_E"
    33140 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_S_GETH_DMA1_E"
    33141 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BI_GETH_DMA1_E"
    33142 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_UNC_GETH_DMA1_E"
    33143 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_SP_GETH_DMA1_E"
    33144 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BS_GETH_DMA1_E"
    33145 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_ADDR_GETH_DMA1_E"
    33146 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_LPB_GETH_DMA1_E"
    33147 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_MTMV_GETH_DMA1_E"
    33148 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IED_GETH_DMA2_E"
    33149 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_T_GETH_DMA2_E"
    33150 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_C_GETH_DMA2_E"
    33151 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_S_GETH_DMA2_E"
    33152 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BI_GETH_DMA2_E"
    33153 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_UNC_GETH_DMA2_E"
    33154 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_SP_GETH_DMA2_E"
    33155 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BS_GETH_DMA2_E"
    33156 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_ADDR_GETH_DMA2_E"
    33157 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_LPB_GETH_DMA2_E"
    33158 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_MTMV_GETH_DMA2_E"
    33159 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IED_GETH_DMA3_E"
    33160 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_T_GETH_DMA3_E"
    33161 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_C_GETH_DMA3_E"
    33162 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_S_GETH_DMA3_E"
    33163 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BI_GETH_DMA3_E"
    33164 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_UNC_GETH_DMA3_E"
    33165 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_SP_GETH_DMA3_E"
    33166 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BS_GETH_DMA3_E"
    33167 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_ADDR_GETH_DMA3_E"
    33168 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_LPB_GETH_DMA3_E"
    33169 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_MTMV_GETH_DMA3_E"
    33170 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IED_DAM0_E"
    33171 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_T_DAM0_E"
    33172 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_C_DAM0_E"
    33173 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_S_DAM0_E"
    33174 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BI_DAM0_E"
    33175 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_UNC_DAM0_E"
    33176 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_SP_DAM0_E"
    33177 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BS_DAM0_E"
    33178 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_ADDR_DAM0_E"
    33179 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_LPB_DAM0_E"
    33180 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_MTMV_DAM0_E"
    33181 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IED_DAM1_E"
    33182 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_T_DAM1_E"
    33183 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_C_DAM1_E"
    33184 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_S_DAM1_E"
    33185 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BI_DAM1_E"
    33186 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_UNC_DAM1_E"
    33187 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_SP_DAM1_E"
    33188 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_BS_DAM1_E"
    33189 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_ADDR_DAM1_E"
    33190 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_LPB_DAM1_E"
    33191 "RBA_RESET_CPU3_TRAP_SYSBUSERR_PIE_IE_MTMV_DAM1_E"
    33192 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_UNKNOWN_E"
    33193 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IED_DMA_PARTITION_0_E"
    33194 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_T_DMA_PARTITION_0_E"
    33195 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_C_DMA_PARTITION_0_E"
    33196 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_S_DMA_PARTITION_0_E"
    33197 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BI_DMA_PARTITION_0_E"
    33198 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_UNC_DMA_PARTITION_0_E"
    33199 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_SP_DMA_PARTITION_0_E"
    33200 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BS_DMA_PARTITION_0_E"
    33201 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_ADDR_DMA_PARTITION_0_E"
    33202 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_LPB_DMA_PARTITION_0_E"
    33203 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_MTMV_DMA_PARTITION_0_E"
    33204 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IED_CPU0_DMI_NONESAFE_E"
    33205 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_T_CPU0_DMI_NONESAFE_E"
    33206 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_C_CPU0_DMI_NONESAFE_E"
    33207 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_S_CPU0_DMI_NONESAFE_E"
    33208 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BI_CPU0_DMI_NONESAFE_E"
    33209 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_UNC_CPU0_DMI_NONESAFE_E"
    33210 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_SP_CPU0_DMI_NONESAFE_E"
    33211 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BS_CPU0_DMI_NONESAFE_E"
    33212 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU0_DMI_NONESAFE_E"
    33213 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_LPB_CPU0_DMI_NONESAFE_E"
    33214 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU0_DMI_NONESAFE_E"
    33215 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IED_CPU0_DMI_SAFE_E"
    33216 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_T_CPU0_DMI_SAFE_E"
    33217 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_C_CPU0_DMI_SAFE_E"
    33218 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_S_CPU0_DMI_SAFE_E"
    33219 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BI_CPU0_DMI_SAFE_E"
    33220 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_UNC_CPU0_DMI_SAFE_E"
    33221 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_SP_CPU0_DMI_SAFE_E"
    33222 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BS_CPU0_DMI_SAFE_E"
    33223 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU0_DMI_SAFE_E"
    33224 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_LPB_CPU0_DMI_SAFE_E"
    33225 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU0_DMI_SAFE_E"
    33226 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IED_HSMCMI_HSMRMI_E"
    33227 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_T_HSMCMI_HSMRMI_E"
    33228 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_C_HSMCMI_HSMRMI_E"
    33229 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_S_HSMCMI_HSMRMI_E"
    33230 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BI_HSMCMI_HSMRMI_E"
    33231 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_UNC_HSMCMI_HSMRMI_E"
    33232 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_SP_HSMCMI_HSMRMI_E"
    33233 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BS_HSMCMI_HSMRMI_E"
    33234 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_ADDR_HSMCMI_HSMRMI_E"
    33235 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_LPB_HSMCMI_HSMRMI_E"
    33236 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_MTMV_HSMCMI_HSMRMI_E"
    33237 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IED_DMA_PARTITION_1_E"
    33238 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_T_DMA_PARTITION_1_E"
    33239 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_C_DMA_PARTITION_1_E"
    33240 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_S_DMA_PARTITION_1_E"
    33241 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BI_DMA_PARTITION_1_E"
    33242 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_UNC_DMA_PARTITION_1_E"
    33243 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_SP_DMA_PARTITION_1_E"
    33244 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BS_DMA_PARTITION_1_E"
    33245 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_ADDR_DMA_PARTITION_1_E"
    33246 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_LPB_DMA_PARTITION_1_E"
    33247 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_MTMV_DMA_PARTITION_1_E"
    33248 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IED_CPU1_DMI_NONESAFE_E"
    33249 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_T_CPU1_DMI_NONESAFE_E"
    33250 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_C_CPU1_DMI_NONESAFE_E"
    33251 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_S_CPU1_DMI_NONESAFE_E"
    33252 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BI_CPU1_DMI_NONESAFE_E"
    33253 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_UNC_CPU1_DMI_NONESAFE_E"
    33254 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_SP_CPU1_DMI_NONESAFE_E"
    33255 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BS_CPU1_DMI_NONESAFE_E"
    33256 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU1_DMI_NONESAFE_E"
    33257 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_LPB_CPU1_DMI_NONESAFE_E"
    33258 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU1_DMI_NONESAFE_E"
    33259 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IED_CPU1_DMI_SAFE_E"
    33260 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_T_CPU1_DMI_SAFE_E"
    33261 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_C_CPU1_DMI_SAFE_E"
    33262 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_S_CPU1_DMI_SAFE_E"
    33263 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BI_CPU1_DMI_SAFE_E"
    33264 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_UNC_CPU1_DMI_SAFE_E"
    33265 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_SP_CPU1_DMI_SAFE_E"
    33266 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BS_CPU1_DMI_SAFE_E"
    33267 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU1_DMI_SAFE_E"
    33268 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_LPB_CPU1_DMI_SAFE_E"
    33269 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU1_DMI_SAFE_E"
    33270 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IED_SDMMC_E"
    33271 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_T_SDMMC_E"
    33272 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_C_SDMMC_E"
    33273 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_S_SDMMC_E"
    33274 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BI_SDMMC_E"
    33275 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_UNC_SDMMC_E"
    33276 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_SP_SDMMC_E"
    33277 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BS_SDMMC_E"
    33278 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_ADDR_SDMMC_E"
    33279 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_LPB_SDMMC_E"
    33280 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_MTMV_SDMMC_E"
    33281 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IED_DMA_PARTITION_2_E"
    33282 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_T_DMA_PARTITION_2_E"
    33283 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_C_DMA_PARTITION_2_E"
    33284 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_S_DMA_PARTITION_2_E"
    33285 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BI_DMA_PARTITION_2_E"
    33286 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_UNC_DMA_PARTITION_2_E"
    33287 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_SP_DMA_PARTITION_2_E"
    33288 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BS_DMA_PARTITION_2_E"
    33289 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_ADDR_DMA_PARTITION_2_E"
    33290 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_LPB_DMA_PARTITION_2_E"
    33291 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_MTMV_DMA_PARTITION_2_E"
    33292 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IED_CPU2_DMI_NONESAFE_E"
    33293 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_T_CPU2_DMI_NONESAFE_E"
    33294 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_C_CPU2_DMI_NONESAFE_E"
    33295 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_S_CPU2_DMI_NONESAFE_E"
    33296 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BI_CPU2_DMI_NONESAFE_E"
    33297 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_UNC_CPU2_DMI_NONESAFE_E"
    33298 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_SP_CPU2_DMI_NONESAFE_E"
    33299 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BS_CPU2_DMI_NONESAFE_E"
    33300 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU2_DMI_NONESAFE_E"
    33301 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_LPB_CPU2_DMI_NONESAFE_E"
    33302 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU2_DMI_NONESAFE_E"
    33303 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IED_CPU2_DMI_SAFE_E"
    33304 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_T_CPU2_DMI_SAFE_E"
    33305 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_C_CPU2_DMI_SAFE_E"
    33306 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_S_CPU2_DMI_SAFE_E"
    33307 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BI_CPU2_DMI_SAFE_E"
    33308 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_UNC_CPU2_DMI_SAFE_E"
    33309 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_SP_CPU2_DMI_SAFE_E"
    33310 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BS_CPU2_DMI_SAFE_E"
    33311 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU2_DMI_SAFE_E"
    33312 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_LPB_CPU2_DMI_SAFE_E"
    33313 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU2_DMI_SAFE_E"
    33314 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IED_HSSL0_E"
    33315 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_T_HSSL0_E"
    33316 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_C_HSSL0_E"
    33317 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_S_HSSL0_E"
    33318 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BI_HSSL0_E"
    33319 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_UNC_HSSL0_E"
    33320 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_SP_HSSL0_E"
    33321 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BS_HSSL0_E"
    33322 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_ADDR_HSSL0_E"
    33323 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_LPB_HSSL0_E"
    33324 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_MTMV_HSSL0_E"
    33325 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IED_DMA_PARTITION_3_E"
    33326 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_T_DMA_PARTITION_3_E"
    33327 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_C_DMA_PARTITION_3_E"
    33328 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_S_DMA_PARTITION_3_E"
    33329 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BI_DMA_PARTITION_3_E"
    33330 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_UNC_DMA_PARTITION_3_E"
    33331 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_SP_DMA_PARTITION_3_E"
    33332 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BS_DMA_PARTITION_3_E"
    33333 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_ADDR_DMA_PARTITION_3_E"
    33334 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_LPB_DMA_PARTITION_3_E"
    33335 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_MTMV_DMA_PARTITION_3_E"
    33336 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IED_CPU3_DMI_NONESAFE_E"
    33337 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_T_CPU3_DMI_NONESAFE_E"
    33338 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_C_CPU3_DMI_NONESAFE_E"
    33339 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_S_CPU3_DMI_NONESAFE_E"
    33340 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BI_CPU3_DMI_NONESAFE_E"
    33341 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_UNC_CPU3_DMI_NONESAFE_E"
    33342 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_SP_CPU3_DMI_NONESAFE_E"
    33343 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BS_CPU3_DMI_NONESAFE_E"
    33344 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU3_DMI_NONESAFE_E"
    33345 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_LPB_CPU3_DMI_NONESAFE_E"
    33346 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU3_DMI_NONESAFE_E"
    33347 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IED_CPU3_DMI_SAFE_E"
    33348 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_T_CPU3_DMI_SAFE_E"
    33349 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_C_CPU3_DMI_SAFE_E"
    33350 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_S_CPU3_DMI_SAFE_E"
    33351 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BI_CPU3_DMI_SAFE_E"
    33352 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_UNC_CPU3_DMI_SAFE_E"
    33353 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_SP_CPU3_DMI_SAFE_E"
    33354 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BS_CPU3_DMI_SAFE_E"
    33355 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU3_DMI_SAFE_E"
    33356 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_LPB_CPU3_DMI_SAFE_E"
    33357 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU3_DMI_SAFE_E"
    33358 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IED_HSSL1_E"
    33359 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_T_HSSL1_E"
    33360 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_C_HSSL1_E"
    33361 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_S_HSSL1_E"
    33362 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BI_HSSL1_E"
    33363 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_UNC_HSSL1_E"
    33364 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_SP_HSSL1_E"
    33365 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BS_HSSL1_E"
    33366 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_ADDR_HSSL1_E"
    33367 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_LPB_HSSL1_E"
    33368 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_MTMV_HSSL1_E"
    33369 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IED_CPU4_DMI_NONESAFE_E"
    33370 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_T_CPU4_DMI_NONESAFE_E"
    33371 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_C_CPU4_DMI_NONESAFE_E"
    33372 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_S_CPU4_DMI_NONESAFE_E"
    33373 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BI_CPU4_DMI_NONESAFE_E"
    33374 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_UNC_CPU4_DMI_NONESAFE_E"
    33375 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_SP_CPU4_DMI_NONESAFE_E"
    33376 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BS_CPU4_DMI_NONESAFE_E"
    33377 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU4_DMI_NONESAFE_E"
    33378 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_LPB_CPU4_DMI_NONESAFE_E"
    33379 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU4_DMI_NONESAFE_E"
    33380 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IED_CPU4_DMI_SAFE_E"
    33381 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_T_CPU4_DMI_SAFE_E"
    33382 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_C_CPU4_DMI_SAFE_E"
    33383 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_S_CPU4_DMI_SAFE_E"
    33384 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BI_CPU4_DMI_SAFE_E"
    33385 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_UNC_CPU4_DMI_SAFE_E"
    33386 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_SP_CPU4_DMI_SAFE_E"
    33387 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BS_CPU4_DMI_SAFE_E"
    33388 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU4_DMI_SAFE_E"
    33389 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_LPB_CPU4_DMI_SAFE_E"
    33390 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU4_DMI_SAFE_E"
    33391 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IED_CIF1_E"
    33392 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_T_CIF1_E"
    33393 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_C_CIF1_E"
    33394 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_S_CIF1_E"
    33395 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BI_CIF1_E"
    33396 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_UNC_CIF1_E"
    33397 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_SP_CIF1_E"
    33398 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BS_CIF1_E"
    33399 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_ADDR_CIF1_E"
    33400 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_LPB_CIF1_E"
    33401 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_MTMV_CIF1_E"
    33402 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IED_CPU5_DMI_NONESAFE_E"
    33403 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_T_CPU5_DMI_NONESAFE_E"
    33404 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_C_CPU5_DMI_NONESAFE_E"
    33405 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_S_CPU5_DMI_NONESAFE_E"
    33406 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BI_CPU5_DMI_NONESAFE_E"
    33407 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_UNC_CPU5_DMI_NONESAFE_E"
    33408 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_SP_CPU5_DMI_NONESAFE_E"
    33409 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BS_CPU5_DMI_NONESAFE_E"
    33410 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU5_DMI_NONESAFE_E"
    33411 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_LPB_CPU5_DMI_NONESAFE_E"
    33412 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU5_DMI_NONESAFE_E"
    33413 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IED_CPU5_DMI_SAFE_E"
    33414 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_T_CPU5_DMI_SAFE_E"
    33415 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_C_CPU5_DMI_SAFE_E"
    33416 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_S_CPU5_DMI_SAFE_E"
    33417 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BI_CPU5_DMI_SAFE_E"
    33418 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_UNC_CPU5_DMI_SAFE_E"
    33419 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_SP_CPU5_DMI_SAFE_E"
    33420 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BS_CPU5_DMI_SAFE_E"
    33421 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU5_DMI_SAFE_E"
    33422 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_LPB_CPU5_DMI_SAFE_E"
    33423 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU5_DMI_SAFE_E"
    33424 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IED_CERBERUS_IOC32P_E"
    33425 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_T_CERBERUS_IOC32P_E"
    33426 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_C_CERBERUS_IOC32P_E"
    33427 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_S_CERBERUS_IOC32P_E"
    33428 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BI_CERBERUS_IOC32P_E"
    33429 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_UNC_CERBERUS_IOC32P_E"
    33430 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_SP_CERBERUS_IOC32P_E"
    33431 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BS_CERBERUS_IOC32P_E"
    33432 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_ADDR_CERBERUS_IOC32P_E"
    33433 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_LPB_CERBERUS_IOC32P_E"
    33434 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_MTMV_CERBERUS_IOC32P_E"
    33435 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IED_IOC32E_E"
    33436 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_T_IOC32E_E"
    33437 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_C_IOC32E_E"
    33438 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_S_IOC32E_E"
    33439 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BI_IOC32E_E"
    33440 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_UNC_IOC32E_E"
    33441 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_SP_IOC32E_E"
    33442 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BS_IOC32E_E"
    33443 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_ADDR_IOC32E_E"
    33444 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_LPB_IOC32E_E"
    33445 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_MTMV_IOC32E_E"
    33446 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IED_CPU0_PMI_PMBI_E"
    33447 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_T_CPU0_PMI_PMBI_E"
    33448 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_C_CPU0_PMI_PMBI_E"
    33449 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_S_CPU0_PMI_PMBI_E"
    33450 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BI_CPU0_PMI_PMBI_E"
    33451 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_UNC_CPU0_PMI_PMBI_E"
    33452 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_SP_CPU0_PMI_PMBI_E"
    33453 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BS_CPU0_PMI_PMBI_E"
    33454 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU0_PMI_PMBI_E"
    33455 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_LPB_CPU0_PMI_PMBI_E"
    33456 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU0_PMI_PMBI_E"
    33457 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IED_CPU1_PMI_PMBI_E"
    33458 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_T_CPU1_PMI_PMBI_E"
    33459 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_C_CPU1_PMI_PMBI_E"
    33460 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_S_CPU1_PMI_PMBI_E"
    33461 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BI_CPU1_PMI_PMBI_E"
    33462 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_UNC_CPU1_PMI_PMBI_E"
    33463 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_SP_CPU1_PMI_PMBI_E"
    33464 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BS_CPU1_PMI_PMBI_E"
    33465 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU1_PMI_PMBI_E"
    33466 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_LPB_CPU1_PMI_PMBI_E"
    33467 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU1_PMI_PMBI_E"
    33468 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IED_CPU2_PMI_PMBI_E"
    33469 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_T_CPU2_PMI_PMBI_E"
    33470 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_C_CPU2_PMI_PMBI_E"
    33471 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_S_CPU2_PMI_PMBI_E"
    33472 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BI_CPU2_PMI_PMBI_E"
    33473 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_UNC_CPU2_PMI_PMBI_E"
    33474 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_SP_CPU2_PMI_PMBI_E"
    33475 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BS_CPU2_PMI_PMBI_E"
    33476 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU2_PMI_PMBI_E"
    33477 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_LPB_CPU2_PMI_PMBI_E"
    33478 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU2_PMI_PMBI_E"
    33479 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IED_CPU3_PMI_PMBI_E"
    33480 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_T_CPU3_PMI_PMBI_E"
    33481 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_C_CPU3_PMI_PMBI_E"
    33482 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_S_CPU3_PMI_PMBI_E"
    33483 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BI_CPU3_PMI_PMBI_E"
    33484 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_UNC_CPU3_PMI_PMBI_E"
    33485 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_SP_CPU3_PMI_PMBI_E"
    33486 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BS_CPU3_PMI_PMBI_E"
    33487 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU3_PMI_PMBI_E"
    33488 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_LPB_CPU3_PMI_PMBI_E"
    33489 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU3_PMI_PMBI_E"
    33490 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IED_CPU4_PMI_PMBI_E"
    33491 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_T_CPU4_PMI_PMBI_E"
    33492 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_C_CPU4_PMI_PMBI_E"
    33493 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_S_CPU4_PMI_PMBI_E"
    33494 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BI_CPU4_PMI_PMBI_E"
    33495 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_UNC_CPU4_PMI_PMBI_E"
    33496 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_SP_CPU4_PMI_PMBI_E"
    33497 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BS_CPU4_PMI_PMBI_E"
    33498 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU4_PMI_PMBI_E"
    33499 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_LPB_CPU4_PMI_PMBI_E"
    33500 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU4_PMI_PMBI_E"
    33501 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IED_CPU5_PMI_PMBI_E"
    33502 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_T_CPU5_PMI_PMBI_E"
    33503 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_C_CPU5_PMI_PMBI_E"
    33504 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_S_CPU5_PMI_PMBI_E"
    33505 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BI_CPU5_PMI_PMBI_E"
    33506 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_UNC_CPU5_PMI_PMBI_E"
    33507 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_SP_CPU5_PMI_PMBI_E"
    33508 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BS_CPU5_PMI_PMBI_E"
    33509 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_ADDR_CPU5_PMI_PMBI_E"
    33510 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_LPB_CPU5_PMI_PMBI_E"
    33511 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_MTMV_CPU5_PMI_PMBI_E"
    33512 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IED_GETH_DMA0_E"
    33513 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_T_GETH_DMA0_E"
    33514 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_C_GETH_DMA0_E"
    33515 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_S_GETH_DMA0_E"
    33516 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BI_GETH_DMA0_E"
    33517 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_UNC_GETH_DMA0_E"
    33518 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_SP_GETH_DMA0_E"
    33519 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BS_GETH_DMA0_E"
    33520 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_ADDR_GETH_DMA0_E"
    33521 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_LPB_GETH_DMA0_E"
    33522 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_MTMV_GETH_DMA0_E"
    33523 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IED_GETH_DMA1_E"
    33524 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_T_GETH_DMA1_E"
    33525 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_C_GETH_DMA1_E"
    33526 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_S_GETH_DMA1_E"
    33527 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BI_GETH_DMA1_E"
    33528 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_UNC_GETH_DMA1_E"
    33529 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_SP_GETH_DMA1_E"
    33530 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BS_GETH_DMA1_E"
    33531 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_ADDR_GETH_DMA1_E"
    33532 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_LPB_GETH_DMA1_E"
    33533 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_MTMV_GETH_DMA1_E"
    33534 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IED_GETH_DMA2_E"
    33535 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_T_GETH_DMA2_E"
    33536 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_C_GETH_DMA2_E"
    33537 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_S_GETH_DMA2_E"
    33538 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BI_GETH_DMA2_E"
    33539 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_UNC_GETH_DMA2_E"
    33540 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_SP_GETH_DMA2_E"
    33541 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BS_GETH_DMA2_E"
    33542 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_ADDR_GETH_DMA2_E"
    33543 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_LPB_GETH_DMA2_E"
    33544 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_MTMV_GETH_DMA2_E"
    33545 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IED_GETH_DMA3_E"
    33546 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_T_GETH_DMA3_E"
    33547 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_C_GETH_DMA3_E"
    33548 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_S_GETH_DMA3_E"
    33549 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BI_GETH_DMA3_E"
    33550 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_UNC_GETH_DMA3_E"
    33551 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_SP_GETH_DMA3_E"
    33552 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BS_GETH_DMA3_E"
    33553 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_ADDR_GETH_DMA3_E"
    33554 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_LPB_GETH_DMA3_E"
    33555 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_MTMV_GETH_DMA3_E"
    33556 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IED_DAM0_E"
    33557 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_T_DAM0_E"
    33558 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_C_DAM0_E"
    33559 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_S_DAM0_E"
    33560 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BI_DAM0_E"
    33561 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_UNC_DAM0_E"
    33562 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_SP_DAM0_E"
    33563 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BS_DAM0_E"
    33564 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_ADDR_DAM0_E"
    33565 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_LPB_DAM0_E"
    33566 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_MTMV_DAM0_E"
    33567 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IED_DAM1_E"
    33568 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_T_DAM1_E"
    33569 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_C_DAM1_E"
    33570 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_S_DAM1_E"
    33571 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BI_DAM1_E"
    33572 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_UNC_DAM1_E"
    33573 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_SP_DAM1_E"
    33574 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_BS_DAM1_E"
    33575 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_ADDR_DAM1_E"
    33576 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_LPB_DAM1_E"
    33577 "RBA_RESET_CPU3_TRAP_SYSBUSERR_DIE_IE_MTMV_DAM1_E"
    33578 "RBA_RESET_CPU3_TRAP_TCN4_UNKNOWN_E"
    33579 "RBA_RESET_CPU3_TRAP_TCN5_TIN0_E"
    33580 "RBA_RESET_CPU3_TRAP_ASSTRAP_OVF_E"
    33581 "RBA_RESET_CPU3_TRAP_ASSTRAP_SOVF_E"
    33582 "RBA_RESET_CPU3_TRAP_TCN5_UNKNOWN_E"
    33583 "RBA_RESET_CPU3_TRAP_SYSCALL_SYS_E"
    33584 "RBA_RESET_CPU3_TRAP_NMI_UNKNOWN_E"
    33585 "RBA_RESET_CPU3_TRAP_NMI_ESR0_E"
    33586 "RBA_RESET_CPU3_TRAP_NMI_ESR1_E"
    33587 "RBA_RESET_CPU3_TRAP_NMI_SMUT_E"
    33588 "RBA_RESET_CPU3_TRAP_NMI_SMU_CPU0_MPU_E"
    33589 "RBA_RESET_CPU3_TRAP_NMI_SMU_CPU1_MPU_E"
    33590 "RBA_RESET_CPU3_TRAP_NMI_SMU_CPU2_MPU_E"
    33591 "RBA_RESET_CPU3_TRAP_NMI_SMU_IR_E"
    33592 "RBA_RESET_CPU3_TRAP_NMI_SMU_CGU_WDT_E"
    33593 "RBA_RESET_CPU3_TRAP_NMI_SMU_CGU_PLLLOL_E"
    33594 "RBA_RESET_CPU3_TRAP_NMI_SMU_CGU_PLLERAYLOL_E"
    33595 "RBA_RESET_CPU3_TRAP_NMI_SMU_CGU_STM_E"
    33596 "RBA_RESET_CPU3_TRAP_NMI_SMU_CGU_PLLERAY_E"
    33597 "RBA_RESET_CPU3_TRAP_NMI_SMU_CGU_PLL_E"
    33598 "RBA_RESET_CPU3_TRAP_NMI_SMU_CGU_SRI_E"
    33599 "RBA_RESET_CPU3_TRAP_NMI_SMU_CGU_SPB_E"
    33600 "RBA_RESET_CPU3_TRAP_NMI_SMU_CGU_CPU0_E"
    33601 "RBA_RESET_CPU3_TRAP_NMI_SMU_SCUEVR_12UV_E"
    33602 "RBA_RESET_CPU3_TRAP_NMI_SMU_SCUEVR_12OV_E"
    33603 "RBA_RESET_CPU3_TRAP_NMI_SMU_SCUEVR_33UV_E"
    33604 "RBA_RESET_CPU3_TRAP_NMI_SMU_SCUEVR_33OV_E"
    33605 "RBA_RESET_CPU3_TRAP_NMI_SMU_SCUEVR_5UV_E"
    33606 "RBA_RESET_CPU3_TRAP_NMI_SMU_SCUEVR_5OV_E"
    33607 "RBA_RESET_CPU3_TRAP_NMI_SMU_SWDT_E"
    33608 "RBA_RESET_CPU3_TRAP_NMI_SMU_WDT0_E"
    33609 "RBA_RESET_CPU3_TRAP_NMI_SMU_WDT1_E"
    33610 "RBA_RESET_CPU3_TRAP_NMI_SMU_WDT2_E"
    33611 "RBA_RESET_CPU3_TRAP_NMI_SMU_WDT3_E"
    33612 "RBA_RESET_CPU3_TRAP_NMI_SMU_WDT4_E"
    33613 "RBA_RESET_CPU3_TRAP_NMI_SMU_WDT5_E"
    33614 "RBA_RESET_CPU3_TRAP_TCN7_UNKNOWN_E"
/end COMPU_VTAB




/begin COMPU_VTAB
    RB_RBA_rba_SvbbEtk_CompuMethods_rba_SvbbEtk_StateEnable_CM
    "CompuMethod for SvbbEtk state"
    TAB_VERB
    6
    0 "Inactive"
    1 "Waiting_for_activation"
    2 "Waiting_for_setting_of_calibration_label"
    3 "Waiting_for_stimulation_data_directly_after_reset"
    4 "Waiting_for_stimulation_data"
    5 "Stimulivalues_are_used__Processes_can_be_disabled"
/end COMPU_VTAB




/begin COMPU_VTAB
    RB_RBA_rba_SvbbEtk_CompuMethods_rba_SvbbEtk_Enable_CM
    "CompuMethod for SvbbEtk state"
    TAB_VERB
    4
    0 "Disable"
    1 "Enable_now"
    2 "Enable_always"
    3 "Enable_after_reset"
/end COMPU_VTAB




/begin COMPU_VTAB
    RB_RBA_rba_SyC_States_BswModuleDescriptions_rba_SyC_States_CompuMethod
    "CompuMethod for states in System Control"
    TAB_VERB
    8
    0 "RBA_SYC_STATES_BOOT"
    1 "RBA_SYC_STATES_INIT"
    2 "RBA_SYC_STATES_WAIT"
    3 "RBA_SYC_STATES_PREPARE_DRIVE"
    4 "RBA_SYC_STATES_PREPARE_SHUTDOWN"
    5 "RBA_SYC_STATES_DRIVE"
    6 "RBA_SYC_STATES_POSTDRIVE"
    7 "RBA_SYC_STATES_SHUTDOWN"
/end COMPU_VTAB




/begin COMPU_VTAB
    RB_RBA_rba_SyC_States_BswModuleDescriptions_rba_SyC_States_PostDrive_CompuMethod
    "CompuMethod for PostDrive state of System Control"
    TAB_VERB
    10
    0 "RBA_SYC_STATES_POSTDRIVE_NOT_ACTIVE"
    1 "RBA_SYC_STATES_POSTDRIVE_INIT"
    2 "RBA_SYC_STATES_POSTDRIVE_DIAGNOSIS_BEGIN"
    3 "RBA_SYC_STATES_POSTDRIVE_STORAGE_BEGIN"
    4 "RBA_SYC_STATES_POSTDRIVE_PROLONG"
    5 "RBA_SYC_STATES_POSTDRIVE_NETWORK"
    6 "RBA_SYC_STATES_POSTDRIVE_DIAGNOSIS_END"
    7 "RBA_SYC_STATES_POSTDRIVE_STORAGE_END"
    8 "RBA_SYC_STATES_POSTDRIVE_DELAY"
    9 "RBA_SYC_STATES_POSTDRIVE_FINISHED"
/end COMPU_VTAB




/begin COMPU_VTAB
    RB_RBA_rba_SyC_States_BswModuleDescriptions_rba_SyC_States_PrepareDrive_CompuMethod
    "CompuMethod for PrepareDrive state in System Control"
    TAB_VERB
    4
    0 "RBA_SYC_STATES_PREPARE_DRIVE_NOT_ACTIVE"
    1 "RBA_SYC_STATES_PREPARE_DRIVE_INIT"
    2 "RBA_SYC_STATES_PREPARE_DRIVE_MAINRELAY"
    3 "RBA_SYC_STATES_PREPARE_DRIVE_FINISHED"
/end COMPU_VTAB




/begin COMPU_VTAB
    RB_RBA_rba_SyC_States_BswModuleDescriptions_rba_SyC_States_PrepareShutdown_CompuMethod
    "CompuMethod for PrepareShutdown state in System Control"
    TAB_VERB
    7
    0 "RBA_SYC_STATES_PREPARE_SHUTDOWN_NOT_ACTIVE"
    1 "RBA_SYC_STATES_PREPARE_SHUTDOWN_INIT"
    2 "RBA_SYC_STATES_PREPARE_SHUTDOWN_MAINRELAY"
    3 "RBA_SYC_STATES_PREPARE_SHUTDOWN_DIAGNOSIS"
    4 "RBA_SYC_STATES_PREPARE_SHUTDOWN_STORAGE"
    5 "RBA_SYC_STATES_PREPARE_SHUTDOWN_DELAY"
    6 "RBA_SYC_STATES_PREPARE_SHUTDOWN_FINISHED"
/end COMPU_VTAB




/begin COMPU_VTAB
    RB_RBA_rba_SyC_States_BswModuleDescriptions_rba_SyC_States_Wait_CompuMethod
    "CompuMethod for Wait state in System Control"
    TAB_VERB
    6
    0 "RBA_SYC_STATES_WAIT_NOT_ACTIVE"
    1 "RBA_SYC_STATES_WAIT_INIT"
    2 "RBA_SYC_STATES_WAIT_PROLONG"
    3 "RBA_SYC_STATES_WAIT_NETWORK"
    4 "RBA_SYC_STATES_WAIT_DELAY"
    5 "RBA_SYC_STATES_WAIT_FINISHED"
/end COMPU_VTAB




/begin COMPU_VTAB
    RB_RBA_rba_T15_BswModuleDescriptions_rba_T15_Signal_Status_CompuMethod
    "CompuMethod for signal status of Terminal 15"
    TAB_VERB
    2
    0 "rba_T15_Signal_Off_e"
    1 "rba_T15_Signal_On_e"
/end COMPU_VTAB




/begin COMPU_VTAB
    RB_RBA_rba_T15_BswModuleDescriptions_rba_T15_Signal_StatusValid_CompuMethod
    "CompuMethod for signal status validity of Terminal 15"
    TAB_VERB
    2
    0 "rba_T15_Signal_InValid_e"
    1 "rba_T15_Signal_Valid_e"
/end COMPU_VTAB




/begin COMPU_VTAB
    TimedCom_HrmcCh_StMac_COMPU_VERB
    "Mapping for enum TimedCom_HrmcCh_StMac"
    TAB_VERB
    5
    0 "HRMCCH_UNINI"
    1 "HRMCCH_PROC_ACTV"
    2 "HRMCCH_PROC_CMPL"
    3 "HRMCCH_TRANS_ACTV"
    4 "HRMCCH_TRANS_CMPL"
/end COMPU_VTAB




/begin COMPU_VTAB
    TimedCom_HrmcCh_Err_COMPU_VERB
    "Mapping for enum TimedCom_HrmcCh_Err"
    TAB_VERB
    9
    0 "HRMCCH_ERR_OK"
    1 "HRMCCH_ERR_INI_FAILED"
    2 "HRMCCH_ERR_ILLEGAL_ST_VAL"
    3 "HRMCCH_ERR_NO_TRANS_IN_LAST_CYCLE"
    4 "HRMCCH_ERR_TRANS_IS_NOT_FINISHED"
    5 "HRMCCH_ERR_SRC_TASKSKIP"
    6 "HRMCCH_ERR_DEST_TASKSKIP"
    7 "HRMCCH_ERR_ILLEGAL_DMA_ID"
    8 "HRMCCH_ERR_DMA_TRANS_FAILED"
/end COMPU_VTAB




/begin COMPU_VTAB
    TimedCom_AsyncCh_StMac_COMPU_VERB
    "Mapping for enum TimedCom_AsyncCh_StMac"
    TAB_VERB
    5
    0 "ASYNCCH_UNINI"
    1 "ASYNCCH_PROC_ACTV"
    2 "ASYNCCH_PROC_CMPL"
    3 "ASYNCCH_TRANS_ACTV"
    4 "ASYNCCH_TRANS_CMPL"
/end COMPU_VTAB




/begin COMPU_VTAB
    TimedCom_AsyncCh_Err_COMPU_VERB
    "Mapping for enum TimedCom_AsyncCh_Err"
    TAB_VERB
    8
    0 "ASYNCCH_ERR_OK"
    1 "ASYNCCH_ERR_INI_FAILED"
    2 "ASYNCCH_ERR_SRC_STRT_BEFORE_INI"
    3 "ASYNCCH_ERR_DEST_START_BEFORE_INI"
    4 "ASYNCCH_ERR_MULTIPLE_INI"
    5 "ASYNCCH_ERR_ILLEGAL_STATE_VALUE"
    6 "ASYNCCH_ERR_IDX_NOT_IN_RANGE"
    7 "ASYNCCH_ERR_NO_FREE_BUFFER"
/end COMPU_VTAB



/***********   End of merged COMPU_VTAB blocks    ***********/
/begin COMPU_VTAB

    ACCHRGRINTKT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    ACCIMass
    ""
    RAT_FUNC
    "%6.2"
    "kg"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    ACTRLIB_IINITSPEZIAL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ACTRLIB_IINITSPEZIAL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ACTRLIB_IINITSPEZIAL_SY_Compu
    ""
    TAB_VERB
    2
    0 "FALSE"
    1 "TRUE"


/end COMPU_VTAB

/begin COMPU_METHOD
    ADDLEONV_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ADDLEONV_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ADDLEONV_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    AFSP_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF AFSP_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    AFSP_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    AFST_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF AFST_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    AFST_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    AFST_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF AFST_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    AFST_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    AirFlRat
    ""
    RAT_FUNC
    "%6.4"
    "-"

    COEFFS 0 200 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    AIRHUMT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF AIRHUMT_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    AIRHUMT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    AirMassPerCyl
    ""
    RAT_FUNC
    "%6.3"
    "mg/Hub"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    AirMassPerTime_2
    ""
    RAT_FUNC
    "%7.6"
    "g/s"

    COEFFS 0 31250 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    AirMsPrTime_q0p0003_COMPU
    ""
    RAT_FUNC
    "%6.5"
    "g/s"

    COEFFS 0 3333.33333333333 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    AirMs_q0p1_COMPU
    ""
    RAT_FUNC
    "%6.3"
    "g"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    AIRPIN_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF AIRPIN_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    AIRPIN_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    AIRPOUT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF AIRPOUT_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    AIRPOUT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    AirSysDdT_ms
    ""
    RAT_FUNC
    "%13.3"
    "ms"

    COEFFS 0 0 1 0 9.31322574615479e-006 0 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    AIRTIN_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF AIRTIN_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    AIRTIN_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    AIRTOUT_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF AIRTOUT_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    AIRTOUT_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    AltChpTemp_q8p0_COMPU
    ""
    RAT_FUNC
    "%6.2"
    "deg C"

    COEFFS 0 0.125 4 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    AltCrntLim_A_q0p25_COMPU
    ""
    RAT_FUNC
    "%6.3"
    "A"

    COEFFS 0 4 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    AltCrntOut_A_q0p125_COMPU
    ""
    RAT_FUNC
    "%6.3"
    "A"

    COEFFS 0 8 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    AltLd_q3p125_COMPU
    ""
    RAT_FUNC
    "%6.2"
    "%"

    COEFFS 0 0.32 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    AltVltg_V_q0p1_COMPU
    ""
    RAT_FUNC
    "%6.2"
    "V"

    COEFFS 0 10 -106 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    AMPT_NOx
    ""
    RAT_FUNC
    "%8.7"
    "g/s"

    COEFFS 0 100000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    AMPT_NOxLdUnld
    ""
    RAT_FUNC
    "%7.6"
    "g/s"

    COEFFS 0 10000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    AMPT_NOxRgn
    ""
    RAT_FUNC
    "%6.5"
    "g/s"

    COEFFS 0 2000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    AMPT_SOx1
    ""
    RAT_FUNC
    "%6.4"
    "mg/s"

    COEFFS 0 333.333333333333 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    AngleCrS
    ""
    RAT_FUNC
    "%6.4"
    "deg CrS"

    COEFFS 0 45.5111111111 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    ARBLD_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ARBLD_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ARBLD_SC_Compu
    ""
    TAB_VERB
    4
    0 "NonAR"
    1 "PCLT"
    2 "PBL"
    3 "PBS"


/end COMPU_VTAB

/begin COMPU_METHOD

    Area_cm2_float
    ""
    RAT_FUNC
    "%6.2"
    "cm*cm"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    ARVERS_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ARVERS_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ARVERS_SC_Compu
    ""
    TAB_VERB
    3
    0 "0"
    1 "1"
    2 "2"


/end COMPU_VTAB

/begin COMPU_METHOD
    ATS_BRK_APP_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ATS_BRK_APP_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ATS_BRK_APP_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    BRKBSTP2_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF BRKBSTP2_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    BRKBSTP2_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    BRKBSTP_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF BRKBSTP_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    BRKBSTP_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    BSWLIB_TRAPLOG_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF BSWLIB_TRAPLOG_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    BSWLIB_TRAPLOG_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    BSW_GENN_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF BSW_GENN_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    BSW_GENN_SC_Compu
    ""
    TAB_VERB
    2
    0 "CUBAS_GEN5"
    1 "AR_CLASSIC_GEN6"


/end COMPU_VTAB

/begin COMPU_METHOD
    BYPASS_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF BYPASS_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    BYPASS_SY_Compu
    ""
    TAB_VERB
    2
    0 "No Bypass"
    1 "Bypass"


/end COMPU_VTAB

/begin COMPU_METHOD
    B_TRUE
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF B_TRUE
    
/end COMPU_METHOD

/begin COMPU_VTAB

    B_TRUE
    ""
    TAB_VERB
    2
    0 "FALSE"
    1 "TRUE"


/end COMPU_VTAB

/begin COMPU_METHOD
    CACDSPLP_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CACDSPLP_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CACDSPLP_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    CACDSP_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CACDSP_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CACDSP_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    CACDSTLP_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CACDSTLP_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CACDSTLP_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    CACDST_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CACDST_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CACDST_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    CACUSP_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CACUSP_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CACUSP_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    CACUST_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CACUST_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CACUST_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    CALWUP_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CALWUP_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CALWUP_SY_Compu
    ""
    TAB_VERB
    2
    0 "no calibration wake up"
    1 "calibration wake up"


/end COMPU_VTAB

/begin COMPU_METHOD
    CAMSFT_ACTRINTKB2_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CAMSFT_ACTRINTKB2_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CAMSFT_ACTRINTKB2_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    CAMSFT_ACTROUTLB2_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CAMSFT_ACTROUTLB2_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CAMSFT_ACTROUTLB2_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    CAMSFT_ADPNCLB_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CAMSFT_ADPNCLB_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CAMSFT_ADPNCLB_SC_Compu
    ""
    TAB_VERB
    2
    0 "OFF"
    1 "ON"


/end COMPU_VTAB

/begin COMPU_METHOD
    CAMSFT_LOCKDIAGINTK_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CAMSFT_LOCKDIAGINTK_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CAMSFT_LOCKDIAGINTK_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    CAMSFT_LOCKDIAGOUTL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CAMSFT_LOCKDIAGOUTL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CAMSFT_LOCKDIAGOUTL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    CAMSFT_VARIINTK_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CAMSFT_VARIINTK_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CAMSFT_VARIINTK_SC_Compu
    ""
    TAB_VERB
    3
    0 "NoShft"
    1 "2PtShft"
    2 "ContShft"


/end COMPU_VTAB

/begin COMPU_METHOD
    CAMSFT_VARIOUTL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CAMSFT_VARIOUTL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CAMSFT_VARIOUTL_SC_Compu
    ""
    TAB_VERB
    3
    0 "NoShft"
    1 "2PtShft"
    2 "ContShft"


/end COMPU_VTAB

/begin COMPU_METHOD
    CANIPCORETYPE_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CANIPCORETYPE_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CANIPCORETYPE_SC_Compu
    ""
    TAB_VERB
    2
    0 "0"
    1 "1"


/end COMPU_VTAB

/begin COMPU_METHOD
    CANNM_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CANNM_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CANNM_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    CANSM_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CANSM_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CANSM_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    CANTP_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CANTP_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CANTP_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    CANTSYN_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CANTSYN_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CANTSYN_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    CAN_MDS_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CAN_MDS_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CAN_MDS_SC_Compu
    ""
    TAB_VERB
    2
    0 "CAN_MDS_OFF"
    1 "CAN_MDS_ON"


/end COMPU_VTAB

/begin COMPU_METHOD

    CARBMDLYR19UPD2016_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    CASI1_SSP_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CASI1_SSP_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CASI1_SSP_SY_Compu
    ""
    TAB_VERB
    4
    0 "NO_CAS_SSPMON"
    1 "SSPMON1"
    2 "SSPMON2"
    3 "SSPMON3"


/end COMPU_VTAB

/begin COMPU_METHOD
    CASI2_SSP_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CASI2_SSP_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CASI2_SSP_SY_Compu
    ""
    TAB_VERB
    4
    0 "NO_CAS_SSPMON"
    1 "SSPMON1"
    2 "SSPMON2"
    3 "SSPMON3"


/end COMPU_VTAB

/begin COMPU_METHOD
    CASO1_SSP_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CASO1_SSP_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CASO1_SSP_SY_Compu
    ""
    TAB_VERB
    4
    0 "NO_CAS_SSPMON"
    1 "SSPMON1"
    2 "SSPMON2"
    3 "SSPMON3"


/end COMPU_VTAB

/begin COMPU_METHOD
    CASO2_SSP_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CASO2_SSP_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CASO2_SSP_SY_Compu
    ""
    TAB_VERB
    4
    0 "NO_CAS_SSPMON"
    1 "SSPMON1"
    2 "SSPMON2"
    3 "SSPMON3"


/end COMPU_VTAB

/begin COMPU_METHOD
    CASTYP_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CASTYP_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CASTYP_SY_Compu
    ""
    TAB_VERB
    8
    0 "INDIVIDUAL"
    1 "CAS_GS_STD_4TOOTH"
    2 "CAS_3TOOTH"
    3 "CAS_PULSE"
    4 "CAS_HALFMOON"
    5 "CAS_5TOOH"
    6 "CAS_DS_STD_3TEETH"
    7 "CAS_3TOOTH_180_60"


/end COMPU_VTAB

/begin COMPU_METHOD
    CAS_ADAP_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CAS_ADAP_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CAS_ADAP_SY_Compu
    ""
    TAB_VERB
    4
    0 "NO_ADAP"
    1 "ADAP"
    2 "ADAP_MNTCHK"
    3 "ADAP_MNTCHK_INDEDGE"


/end COMPU_VTAB

/begin COMPU_METHOD
    CAS_ANGLE_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CAS_ANGLE_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CAS_ANGLE_SY_Compu
    ""
    TAB_VERB
    3
    0 "NO_ANGLE"
    1 "VIA_MESSAGE"
    2 "VIA_SERVICE"


/end COMPU_VTAB

/begin COMPU_METHOD
    CAS_BACKUPVAR_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CAS_BACKUPVAR_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CAS_BACKUPVAR_SY_Compu
    ""
    TAB_VERB
    3
    0 "NO_VAR"
    1 "ACC_CURVE"
    2 "CAS_START"


/end COMPU_VTAB

/begin COMPU_METHOD
    CAS_BACKUP_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CAS_BACKUP_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CAS_BACKUP_SY_Compu
    ""
    TAB_VERB
    5
    0 "NO_BACKUP"
    1 "TST_INJ"
    2 "DOUBLE_IGN"
    3 "TST_INJ_GDI"
    4 "TST_INJ_DS"


/end COMPU_VTAB

/begin COMPU_METHOD
    CAS_CY30CONF_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CAS_CY30CONF_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CAS_CY30CONF_SY_Compu
    ""
    TAB_VERB
    4
    0 "hard-wired"
    1 "CONF_TH is set from SW"
    2 "CONF_K is set from SW"
    3 "CONF_K  and CONF_TH is set from SW"


/end COMPU_VTAB

/begin COMPU_METHOD
    CAS_DIAG_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CAS_DIAG_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CAS_DIAG_SY_Compu
    ""
    TAB_VERB
    4
    0 "STD"
    1 "ADD_OFFS"
    2 "ADD_MINMAX"
    3 "ADD_IUMPR"


/end COMPU_VTAB

/begin COMPU_METHOD
    CAS_I1_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CAS_I1_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CAS_I1_SY_Compu
    ""
    TAB_VERB
    2
    0 "NO_SIGNAL"
    1 "SIGNAL_AVAILABLE"


/end COMPU_VTAB

/begin COMPU_METHOD
    CAS_I2_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CAS_I2_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CAS_I2_SY_Compu
    ""
    TAB_VERB
    2
    0 "NO_SIGNAL"
    1 "SIGNAL_AVAILABLE"


/end COMPU_VTAB

/begin COMPU_METHOD
    CAS_O1_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CAS_O1_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CAS_O1_SY_Compu
    ""
    TAB_VERB
    2
    0 "NO_SIGNAL"
    1 "SIGNAL_AVAILABLE"


/end COMPU_VTAB

/begin COMPU_METHOD
    CAS_O2_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CAS_O2_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CAS_O2_SY_Compu
    ""
    TAB_VERB
    2
    0 "NO_SIGNAL"
    1 "SIGNAL_AVAILABLE"


/end COMPU_VTAB

/begin COMPU_METHOD
    CCACHPDST_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CCACHPDST_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CCACHPDST_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    CCACLPDST_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CCACLPDST_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CCACLPDST_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    CDGEN_ENV_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CDGEN_ENV_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CDGEN_ENV_SC_Compu
    ""
    TAB_VERB
    4
    0 "CDGEN_ENV_DS"
    1 "CDGEN_ENV_GS"
    2 "CDGEN_ENV_DGS"
    3 "CDGEN_ENV_MDG"


/end COMPU_VTAB

/begin COMPU_METHOD
    CELPRJ_SIMPLEMDLENA_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CELPRJ_SIMPLEMDLENA_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CELPRJ_SIMPLEMDLENA_SC_Compu
    ""
    TAB_VERB
    2
    0 "FALSE"
    1 "TRUE"


/end COMPU_VTAB

/begin COMPU_METHOD
    CENGDST_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CENGDST_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CENGDST_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    CENGUST2_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CENGUST2_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CENGUST2_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    CENGUST_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CENGUST_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CENGUST_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    CfgRatio_Verb
    ""
    TAB_VERB
    "%2.1"
    "NO"
    COMPU_TAB_REF CfgRatio_Verb
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CfgRatio_Verb
    ""
    TAB_VERB
    40
    0 "0"
    1 "1"
    2 "2"
    3 "3"
    4 "4"
    5 "5"
    6 "6"
    7 "7"
    8 "8"
    9 "9"
    10 "10"
    11 "11"
    12 "12"
    13 "13"
    14 "14"
    15 "15"
    16 "16"
    17 "17"
    18 "18"
    19 "19"
    20 "20"
    21 "21"
    22 "22"
    23 "23"
    24 "24"
    25 "25"
    26 "26"
    27 "27"
    28 "28"
    29 "29"
    30 "30"
    31 "31"
    32 "32"
    33 "33"
    34 "34"
    35 "35"
    36 "36"
    37 "37"
    38 "38"
    39 "39"

    DEFAULT_VALUE "---"

/end COMPU_VTAB

/begin COMPU_METHOD
    CHDT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CHDT_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CHDT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    CHRCTL_EIAECD_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CHRCTL_EIAECD_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CHRCTL_EIAECD_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    CJ721_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CJ721_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CJ721_SC_Compu
    ""
    TAB_VERB
    2
    0 "no_Cj721"
    1 "one_Cj721"


/end COMPU_VTAB

/begin COMPU_METHOD
    CJ722_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CJ722_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CJ722_SC_Compu
    ""
    TAB_VERB
    2
    0 "no_Cj722"
    1 "one_Cj722"


/end COMPU_VTAB

/begin COMPU_METHOD
    CJ950_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CJ950_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CJ950_SY_Compu
    ""
    TAB_VERB
    5
    0 "NO_CJ950"
    1 "1_CJ950"
    2 "2_CJ950"
    3 "3_CJ950"
    4 "4_CJ950"


/end COMPU_VTAB

/begin COMPU_METHOD
    CJ960_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CJ960_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CJ960_SC_Compu
    ""
    TAB_VERB
    11
    0 "No CJ960"
    1 "1 CJ960"
    2 "2 CJ960"
    3 "3 CJ960"
    4 "4 CJ960"
    5 "5 CJ960"
    6 "6 CJ960"
    7 "7 CJ960"
    8 "8 CJ960"
    9 "9 CJ960"
    10 "10 CJ960"


/end COMPU_VTAB

/begin COMPU_METHOD
    CJ970_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CJ970_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CJ970_SC_Compu
    ""
    TAB_VERB
    6
    0 "0"
    1 "1"
    2 "2"
    3 "3"
    4 "4"
    5 "5"


/end COMPU_VTAB

/begin COMPU_METHOD
    CMBTYP_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CMBTYP_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CMBTYP_SY_Compu
    ""
    TAB_VERB
    2
    0 "CMBTYP_DS"
    1 "CMBTYP_GS"


/end COMPU_VTAB

/begin COMPU_METHOD
    CMPRHP2DST_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CMPRHP2DST_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CMPRHP2DST_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    CoEng_stMai_VERB
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CoEng_stMai_VERB
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CoEng_stMai_VERB
    ""
    TAB_VERB
    7
    0 "COENG_ST_STANDBY"
    4 "COENG_ST_READY"
    16 "COENG_ST_STARTING"
    64 "COENG_ST_AUTOSTOPPING"
    1024 "COENG_ST_RUNNING"
    4096 "COENG_ST_STOPPING"
    16384 "COENG_ST_FINISH"


/end COMPU_VTAB

/begin COMPU_METHOD
    CoEng_st_COMPU_VERB
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CoEng_st_COMPU_VERB
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CoEng_st_COMPU_VERB
    ""
    TAB_VERB
    6
    0 "COENG_STANDBY"
    1 "COENG_READY"
    2 "COENG_CRANKING"
    3 "COENG_RUNNING"
    4 "COENG_STOPPING"
    5 "COENG_FINISH"


/end COMPU_VTAB

/begin COMPU_METHOD

    COEOM_INJCRVMI1NUMMAP_SY_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    COEOM_INJCRVMI1NUMSWTDES_SY_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    COEOM_INJCRVPII1NUMMAP_SY_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    COEOM_INJCRVPII1NUMSWTDES_SY_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    COEOM_INJCRVPII2NUMMAP_SY_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    COEOM_INJCRVPII2NUMSWTDES_SY_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    COEOM_INJCRVPOI1NUMMAP_SY_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    COEOM_INJCRVPOI1NUMSWTDES_SY_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    COEOM_INJCRVPOI2NUMMAP_SY_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    COEOM_INJCRVPOI2NUMSWTDES_SY_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    COEOM_INJCRVPOI3NUMMAP_SY_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    COEOM_INJCRVPOI3NUMSWTDES_SY_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    COEOM_TYP_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF COEOM_TYP_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    COEOM_TYP_SY_Compu
    ""
    TAB_VERB
    2
    1 "HESRV_SNGLFLW"
    2 "HESRV_TWFLW"


/end COMPU_VTAB

/begin COMPU_METHOD
    COMDIA_RTEENA_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF COMDIA_RTEENA_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    COMDIA_RTEENA_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    COMM_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF COMM_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    COMM_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    COMVERS_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF COMVERS_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    COMVERS_SC_Compu
    ""
    TAB_VERB
    4
    0 "COMVERS_V4V5"
    1 "COMVERS_MLB"
    2 "COMVERS_MQB"
    3 "COMVERS_MLBEVO"


/end COMPU_VTAB

/begin COMPU_METHOD
    COM_ENADTCINFO_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF COM_ENADTCINFO_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    COM_ENADTCINFO_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    COM_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF COM_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    COM_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    CONDRDSFLDP_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CONDRDSFLDP_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CONDRDSFLDP_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    CONDRDSFLDT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CONDRDSFLDT_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CONDRDSFLDT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    CONDRUSCOOLTT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CONDRUSCOOLTT_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CONDRUSCOOLTT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    CONDRUSFLDT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CONDRUSFLDT_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CONDRUSFLDT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    COOLTPIN_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF COOLTPIN_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    COOLTPIN_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    COOLTPOUT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF COOLTPOUT_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    COOLTPOUT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    COOLTTIN_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF COOLTTIN_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    COOLTTIN_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    COOLTTOUT_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF COOLTTOUT_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    COOLTTOUT_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    COOLTTRADROUT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF COOLTTRADROUT_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    COOLTTRADROUT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    CPUDEVICE_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CPUDEVICE_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CPUDEVICE_SC_Compu
    ""
    TAB_VERB
    10
    0 "None"
    1 "Device1"
    2 "Device2"
    3 "Device3"
    4 "Device4"
    5 "Device5"
    13 "Device3+"
    14 "Device4+"
    15 "Device5+"
    16 "Device5_28"


/end COMPU_VTAB

/begin COMPU_METHOD
    CPUVENDOR_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CPUVENDOR_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CPUVENDOR_SC_Compu
    ""
    TAB_VERB
    4
    0 "None"
    1 "IFX"
    2 "JDP"
    3 "ST"


/end COMPU_VTAB

/begin COMPU_METHOD
    CRCSP_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CRCSP_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CRCSP_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    CRKCSPABSLT_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CRKCSPABSLT_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CRKCSPABSLT_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    CRSSENSTYP_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CRSSENSTYP_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CRSSENSTYP_SY_Compu
    ""
    TAB_VERB
    2
    0 "STD"
    1 "DGI"


/end COMPU_VTAB

/begin COMPU_METHOD
    CRSTYP_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CRSTYP_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CRSTYP_SY_Compu
    ""
    TAB_VERB
    4
    0 "SYMMETRIC_GAP"
    1 "SHORT_GAP"
    2 "CODED_GAP"
    3 "ASYMMETRIC_GAP"


/end COMPU_VTAB

/begin COMPU_METHOD
    CRS_ANGLECOR_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CRS_ANGLECOR_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CRS_ANGLECOR_SY_Compu
    ""
    TAB_VERB
    4
    0 "NO_COR"
    1 "IAS"
    2 "IAP"
    3 "IAS_IAP"


/end COMPU_VTAB

/begin COMPU_METHOD
    CRS_BACKUP_CASTYP_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CRS_BACKUP_CASTYP_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CRS_BACKUP_CASTYP_SY_Compu
    ""
    TAB_VERB
    6
    0 "ZN_PLUS_1_WHEEL"
    1 "DS_STD_WHEEL"
    2 "GS_STD_WHEEL"
    3 "HALFMOON_WHEEL"
    7 "CAS_3TOOTH_180_60"
    12 "SWTCHCAL_DS_STD_WHEEL_GS_STD_WHEEL"


/end COMPU_VTAB

/begin COMPU_METHOD
    CRS_BACKUP_DYN_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CRS_BACKUP_DYN_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CRS_BACKUP_DYN_SY_Compu
    ""
    TAB_VERB
    2
    0 "CAL_DYNCOR"
    1 "ADAP_DYNCAOR"


/end COMPU_VTAB

/begin COMPU_METHOD
    CRS_BACKUP_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CRS_BACKUP_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CRS_BACKUP_SY_Compu
    ""
    TAB_VERB
    4
    0 "NO_BCR"
    1 "BCR"
    2 "BCR_DYNCOR_START"
    3 "BCR_DYNCOR_ALWAYS"


/end COMPU_VTAB

/begin COMPU_METHOD
    CRS_CY30CONF_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CRS_CY30CONF_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CRS_CY30CONF_SY_Compu
    ""
    TAB_VERB
    4
    0 "HARD_WIRED"
    1 "CONF_TH_VIA_SW"
    2 "CONF_K_VIA_SW"
    3 "CONF_TH_K_VIA_SW"


/end COMPU_VTAB

/begin COMPU_METHOD
    CRS_DIAG_DETAIL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CRS_DIAG_DETAIL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CRS_DIAG_DETAIL_SY_Compu
    ""
    TAB_VERB
    3
    0 "NO_DETAIL"
    1 "DETAIL_ERRSIG"
    2 "DETAIL_ERRSIG_GLITCH"


/end COMPU_VTAB

/begin COMPU_METHOD
    CRS_DIAG_SYNCINJLOST_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CRS_DIAG_SYNCINJLOST_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CRS_DIAG_SYNCINJLOST_SY_Compu
    ""
    TAB_VERB
    3
    0 "NO_ADD_DIAG"
    1 "ACTIVATED"
    2 "ACTIVATED_ALL"


/end COMPU_VTAB

/begin COMPU_METHOD
    CRS_MIAP_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CRS_MIAP_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CRS_MIAP_SY_Compu
    ""
    TAB_VERB
    2
    0 "NO_COR"
    1 "MIAP"


/end COMPU_VTAB

/begin COMPU_METHOD
    CRS_SSP_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CRS_SSP_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CRS_SSP_SY_Compu
    ""
    TAB_VERB
    4
    0 "NO_CRS_SSPMON"
    1 "CRS_SSPMON1"
    2 "CRS_SSPMON2"
    3 "CRS_SSPMON3"


/end COMPU_VTAB

/begin COMPU_METHOD
    CRS_TAA_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CRS_TAA_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CRS_TAA_SY_Compu
    ""
    TAB_VERB
    3
    0 "NO_COR"
    1 "TAA"
    2 "TAA_ChkCor"


/end COMPU_VTAB

/begin COMPU_METHOD
    CRS_TOOTHAVRG_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CRS_TOOTHAVRG_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CRS_TOOTHAVRG_SY_Compu
    ""
    TAB_VERB
    2
    0 "NO_AVRG"
    1 "TOOTH_AVERAGE"


/end COMPU_VTAB

/begin COMPU_METHOD
    CRYPTOLIB_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CRYPTOLIB_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CRYPTOLIB_SC_Compu
    ""
    TAB_VERB
    2
    0 "CRYPTOLIB_RB"
    1 "CRYPTOLIB_BMW"


/end COMPU_VTAB

/begin COMPU_METHOD
    CTEGRCLRDS_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CTEGRCLRDS_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CTEGRCLRDS_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    CTEGRCLRLPUS_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CTEGRCLRLPUS_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CTEGRCLRLPUS_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    CTEGRCLRUS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CTEGRCLRUS_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CTEGRCLRUS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "0"
    1 "1"


/end COMPU_VTAB

/begin COMPU_METHOD
    CTEVCHRGRDS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CTEVCHRGRDS_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CTEVCHRGRDS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    CTEVEMDS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CTEVEMDS_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CTEVEMDS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    CTEVHTRDS_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CTEVHTRDS_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CTEVHTRDS_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    CTEVHTREXCHGDS_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CTEVHTREXCHGDS_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CTEVHTREXCHGDS_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    CTEVHTRUS_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CTEVHTRUS_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CTEVHTRUS_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    CTEVINVRUS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CTEVINVRUS_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CTEVINVRUS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    CTEVLEDS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CTEVLEDS_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CTEVLEDS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    CubMtrPerHr
    ""
    RAT_FUNC
    "%6.3"
    "m^3/h"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Curr
    ""
    RAT_FUNC
    "%6.2"
    "mA"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    CY326_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CY326_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CY326_SC_Compu
    ""
    TAB_VERB
    3
    0 "No CY326"
    1 "One CY326"
    2 "Two CY326"


/end COMPU_VTAB

/begin COMPU_METHOD
    CY327_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CY327_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CY327_SY_Compu
    ""
    TAB_VERB
    3
    0 "No CY327"
    1 "One CY327"
    2 "Two CY327"


/end COMPU_VTAB

/begin COMPU_METHOD
    CY329_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF CY329_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    CY329_SC_Compu
    ""
    TAB_VERB
    4
    0 "No CY329"
    1 "One CY329"
    2 "Two CY329"
    3 "Three CY329"


/end COMPU_VTAB

/begin COMPU_METHOD

    CYL_MAX_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    DCCHRGRINTKT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DCCHRGRINTKT_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DCCHRGRINTKT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DcmDspUds_DID_requestIBChk_Cnv
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DcmDspUds_DID_requestIBChk_Cnv
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DcmDspUds_DID_requestIBChk_Cnv
    ""
    TAB_VERB
    3
    0 "DCMDSPUDS_DID_REQUESTIBCHK_INACTIVE"
    1 "DCMDSPUDS_DID_REQUESTIBCHK_REQUESTED"
    2 "DCMDSPUDS_DID_REQUESTIBCHK_PERFORMED"


/end COMPU_VTAB

/begin COMPU_METHOD

    DDRCTime_ms
    ""
    RAT_FUNC
    "%6.1"
    "ms"

    COEFFS 0 1 0 0 0 10 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    DDRC_DTRFRZINFHEALDEB_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DDRC_DTRFRZINFHEALDEB_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DDRC_DTRFRZINFHEALDEB_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DDRC_DTRUPDSUP_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DDRC_DTRUPDSUP_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DDRC_DTRUPDSUP_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DDRC_LstRprtEve_VERB
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DDRC_LstRprtEve_VERB
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DDRC_LstRprtEve_VERB
    ""
    TAB_VERB
    5
    0 "PASSED"
    1 "FAILED"
    2 "PREPASSED"
    3 "PREFAILED"
    255 "INVALID"


/end COMPU_VTAB

/begin COMPU_METHOD
    DDRC_Ratio
    ""
    TAB_VERB
    "%6.3"
    "NO"
    COMPU_TAB_REF DDRC_Ratio
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DDRC_Ratio
    ""
    TAB_VERB
    4
    1 "Ratio1"
    2 "Ratio2"
    3 "Ratio3"
    4 "Ratio4"


/end COMPU_VTAB

/begin COMPU_METHOD
    DEDIA_DBG_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DEDIA_DBG_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DEDIA_DBG_SC_Compu
    ""
    TAB_VERB
    2
    0 "0"
    1 "1"


/end COMPU_VTAB

/begin COMPU_METHOD
    DEDIA_VRNTCONF_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DEDIA_VRNTCONF_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DEDIA_VRNTCONF_SY_Compu
    ""
    TAB_VERB
    3
    0 "DEDIA_VRNTCONF_ALL"
    1 "DEDIA_VRNTCONF_DS"
    2 "DEDIA_VRNTCONF_GS"


/end COMPU_VTAB

/begin COMPU_METHOD

    DELIB_DBG_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    DELIB_DSQACTVT_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DELIB_DSQACTVT_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DELIB_DSQACTVT_SC_Compu
    ""
    TAB_VERB
    2
    0 "Inactive"
    1 "Active"


/end COMPU_VTAB

/begin COMPU_METHOD
    DELIB_DYNSDLDEACTV_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DELIB_DYNSDLDEACTV_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DELIB_DYNSDLDEACTV_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DELIB_ELECACTRTYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DELIB_ELECACTRTYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DELIB_ELECACTRTYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DELIB_ENGDATENG_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DELIB_ENGDATENG_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DELIB_ENGDATENG_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    DELIB_FACPRECTLDWNTEMPCORRSIZECUR_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    DELIB_FACPRECTLUPTEMPCORRSIZECUR_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    DELIB_FACTQLOSSCMPSIZECUR_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    DELIB_HVDDC_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DELIB_HVDDC_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DELIB_HVDDC_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DELIB_MDLEXHSNSRAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DELIB_MDLEXHSNSRAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DELIB_MDLEXHSNSRAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    DELIB_PMINLRNSIZECUR_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    DELIB_RACTRLIM2SIZECUR_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    DELIB_RACTRLIMSIZECUR_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    DELIB_RDIAVALMINSIZECUR_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    DELIB_RPRECTLDWNMAINMAPSIZEX_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    DELIB_RPRECTLDWNMAINMAPSIZEY_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    DELIB_RPRECTLDWNMAPSIZEX_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    DELIB_RPRECTLDWNMAPSIZEY_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    DELIB_RPRECTLUPMAINMAPSIZEX_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    DELIB_RPRECTLUPMAINMAPSIZEY_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    DELIB_RPRECTLUPMAPSIZEX_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    DELIB_RPRECTLUPMAPSIZEY_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    DELIB_RPSMAXMAPSIZEX_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    DELIB_RPSMAXMAPSIZEY_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    DELIB_SENTCALULINSIZECUR_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    DELIB_SIMPLESWTAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DELIB_SIMPLESWTAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DELIB_SIMPLESWTAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "deactivated"
    1 "activated"


/end COMPU_VTAB

/begin COMPU_METHOD
    DELIB_STDACTRTYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DELIB_STDACTRTYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DELIB_STDACTRTYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DELIB_STDSENSTYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DELIB_STDSENSTYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DELIB_STDSENSTYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    DELIB_TIDIAGDISSIZECUR_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    DELIB_UTOFFSADJCLSDSIZECRV_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    DELIB_UTOFFSADJOPENDSIZECRV_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    Dem_DTCFltSt_Verb
    ""
    TAB_VERB
    "%6.3"
    "-"
    COMPU_TAB_REF Dem_DTCFltSt_Verb
    
/end COMPU_METHOD

/begin COMPU_VTAB

    Dem_DTCFltSt_Verb
    ""
    TAB_VERB
    6
    0 "IDLE"
    1 "UDS_ENTRIES_PENDING"
    2 "UDS_DTCS_PENDING"
    3 "UDS_ENTRIES_RSLT"
    4 "OBD_ENTRIES_RSLT"
    5 "UDS_DTCS_RSLT"


/end COMPU_VTAB

/begin COMPU_METHOD
    Dem_DTCGroup_Verb
    ""
    TAB_VERB
    "%6.3"
    "NO"
    COMPU_TAB_REF Dem_DTCGroup_Verb
    
/end COMPU_METHOD

/begin COMPU_VTAB

    Dem_DTCGroup_Verb
    ""
    TAB_VERB
    6
    0 "DEM_DTC_GROUP_NONE"
    1 "DEM_DTC_GROUP_EMISSION_REL"
    2 "DEM_DTC_GROUP_POWERTRAIN"
    4 "DEM_DTC_GROUP_CHASSIS"
    8 "DEM_DTC_GROUP_BODY"
    16 "DEM_DTC_GROUP_NETWORK_COM"


/end COMPU_VTAB

/begin COMPU_METHOD
    Dem_DTCSeverity_Verb
    ""
    TAB_VERB
    "%6.3"
    "-"
    COMPU_TAB_REF Dem_DTCSeverity_Verb
    
/end COMPU_METHOD

/begin COMPU_VTAB

    Dem_DTCSeverity_Verb
    ""
    TAB_VERB
    4
    0 "DEM_SEVERITY_NO_SEVERITY"
    32 "DEM_SEVERITY_MAINTENANCE_ONLY"
    64 "DEM_SEVERITY_CHECK_AT_NEXT_HALT"
    128 "DEM_SEVERITY_CHECK_IMMEDIATELY"


/end COMPU_VTAB

/begin COMPU_METHOD
    DEVLIB_4WINDIACMPNENA_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DEVLIB_4WINDIACMPNENA_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DEVLIB_4WINDIACMPNENA_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DEVLIB_ACTRPRTCMPNENA_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DEVLIB_ACTRPRTCMPNENA_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DEVLIB_ACTRPRTCMPNENA_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DEVLIB_DBG_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DEVLIB_DBG_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DEVLIB_DBG_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DEVLIB_DIACTLLINECMPNENA_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DEVLIB_DIACTLLINECMPNENA_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DEVLIB_DIACTLLINECMPNENA_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DEVLIB_HBRGENA_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DEVLIB_HBRGENA_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DEVLIB_HBRGENA_SY_Compu
    ""
    TAB_VERB
    2
    0 "0"
    1 "1"


/end COMPU_VTAB

/begin COMPU_METHOD
    DEVLIB_PHYSRNGCHK_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DEVLIB_PHYSRNGCHK_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DEVLIB_PHYSRNGCHK_SY_Compu
    ""
    TAB_VERB
    2
    0 "FALSE"
    1 "TRUE"


/end COMPU_VTAB

/begin COMPU_METHOD
    DEVLIB_PSOFFOPNLD_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DEVLIB_PSOFFOPNLD_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DEVLIB_PSOFFOPNLD_SY_Compu
    ""
    TAB_VERB
    2
    0 "FALSE"
    1 "TRUE"


/end COMPU_VTAB

/begin COMPU_METHOD
    DEVLIB_PSSTATEMOCSOPINI_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DEVLIB_PSSTATEMOCSOPINI_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DEVLIB_PSSTATEMOCSOPINI_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DEVLIB_PWRSTGSTATEMOCSOPCHK_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DEVLIB_PWRSTGSTATEMOCSOPCHK_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DEVLIB_PWRSTGSTATEMOCSOPCHK_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    dez
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    DFCDFP_Verb
    ""
    TAB_VERB
    "%2.1"
    "NO"
    COMPU_TAB_REF DFCDFP_Verb
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DFCDFP_Verb
    ""
    TAB_VERB
    1010
    0 "NoEntry"
    1 "DFC_bds_TimeInRowDebFault"
    2 "DFC_bds_EventInRowDebFault"
    3 "DFC_DevLibBattUHi"
    4 "DFC_DevLibBattULo"
    5 "DFC_bds_TimeUpDownDebFault"
    6 "DFC_rbr_inA13OR"
    7 "DFC_rbr_inA13SCB"
    8 "DFC_rbr_inA13SCG"
    9 "DFC_rbr_inA14OR"
    10 "DFC_rbr_inA14SCB"
    11 "DFC_rbr_inA14SCG"
    12 "DFC_rbr_inA21OR"
    13 "DFC_rbr_inA21SCB"
    14 "DFC_rbr_inA21SCG"
    15 "DFC_rbr_inA22OR"
    16 "DFC_rbr_inA22SCB"
    17 "DFC_rbr_inA22SCG"
    18 "DFC_rbr_inA23OR"
    19 "DFC_rbr_inA23SCB"
    20 "DFC_rbr_inA23SCG"
    21 "DFC_rbr_inA24OR"
    22 "DFC_rbr_inA24SCB"
    23 "DFC_rbr_inA24SCG"
    24 "DFC_rbr_inA25OR"
    25 "DFC_rbr_inA25SCB"
    26 "DFC_rbr_inA25SCG"
    27 "DFC_rbr_inA26OR"
    28 "DFC_rbr_inA26SCB"
    29 "DFC_rbr_inA26SCG"
    30 "DFC_rbr_inA27OR"
    31 "DFC_rbr_inA27SCB"
    32 "DFC_rbr_inA27SCG"
    33 "DFC_rbr_inA28OR"
    34 "DFC_rbr_inA28SCB"
    35 "DFC_rbr_inA28SCG"
    36 "DFC_rbr_inA29OR"
    37 "DFC_rbr_inA29SCB"
    38 "DFC_rbr_inA29SCG"
    39 "DFC_rbr_inA36AicSCB"
    40 "DFC_rbr_inA36AicSCG"
    41 "DFC_rbr_inA36OR"
    42 "DFC_rbr_inA36SCB"
    43 "DFC_rbr_inA36SCG"
    44 "DFC_rbr_inA36ShuntSCB"
    45 "DFC_rbr_inA37AicSCB"
    46 "DFC_rbr_inA37AicSCG"
    47 "DFC_rbr_inA37OR"
    48 "DFC_rbr_inA37SCB"
    49 "DFC_rbr_inA37SCG"
    50 "DFC_rbr_inA37ShuntSCB"
    51 "DFC_rbr_inA38AicSCB"
    52 "DFC_rbr_inA38AicSCG"
    53 "DFC_rbr_inA38OR"
    54 "DFC_rbr_inA38SCB"
    55 "DFC_rbr_inA38SCG"
    56 "DFC_rbr_inA38ShuntSCB"
    57 "DFC_rbr_inA39AicSCB"
    58 "DFC_rbr_inA39AicSCG"
    59 "DFC_rbr_inA39OR"
    60 "DFC_rbr_inA39SCB"
    61 "DFC_rbr_inA39SCG"
    62 "DFC_rbr_inA39ShuntSCB"
    63 "DFC_rbr_inA40OR"
    64 "DFC_rbr_inA40SCB"
    65 "DFC_rbr_inA40SCG"
    66 "DFC_rbr_inA41OR"
    67 "DFC_rbr_inA41SCB"
    68 "DFC_rbr_inA41SCG"
    69 "DFC_rbr_inA42OR"
    70 "DFC_rbr_inA42SCB"
    71 "DFC_rbr_inA42SCG"
    72 "DFC_rbr_inA43AicSCB"
    73 "DFC_rbr_inA43AicSCG"
    74 "DFC_rbr_inA43OR"
    75 "DFC_rbr_inA43SCB"
    76 "DFC_rbr_inA43SCG"
    77 "DFC_rbr_inA43ShuntSCB"
    78 "DFC_rbr_inA44OL"
    79 "DFC_rbr_inA44SCB"
    80 "DFC_rbr_inA44SCG"
    81 "DFC_rbr_inA57OR"
    82 "DFC_rbr_inA57SCB"
    83 "DFC_rbr_inA57SCG"
    84 "DFC_rbr_inA59OL"
    85 "DFC_rbr_inA59SCB"
    86 "DFC_rbr_inA59SCG"
    87 "DFC_rbr_inK10OR"
    88 "DFC_rbr_inK10SCB"
    89 "DFC_rbr_inK10SCG"
    90 "DFC_rbr_inK11OR"
    91 "DFC_rbr_inK11SCB"
    92 "DFC_rbr_inK11SCG"
    93 "DFC_rbr_inK30AicSCB"
    94 "DFC_rbr_inK30AicSCG"
    95 "DFC_rbr_inK30OR"
    96 "DFC_rbr_inK30SCB"
    97 "DFC_rbr_inK30SCG"
    98 "DFC_rbr_inK30ShuntSCB"
    99 "DFC_rbr_inK31OR"
    100 "DFC_rbr_inK31SCB"
    101 "DFC_rbr_inK31SCG"
    102 "DFC_rbr_inK32OR"
    103 "DFC_rbr_inK32SCB"
    104 "DFC_rbr_inK32SCG"
    105 "DFC_rbr_inK33OR"
    106 "DFC_rbr_inK33SCB"
    107 "DFC_rbr_inK33SCG"
    108 "DFC_rbr_inK34OR"
    109 "DFC_rbr_inK34SCB"
    110 "DFC_rbr_inK34SCG"
    111 "DFC_rbr_inK35OR"
    112 "DFC_rbr_inK35SCB"
    113 "DFC_rbr_inK35SCG"
    114 "DFC_rbr_inK36OR"
    115 "DFC_rbr_inK36SCB"
    116 "DFC_rbr_inK36SCG"
    117 "DFC_rbr_inK37AicSCB"
    118 "DFC_rbr_inK37AicSCG"
    119 "DFC_rbr_inK37OR"
    120 "DFC_rbr_inK37SCB"
    121 "DFC_rbr_inK37SCG"
    122 "DFC_rbr_inK37ShuntSCB"
    123 "DFC_rbr_inK38AicSCB"
    124 "DFC_rbr_inK38AicSCG"
    125 "DFC_rbr_inK38OR"
    126 "DFC_rbr_inK38SCB"
    127 "DFC_rbr_inK38SCG"
    128 "DFC_rbr_inK38ShuntSCB"
    129 "DFC_rbr_inK39AicSCB"
    130 "DFC_rbr_inK39AicSCG"
    131 "DFC_rbr_inK39OR"
    132 "DFC_rbr_inK39SCB"
    133 "DFC_rbr_inK39SCG"
    134 "DFC_rbr_inK39ShuntSCB"
    135 "DFC_rbr_inK40AicSCB"
    136 "DFC_rbr_inK40AicSCG"
    137 "DFC_rbr_inK40OR"
    138 "DFC_rbr_inK40SCB"
    139 "DFC_rbr_inK40SCG"
    140 "DFC_rbr_inK40ShuntSCB"
    141 "DFC_rbr_inK41AicSCB"
    142 "DFC_rbr_inK41AicSCG"
    143 "DFC_rbr_inK41OR"
    144 "DFC_rbr_inK41SCB"
    145 "DFC_rbr_inK41SCG"
    146 "DFC_rbr_inK41ShuntSCB"
    147 "DFC_rbr_inK42AicSCB"
    148 "DFC_rbr_inK42AicSCG"
    149 "DFC_rbr_inK42OR"
    150 "DFC_rbr_inK42SCB"
    151 "DFC_rbr_inK42SCG"
    152 "DFC_rbr_inK42ShuntSCB"
    153 "DFC_rbr_inK43OR"
    154 "DFC_rbr_inK43SCB"
    155 "DFC_rbr_inK43SCG"
    156 "DFC_rbr_inK44AicSCB"
    157 "DFC_rbr_inK44AicSCG"
    158 "DFC_rbr_inK44OR"
    159 "DFC_rbr_inK44SCB"
    160 "DFC_rbr_inK44SCG"
    161 "DFC_rbr_inK44ShuntSCB"
    162 "DFC_rbr_inK45AicSCB"
    163 "DFC_rbr_inK45AicSCG"
    164 "DFC_rbr_inK45OR"
    165 "DFC_rbr_inK45SCB"
    166 "DFC_rbr_inK45SCG"
    167 "DFC_rbr_inK45ShuntSCB"
    168 "DFC_rbr_inK52OR"
    169 "DFC_rbr_inK52SCB"
    170 "DFC_rbr_inK52SCG"
    171 "DFC_rbr_inK53OR"
    172 "DFC_rbr_inK53SCB"
    173 "DFC_rbr_inK53SCG"
    174 "DFC_rbr_inK54AicSCB"
    175 "DFC_rbr_inK54AicSCG"
    176 "DFC_rbr_inK54OR"
    177 "DFC_rbr_inK54SCB"
    178 "DFC_rbr_inK54SCG"
    179 "DFC_rbr_inK54ShuntSCB"
    180 "DFC_rbr_inK55AicSCB"
    181 "DFC_rbr_inK55AicSCG"
    182 "DFC_rbr_inK55OR"
    183 "DFC_rbr_inK55SCB"
    184 "DFC_rbr_inK55SCG"
    185 "DFC_rbr_inK55ShuntSCB"
    186 "DFC_rbr_inK56OR"
    187 "DFC_rbr_inK56SCB"
    188 "DFC_rbr_inK56SCG"
    189 "DFC_rbr_inK57OR"
    190 "DFC_rbr_inK57SCB"
    191 "DFC_rbr_inK57SCG"
    192 "DFC_rbr_inK58OR"
    193 "DFC_rbr_inK58SCB"
    194 "DFC_rbr_inK58SCG"
    195 "DFC_rbr_inK59OR"
    196 "DFC_rbr_inK59SCB"
    197 "DFC_rbr_inK59SCG"
    198 "DFC_rbr_inK60OR"
    199 "DFC_rbr_inK60SCB"
    200 "DFC_rbr_inK60SCG"
    201 "DFC_rbr_inK61AicSCB"
    202 "DFC_rbr_inK61AicSCG"
    203 "DFC_rbr_inK61OR"
    204 "DFC_rbr_inK61SCB"
    205 "DFC_rbr_inK61SCG"
    206 "DFC_rbr_inK61ShuntSCB"
    207 "DFC_rbr_inK62OR"
    208 "DFC_rbr_inK62SCB"
    209 "DFC_rbr_inK62SCG"
    210 "DFC_rbr_inK63AicSCB"
    211 "DFC_rbr_inK63AicSCG"
    212 "DFC_rbr_inK63OR"
    213 "DFC_rbr_inK63SCB"
    214 "DFC_rbr_inK63SCG"
    215 "DFC_rbr_inK63ShuntSCB"
    216 "DFC_rbr_inK64AicSCB"
    217 "DFC_rbr_inK64AicSCG"
    218 "DFC_rbr_inK64OR"
    219 "DFC_rbr_inK64SCB"
    220 "DFC_rbr_inK64SCG"
    221 "DFC_rbr_inK64ShuntSCB"
    222 "DFC_rbr_inK65AicSCB"
    223 "DFC_rbr_inK65AicSCG"
    224 "DFC_rbr_inK65OR"
    225 "DFC_rbr_inK65SCB"
    226 "DFC_rbr_inK65SCG"
    227 "DFC_rbr_inK65ShuntSCB"
    228 "DFC_rbr_inK74OR"
    229 "DFC_rbr_inK74SCB"
    230 "DFC_rbr_inK74SCG"
    231 "DFC_rbr_inK75OR"
    232 "DFC_rbr_inK75SCB"
    233 "DFC_rbr_inK75SCG"
    234 "DFC_rbr_inK76OR"
    235 "DFC_rbr_inK76SCB"
    236 "DFC_rbr_inK76SCG"
    237 "DFC_rbr_inK77OR"
    238 "DFC_rbr_inK77SCB"
    239 "DFC_rbr_inK77SCG"
    240 "DFC_rbr_inK78OR"
    241 "DFC_rbr_inK78SCB"
    242 "DFC_rbr_inK78SCG"
    243 "DFC_rbr_mo_DvUBAT_FWs"
    244 "DFC_rbr_mo_OVErr_VPR6"
    245 "DFC_rbr_mo_OVWarn_VPR6"
    246 "DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3"
    247 "DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2"
    248 "DFC_rbr_mo_OV_UBAT_MON"
    249 "DFC_rbr_mo_OV_UBRM24_FLEXIN"
    250 "DFC_rbr_mo_OV_UBRM24_LOADS"
    251 "DFC_rbr_mo_OV_UBRM24_MON"
    252 "DFC_rbr_mo_OV_VDD5"
    253 "DFC_rbr_mo_OV_VDD5_IN"
    254 "DFC_rbr_mo_OV_VPR6"
    255 "DFC_rbr_mo_OV_VSS3"
    256 "DFC_rbr_mo_OV_VSS4"
    257 "DFC_rbr_mo_Temp1_HTErr"
    258 "DFC_rbr_mo_Temp1_HTWarn"
    259 "DFC_rbr_mo_Temp2_HTErr"
    260 "DFC_rbr_mo_Temp2_HTWarn"
    261 "DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3"
    262 "DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2"
    263 "DFC_rbr_mo_UV_VDD5"
    264 "DFC_rbr_mo_UV_VDD5_IN"
    265 "DFC_rbr_mo_UV_VPR6"
    266 "DFC_rbr_mo_UV_VSS3"
    267 "DFC_rbr_mo_UV_VSS4"
    268 "DFC_rbr_outA01OL"
    269 "DFC_rbr_outA01OT"
    270 "DFC_rbr_outA01SCB"
    271 "DFC_rbr_outA01SCG"
    272 "DFC_rbr_outA02OL"
    273 "DFC_rbr_outA02OR"
    274 "DFC_rbr_outA02OT"
    275 "DFC_rbr_outA02SCB"
    276 "DFC_rbr_outA02SCG"
    277 "DFC_rbr_outA03OL"
    278 "DFC_rbr_outA03OT"
    279 "DFC_rbr_outA03SCB"
    280 "DFC_rbr_outA03SCG"
    281 "DFC_rbr_outA04OL"
    282 "DFC_rbr_outA04OT"
    283 "DFC_rbr_outA04SCB"
    284 "DFC_rbr_outA04SCG"
    285 "DFC_rbr_outA05OL"
    286 "DFC_rbr_outA05OR"
    287 "DFC_rbr_outA05OT"
    288 "DFC_rbr_outA05SCB"
    289 "DFC_rbr_outA05SCG"
    290 "DFC_rbr_outA06OL"
    291 "DFC_rbr_outA06OR"
    292 "DFC_rbr_outA06OT"
    293 "DFC_rbr_outA06SCB"
    294 "DFC_rbr_outA06SCG"
    295 "DFC_rbr_outA07OL"
    296 "DFC_rbr_outA07OT"
    297 "DFC_rbr_outA07SCB"
    298 "DFC_rbr_outA07SCG"
    299 "DFC_rbr_outA08OL"
    300 "DFC_rbr_outA08OT"
    301 "DFC_rbr_outA08SCB"
    302 "DFC_rbr_outA08SCG"
    303 "DFC_rbr_outA09OL"
    304 "DFC_rbr_outA09OR"
    305 "DFC_rbr_outA09OT"
    306 "DFC_rbr_outA09SCB"
    307 "DFC_rbr_outA09SCG"
    308 "DFC_rbr_outA10OL"
    309 "DFC_rbr_outA10OT"
    310 "DFC_rbr_outA10SCB"
    311 "DFC_rbr_outA10SCG"
    312 "DFC_rbr_outA11OL"
    313 "DFC_rbr_outA11OT"
    314 "DFC_rbr_outA11SCB"
    315 "DFC_rbr_outA11SCG"
    316 "DFC_rbr_outA12OR"
    317 "DFC_rbr_outA12SCB"
    318 "DFC_rbr_outA12SCG"
    319 "DFC_rbr_outA16OL"
    320 "DFC_rbr_outA16OT"
    321 "DFC_rbr_outA16SCB"
    322 "DFC_rbr_outA16SCG"
    323 "DFC_rbr_outA17OL"
    324 "DFC_rbr_outA17OR"
    325 "DFC_rbr_outA17OT"
    326 "DFC_rbr_outA17SCB"
    327 "DFC_rbr_outA17SCG"
    328 "DFC_rbr_outA18OL"
    329 "DFC_rbr_outA18OT"
    330 "DFC_rbr_outA18SCB"
    331 "DFC_rbr_outA18SCG"
    332 "DFC_rbr_outA19OL"
    333 "DFC_rbr_outA19OR"
    334 "DFC_rbr_outA19OT"
    335 "DFC_rbr_outA19SCB"
    336 "DFC_rbr_outA19SCG"
    337 "DFC_rbr_outA20OL"
    338 "DFC_rbr_outA20OR"
    339 "DFC_rbr_outA20OT"
    340 "DFC_rbr_outA20SCB"
    341 "DFC_rbr_outA20SCG"
    342 "DFC_rbr_outA31OL"
    343 "DFC_rbr_outA31OR"
    344 "DFC_rbr_outA31OT"
    345 "DFC_rbr_outA31SCB"
    346 "DFC_rbr_outA31SCG"
    347 "DFC_rbr_outA32OL"
    348 "DFC_rbr_outA32OR"
    349 "DFC_rbr_outA32OT"
    350 "DFC_rbr_outA32SCB"
    351 "DFC_rbr_outA32SCG"
    352 "DFC_rbr_outA33OL"
    353 "DFC_rbr_outA33OR"
    354 "DFC_rbr_outA33OT"
    355 "DFC_rbr_outA33SCB"
    356 "DFC_rbr_outA33SCG"
    357 "DFC_rbr_outA34OL"
    358 "DFC_rbr_outA34OR"
    359 "DFC_rbr_outA34OT"
    360 "DFC_rbr_outA34SCB"
    361 "DFC_rbr_outA34SCG"
    362 "DFC_rbr_outA35OL"
    363 "DFC_rbr_outA35OR"
    364 "DFC_rbr_outA35OT"
    365 "DFC_rbr_outA35SCB"
    366 "DFC_rbr_outA35SCG"
    367 "DFC_rbr_outA46OL"
    368 "DFC_rbr_outA46OR"
    369 "DFC_rbr_outA46OT"
    370 "DFC_rbr_outA46SCB"
    371 "DFC_rbr_outA46SCG"
    372 "DFC_rbr_outA47OL"
    373 "DFC_rbr_outA47OR"
    374 "DFC_rbr_outA47OT"
    375 "DFC_rbr_outA47SCB"
    376 "DFC_rbr_outA47SCG"
    377 "DFC_rbr_outA48OL"
    378 "DFC_rbr_outA48OR"
    379 "DFC_rbr_outA48OT"
    380 "DFC_rbr_outA48SCB"
    381 "DFC_rbr_outA48SCG"
    382 "DFC_rbr_outA49OL"
    383 "DFC_rbr_outA49OT"
    384 "DFC_rbr_outA49SCB"
    385 "DFC_rbr_outA49SCG"
    386 "DFC_rbr_outA50OL"
    387 "DFC_rbr_outA50OT"
    388 "DFC_rbr_outA50SCB"
    389 "DFC_rbr_outA50SCG"
    390 "DFC_rbr_outA51OL"
    391 "DFC_rbr_outA51OR"
    392 "DFC_rbr_outA51OT"
    393 "DFC_rbr_outA51SCB"
    394 "DFC_rbr_outA51SCG"
    395 "DFC_rbr_outA52OL"
    396 "DFC_rbr_outA52OR"
    397 "DFC_rbr_outA52OT"
    398 "DFC_rbr_outA52SCB"
    399 "DFC_rbr_outA52SCG"
    400 "DFC_rbr_outA53OL"
    401 "DFC_rbr_outA53OR"
    402 "DFC_rbr_outA53OT"
    403 "DFC_rbr_outA53SCB"
    404 "DFC_rbr_outA53SCG"
    405 "DFC_rbr_outA54OL"
    406 "DFC_rbr_outA54OR"
    407 "DFC_rbr_outA54OT"
    408 "DFC_rbr_outA54SCB"
    409 "DFC_rbr_outA54SCG"
    410 "DFC_rbr_outA55OL"
    411 "DFC_rbr_outA55OT"
    412 "DFC_rbr_outA55SCB"
    413 "DFC_rbr_outA55SCG"
    414 "DFC_rbr_outA56OL"
    415 "DFC_rbr_outA56OT"
    416 "DFC_rbr_outA56SCB"
    417 "DFC_rbr_outA56SCG"
    418 "DFC_rbr_outA58OL"
    419 "DFC_rbr_outA58OT"
    420 "DFC_rbr_outA58SCB"
    421 "DFC_rbr_outA58SCG"
    422 "DFC_rbr_outK07OL"
    423 "DFC_rbr_outK07OR"
    424 "DFC_rbr_outK07OT"
    425 "DFC_rbr_outK07SCB"
    426 "DFC_rbr_outK07SCG"
    427 "DFC_rbr_outK08OL"
    428 "DFC_rbr_outK08OR"
    429 "DFC_rbr_outK08OT"
    430 "DFC_rbr_outK08SCB"
    431 "DFC_rbr_outK08SCG"
    432 "DFC_rbr_outK09OL"
    433 "DFC_rbr_outK09OR"
    434 "DFC_rbr_outK09OT"
    435 "DFC_rbr_outK09SCB"
    436 "DFC_rbr_outK09SCG"
    437 "DFC_rbr_outK12OL"
    438 "DFC_rbr_outK12OT"
    439 "DFC_rbr_outK12SCB"
    440 "DFC_rbr_outK12SCG"
    441 "DFC_rbr_outK13OL"
    442 "DFC_rbr_outK13OT"
    443 "DFC_rbr_outK13SCB"
    444 "DFC_rbr_outK13SCG"
    445 "DFC_rbr_outK14OL"
    446 "DFC_rbr_outK14OR"
    447 "DFC_rbr_outK14OT"
    448 "DFC_rbr_outK14SCB"
    449 "DFC_rbr_outK14SCG"
    450 "DFC_rbr_outK15OL"
    451 "DFC_rbr_outK15OR"
    452 "DFC_rbr_outK15OT"
    453 "DFC_rbr_outK15SCB"
    454 "DFC_rbr_outK15SCG"
    455 "DFC_rbr_outK16OL"
    456 "DFC_rbr_outK16OR"
    457 "DFC_rbr_outK16OT"
    458 "DFC_rbr_outK16SCB"
    459 "DFC_rbr_outK16SCG"
    460 "DFC_rbr_outK17OL"
    461 "DFC_rbr_outK17OR"
    462 "DFC_rbr_outK17OT"
    463 "DFC_rbr_outK17SCB"
    464 "DFC_rbr_outK17SCG"
    465 "DFC_rbr_outK25OR"
    466 "DFC_rbr_outK25SCB"
    467 "DFC_rbr_outK25SCG"
    468 "DFC_rbr_outK29OL"
    469 "DFC_rbr_outK29OR"
    470 "DFC_rbr_outK29OT"
    471 "DFC_rbr_outK29SCB"
    472 "DFC_rbr_outK29SCG"
    473 "DFC_rbr_outK51OL"
    474 "DFC_rbr_outK51OT"
    475 "DFC_rbr_outK51SCB"
    476 "DFC_rbr_outK51SCG"
    477 "DFC_rbr_outK62OR"
    478 "DFC_rbr_outK62SCB"
    479 "DFC_rbr_outK62SCG"
    480 "DFC_rbr_outK73OL"
    481 "DFC_rbr_outK73OR"
    482 "DFC_rbr_outK73OT"
    483 "DFC_rbr_outK73SCB"
    484 "DFC_rbr_outK73SCG"
    485 "DFC_rbr_outK80OL"
    486 "DFC_rbr_outK80OT"
    487 "DFC_rbr_outK80SCB"
    488 "DFC_rbr_outK80SCG"
    489 "DFC_rbr_outK81OL"
    490 "DFC_rbr_outK81OT"
    491 "DFC_rbr_outK81SCB"
    492 "DFC_rbr_outK81SCG"
    493 "DFC_rbr_outK82OL"
    494 "DFC_rbr_outK82OT"
    495 "DFC_rbr_outK82SCB"
    496 "DFC_rbr_outK82SCG"
    497 "DFC_rbr_outK83OL"
    498 "DFC_rbr_outK83OT"
    499 "DFC_rbr_outK83SCB"
    500 "DFC_rbr_outK83SCG"
    501 "DFC_rbr_outK84OL"
    502 "DFC_rbr_outK84OT"
    503 "DFC_rbr_outK84SCB"
    504 "DFC_rbr_outK84SCG"
    505 "DFC_rbr_outK85OL"
    506 "DFC_rbr_outK85OT"
    507 "DFC_rbr_outK85SCB"
    508 "DFC_rbr_outK85SCG"
    509 "DFC_rbr_outK86OL"
    510 "DFC_rbr_outK86OT"
    511 "DFC_rbr_outK86SCB"
    512 "DFC_rbr_outK86SCG"
    513 "DFC_rbr_outK87OL"
    514 "DFC_rbr_outK87OT"
    515 "DFC_rbr_outK87SCB"
    516 "DFC_rbr_outK87SCG"
    517 "DFC_bds_EventUpDownDebFault"
    518 "DFC_DSMDummy"
    519 "DFC_rbr_canGetDataNoBuf"
    520 "DFC_rbr_canGetDataParam"
    521 "DFC_rbr_canGetDataboxNoInit"
    522 "DFC_rbr_canGetDataboxParam"
    523 "DFC_rbr_canGetRxBufStatusParam"
    524 "DFC_rbr_canGetStatusParam"
    525 "DFC_rbr_canGetTxBufStatusParam"
    526 "DFC_rbr_canInitParam"
    527 "DFC_rbr_canInitRxDataboxOverlap"
    528 "DFC_rbr_canInitRxDataboxParam"
    529 "DFC_rbr_canInitTxDataboxParam"
    530 "DFC_rbr_canIpduGroupControl"
    531 "DFC_rbr_canIsDataboxFreeNoInit"
    532 "DFC_rbr_canIsDataboxFreeParam"
    533 "DFC_rbr_canIsTxEmptyParam"
    534 "DFC_rbr_canRegBusOffCallbInvState"
    535 "DFC_rbr_canRegBusOffCallbParam"
    536 "DFC_rbr_canRegRxBufInvState"
    537 "DFC_rbr_canRegRxBufOverlap"
    538 "DFC_rbr_canRegRxBufParam"
    539 "DFC_rbr_canRegRxCallbInvState"
    540 "DFC_rbr_canRegRxCallbParam"
    541 "DFC_rbr_canRegRxDataboxInvNumb"
    542 "DFC_rbr_canRegRxDataboxInvState"
    543 "DFC_rbr_canRegRxDataboxOverlap"
    544 "DFC_rbr_canRegRxDataboxParam"
    545 "DFC_rbr_canRegTxBufInvState"
    546 "DFC_rbr_canRegTxBufOverlap"
    547 "DFC_rbr_canRegTxBufParam"
    548 "DFC_rbr_canRegTxDataboxInvNumb"
    549 "DFC_rbr_canRegTxDataboxInvState"
    550 "DFC_rbr_canRegTxDataboxOverlap"
    551 "DFC_rbr_canRegTxDataboxParam"
    552 "DFC_rbr_canResetTxBufParam"
    553 "DFC_rbr_canSendDataBufOvfl"
    554 "DFC_rbr_canSendDataParam"
    555 "DFC_rbr_canSendDataboxNoInit"
    556 "DFC_rbr_canSendDataboxParam"
    557 "DFC_rbr_canSetTxCycleParam"
    558 "DFC_rbr_canStartParam"
    559 "DFC_rbr_canStopParam"
    560 "DFC_rbr_can_ClearIpduGroup"
    561 "DFC_rbr_can_ReceiveSignal"
    562 "DFC_rbr_can_SendSignal"
    563 "DFC_rbr_can_SetIpduGroup"
    564 "DFC_rbr_dsmDTCJ1939"
    565 "DFC_rbr_dsmDelDTCJ1939"
    566 "DFC_rbr_dsmDelErrors"
    567 "DFC_rbr_dsmGetDFES"
    568 "DFC_rbr_dsmGetDTCJ1939"
    569 "DFC_rbr_dsmGetErrors"
    570 "DFC_rbr_dsmGetNumErrors"
    571 "DFC_rbr_dsmInitQueueOverflow"
    572 "DFC_rbr_dsmNumDTCJ1939"
    573 "DFC_rbr_dsmTesterror"
    574 "DFC_rbr_dsmUpdateDebError"
    575 "DFC_rbr_dsmUpdateError"
    576 "DFC_rbr_dsmgetDFCStatus"
    577 "DFC_rbr_dsmtestErrorDFC"
    578 "DFC_rbr_inAi"
    579 "DFC_rbr_inAic"
    580 "DFC_rbr_inAicCfg"
    581 "DFC_rbr_inAicGetStatus"
    582 "DFC_rbr_inAid"
    583 "DFC_rbr_inAidCfg"
    584 "DFC_rbr_inAiv"
    585 "DFC_rbr_inAivCfg"
    586 "DFC_rbr_inAivGetStatus"
    587 "DFC_rbr_inDi"
    588 "DFC_rbr_inFi"
    589 "DFC_rbr_inFiCfg"
    590 "DFC_rbr_inFiGetStatus"
    591 "DFC_rbr_inFi_Buffered"
    592 "DFC_rbr_inPhase"
    593 "DFC_rbr_inPhaseGetStatus"
    594 "DFC_rbr_inPhaseResetCounter"
    595 "DFC_rbr_inRi"
    596 "DFC_rbr_inRiCfg"
    597 "DFC_rbr_inRiCfgTemp"
    598 "DFC_rbr_inRiGetStatus"
    599 "DFC_rbr_inRiGetTemp"
    600 "DFC_rbr_inSentCopyFDFifo"
    601 "DFC_rbr_inSentDisable"
    602 "DFC_rbr_inSentEnable"
    603 "DFC_rbr_inSentGetErrorStatus"
    604 "DFC_rbr_inSentGetFD"
    605 "DFC_rbr_inSentGetSD"
    606 "DFC_rbr_inSentGetSDDatabox"
    607 "DFC_rbr_inSentGetStatus"
    608 "DFC_rbr_inSentInitSDDatabox"
    609 "DFC_rbr_inSentRegisterCopyFDFifo"
    610 "DFC_rbr_inSentRegisterFDFifo"
    611 "DFC_rbr_inSentRegisterSDDataboxes"
    612 "DFC_rbr_isobusCanRxBufferOverflow"
    613 "DFC_rbr_isobusGetCaAddrParam"
    614 "DFC_rbr_isobusGetDiagnosticParam"
    615 "DFC_rbr_isobusGetRxDataboxStatusParam"
    616 "DFC_rbr_isobusGetStatusParam"
    617 "DFC_rbr_isobusInitCommCaMissing"
    618 "DFC_rbr_isobusInitCommParam"
    619 "DFC_rbr_isobusInitCommState"
    620 "DFC_rbr_isobusInitDiagnosticParam"
    621 "DFC_rbr_isobusInitFailureListParam"
    622 "DFC_rbr_isobusInitRxDataboxParam"
    623 "DFC_rbr_isobusInitTxDataboxParam"
    624 "DFC_rbr_isobusRegRxDataboxOverlap"
    625 "DFC_rbr_isobusRegRxDataboxParam"
    626 "DFC_rbr_isobusRegRxDataboxState"
    627 "DFC_rbr_isobusRegTxDataboxOverlap"
    628 "DFC_rbr_isobusRegTxDataboxParam"
    629 "DFC_rbr_isobusRegTxDataboxState"
    630 "DFC_rbr_isobusRegisterErrClrCallbackParam"
    631 "DFC_rbr_isobusRegisterInstancesOverlap"
    632 "DFC_rbr_isobusRegisterInstancesParam"
    633 "DFC_rbr_isobusRegisterInstancesState"
    634 "DFC_rbr_isobusSendDataboxParam"
    635 "DFC_rbr_isobusSendRequestPGNParam"
    636 "DFC_rbr_isobusSetCaAddrCaUsed"
    637 "DFC_rbr_isobusSetCaAddrComm"
    638 "DFC_rbr_isobusSetCaAddrInvCan"
    639 "DFC_rbr_isobusSetCaAddrParam"
    640 "DFC_rbr_isobusSetCaInfoParam"
    641 "DFC_rbr_isobusSetCaNameParam"
    642 "DFC_rbr_isobusSftyCanTxErr"
    643 "DFC_rbr_lin_ReceiveSignal"
    644 "DFC_rbr_lin_SendSignal"
    645 "DFC_rbr_lin_getStatus"
    646 "DFC_rbr_lin_gotoSleep"
    647 "DFC_rbr_lin_scheduleRequest"
    648 "DFC_rbr_lin_wakeUp"
    649 "DFC_rbr_memFlsCfgShr"
    650 "DFC_rbr_memGetStatus"
    651 "DFC_rbr_memMarkBlock"
    652 "DFC_rbr_memReadApi1Error"
    653 "DFC_rbr_memReadApi2Error"
    654 "DFC_rbr_memReadBlock"
    655 "DFC_rbr_memReadCalibInputError"
    656 "DFC_rbr_memReadCalibOuputError"
    657 "DFC_rbr_memReadSystemError"
    658 "DFC_rbr_memWriteBlock"
    659 "DFC_rbr_moOV_FirstConstADC"
    660 "DFC_rbr_moOV_SecondConstADC"
    661 "DFC_rbr_moUV_FirstConstADC"
    662 "DFC_rbr_moUV_SecondConstADC"
    663 "DFC_rbr_mo_INH"
    664 "DFC_rbr_mo_INHLatch"
    665 "DFC_rbr_mo_adcPDD_fail"
    666 "DFC_rbr_mo_memoryProtection_err"
    667 "DFC_rbr_outA02OC"
    668 "DFC_rbr_outA02Unintended"
    669 "DFC_rbr_outA03OC"
    670 "DFC_rbr_outA03Unintended"
    671 "DFC_rbr_outA04OC"
    672 "DFC_rbr_outA04Unintended"
    673 "DFC_rbr_outA05OC"
    674 "DFC_rbr_outA05Unintended"
    675 "DFC_rbr_outA07OC"
    676 "DFC_rbr_outA07Unintended"
    677 "DFC_rbr_outA08OC"
    678 "DFC_rbr_outA08Unintended"
    679 "DFC_rbr_outA09OC"
    680 "DFC_rbr_outA09Unintended"
    681 "DFC_rbr_outA10OC"
    682 "DFC_rbr_outA10Unintended"
    683 "DFC_rbr_outA17OC"
    684 "DFC_rbr_outA17Unintended"
    685 "DFC_rbr_outA18OC"
    686 "DFC_rbr_outA18Unintended"
    687 "DFC_rbr_outA19OC"
    688 "DFC_rbr_outA19Unintended"
    689 "DFC_rbr_outA20OC"
    690 "DFC_rbr_outA20Unintended"
    691 "DFC_rbr_outA31OC"
    692 "DFC_rbr_outA31Unintended"
    693 "DFC_rbr_outA32OC"
    694 "DFC_rbr_outA32Unintended"
    695 "DFC_rbr_outA33OC"
    696 "DFC_rbr_outA33Unintended"
    697 "DFC_rbr_outA34OC"
    698 "DFC_rbr_outA34Unintended"
    699 "DFC_rbr_outA35OC"
    700 "DFC_rbr_outA35Unintended"
    701 "DFC_rbr_outA46OC"
    702 "DFC_rbr_outA46Unintended"
    703 "DFC_rbr_outA47OC"
    704 "DFC_rbr_outA47Unintended"
    705 "DFC_rbr_outA48OC"
    706 "DFC_rbr_outA48Unintended"
    707 "DFC_rbr_outA51OC"
    708 "DFC_rbr_outA51Unintended"
    709 "DFC_rbr_outA52OC"
    710 "DFC_rbr_outA52Unintended"
    711 "DFC_rbr_outA53OC"
    712 "DFC_rbr_outA53Unintended"
    713 "DFC_rbr_outA54OC"
    714 "DFC_rbr_outA54Unintended"
    715 "DFC_rbr_outAov"
    716 "DFC_rbr_outAovCfg"
    717 "DFC_rbr_outAovCfgPI"
    718 "DFC_rbr_outAovGetStatus"
    719 "DFC_rbr_outAovGetVoltage"
    720 "DFC_rbr_outAovResetError"
    721 "DFC_rbr_outDo"
    722 "DFC_rbr_outDoCfgPwrLs"
    723 "DFC_rbr_outDoDisable"
    724 "DFC_rbr_outDoGetCurrent"
    725 "DFC_rbr_outDoGetStatus"
    726 "DFC_rbr_outDoResetError"
    727 "DFC_rbr_outK07OC"
    728 "DFC_rbr_outK07Unintended"
    729 "DFC_rbr_outK08OC"
    730 "DFC_rbr_outK08Unintended"
    731 "DFC_rbr_outK09OC"
    732 "DFC_rbr_outK09Unintended"
    733 "DFC_rbr_outK12OC"
    734 "DFC_rbr_outK12Unintended"
    735 "DFC_rbr_outK13OC"
    736 "DFC_rbr_outK13Unintended"
    737 "DFC_rbr_outK14OC"
    738 "DFC_rbr_outK14Unintended"
    739 "DFC_rbr_outK15OC"
    740 "DFC_rbr_outK15Unintended"
    741 "DFC_rbr_outK16OC"
    742 "DFC_rbr_outK16Unintended"
    743 "DFC_rbr_outK17OC"
    744 "DFC_rbr_outK17Unintended"
    745 "DFC_rbr_outK29OC"
    746 "DFC_rbr_outK29Unintended"
    747 "DFC_rbr_outK51OC"
    748 "DFC_rbr_outK51Unintended"
    749 "DFC_rbr_outK73OC"
    750 "DFC_rbr_outK73Unintended"
    751 "DFC_rbr_outPo"
    752 "DFC_rbr_outPoCfg"
    753 "DFC_rbr_outPoCfgPeriod"
    754 "DFC_rbr_outPoCfgPwrLs"
    755 "DFC_rbr_outPoDisable"
    756 "DFC_rbr_outPoGetCurrent"
    757 "DFC_rbr_outPoGetStatus"
    758 "DFC_rbr_outPoResetError"
    759 "DFC_rbr_outPoc"
    760 "DFC_rbr_outPocCfg"
    761 "DFC_rbr_outPocCfgDither"
    762 "DFC_rbr_outPocCfgPI"
    763 "DFC_rbr_outPod"
    764 "DFC_rbr_outPodCfg"
    765 "DFC_rbr_outPodCfgPeriod"
    766 "DFC_rbr_rsmFfiApiCallErr"
    767 "DFC_rbr_safout"
    768 "DFC_rbr_safoutCfg"
    769 "DFC_rbr_safoutChnl1"
    770 "DFC_rbr_safoutChnl10"
    771 "DFC_rbr_safoutChnl10Dev"
    772 "DFC_rbr_safoutChnl10OR"
    773 "DFC_rbr_safoutChnl11"
    774 "DFC_rbr_safoutChnl11Dev"
    775 "DFC_rbr_safoutChnl11OR"
    776 "DFC_rbr_safoutChnl12"
    777 "DFC_rbr_safoutChnl12Dev"
    778 "DFC_rbr_safoutChnl12OR"
    779 "DFC_rbr_safoutChnl13"
    780 "DFC_rbr_safoutChnl13Dev"
    781 "DFC_rbr_safoutChnl13OR"
    782 "DFC_rbr_safoutChnl14"
    783 "DFC_rbr_safoutChnl14Dev"
    784 "DFC_rbr_safoutChnl14OR"
    785 "DFC_rbr_safoutChnl15"
    786 "DFC_rbr_safoutChnl15Dev"
    787 "DFC_rbr_safoutChnl15OR"
    788 "DFC_rbr_safoutChnl16"
    789 "DFC_rbr_safoutChnl16Dev"
    790 "DFC_rbr_safoutChnl16OR"
    791 "DFC_rbr_safoutChnl17"
    792 "DFC_rbr_safoutChnl17Dev"
    793 "DFC_rbr_safoutChnl17OR"
    794 "DFC_rbr_safoutChnl18"
    795 "DFC_rbr_safoutChnl18Dev"
    796 "DFC_rbr_safoutChnl18OR"
    797 "DFC_rbr_safoutChnl1Dev"
    798 "DFC_rbr_safoutChnl1OR"
    799 "DFC_rbr_safoutChnl2"
    800 "DFC_rbr_safoutChnl2Dev"
    801 "DFC_rbr_safoutChnl2OR"
    802 "DFC_rbr_safoutChnl3"
    803 "DFC_rbr_safoutChnl3Dev"
    804 "DFC_rbr_safoutChnl3OR"
    805 "DFC_rbr_safoutChnl4"
    806 "DFC_rbr_safoutChnl4Dev"
    807 "DFC_rbr_safoutChnl4OR"
    808 "DFC_rbr_safoutChnl5"
    809 "DFC_rbr_safoutChnl5Dev"
    810 "DFC_rbr_safoutChnl5OR"
    811 "DFC_rbr_safoutChnl6"
    812 "DFC_rbr_safoutChnl6Dev"
    813 "DFC_rbr_safoutChnl6OR"
    814 "DFC_rbr_safoutChnl7"
    815 "DFC_rbr_safoutChnl7Dev"
    816 "DFC_rbr_safoutChnl7OR"
    817 "DFC_rbr_safoutChnl8"
    818 "DFC_rbr_safoutChnl8Dev"
    819 "DFC_rbr_safoutChnl8OR"
    820 "DFC_rbr_safoutChnl9"
    821 "DFC_rbr_safoutChnl9Dev"
    822 "DFC_rbr_safoutChnl9OR"
    823 "DFC_rbr_safoutDevError"
    824 "DFC_rbr_safoutGetStatus"
    825 "DFC_rbr_safoutIgnoreError"
    826 "DFC_rbr_safoutResetError"
    827 "DFC_rbr_safoutUnlock"
    828 "DFC_rbr_safout_cfgDiag"
    829 "DFC_rbr_secAccessDenied_RC"
    830 "DFC_rbr_secAccessDenied_WDBI"
    831 "DFC_rbr_secEvalRespKey"
    832 "DFC_rbr_secFlashingFailure"
    833 "DFC_rbr_secGetLevel"
    834 "DFC_rbr_secGetRnd"
    835 "DFC_rbr_secGetSeed"
    836 "DFC_rbr_secInvalidPassword"
    837 "DFC_rbr_secIsRequestAllowed"
    838 "DFC_rbr_secResetLevel"
    839 "DFC_rbr_secSaveSecret"
    840 "DFC_rbr_secSetLevel"
    841 "DFC_rbr_sysAit"
    842 "DFC_rbr_sysAiv"
    843 "DFC_rbr_sysDi"
    844 "DFC_rbr_sysDo"
    845 "DFC_rbr_sysGetVss"
    846 "DFC_rbr_sysInit"
    847 "DFC_rbr_sysOperHrIntegrityErr"
    848 "DFC_rbr_sysOperHrsSaturated"
    849 "DFC_rbr_sysSetVss"
    850 "DFC_rbr_sys_coreload"
    851 "DFC_rbr_sys_taskload"
    852 "DFC_rbr_mo_OV_VSS1"
    853 "DFC_rbr_mo_OV_VSS2"
    854 "DFC_rbr_mo_UV_VSS1"
    855 "DFC_rbr_mo_UV_VSS2"
    856 "DFC_CANSM_E_BUS_OFF_NETWORK_0"
    857 "DFC_CANSM_E_BUS_OFF_NETWORK_1"
    858 "DFC_CANSM_E_BUS_OFF_NETWORK_2"
    859 "DFC_CANSM_E_BUS_OFF_NETWORK_3"
    860 "DFC_CANTRCV_E_NO_TRCV_CONTROL_0"
    861 "DFC_CAN_E_TIMEOUT"
    862 "DFC_COMM_E_NET_START_IND_CHANNEL_0"
    863 "DFC_COMM_E_NET_START_IND_CHANNEL_1"
    864 "DFC_COMM_E_NET_START_IND_CHANNEL_2"
    865 "DFC_COMM_E_NET_START_IND_CHANNEL_3"
    866 "DFC_COMM_E_NET_START_IND_CHANNEL_4"
    867 "DFC_COMM_E_NET_START_IND_CHANNEL_5"
    868 "DFC_LIN_E_TIMEOUT"
    869 "DFC_rba_MultiStackTrace_Threshold"
    870 "DFC_ETH_E_ACCESS_0"
    871 "DFC_RBA_IOEXTLIB_KEEPALIVE_DRV"
    872 "DFC_RBA_IOEXTLIB_KEEPALIVE_INI"
    873 "DFC_rba_MRly_Diag_Stk_Event"
    874 "DFC_rba_MemDiagExtd_MemReadSngErr"
    875 "DFC_rba_MemDiag_MemReadErr"
    876 "DFC_rba_MemDiag_MemWrErr"
    877 "DFC_rba_SyC_IrrSwOffTrigEngRun_Event"
    878 "DFC_rba_T15_Diag_ComInVld_Event"
    879 "DFC_rba_T15_Diag_ComOff_HwOn_Event"
    880 "DFC_rba_T15_Diag_ComOn_HwOff_Event"
    881 "DFC_MOXEMM_SMU_ALM0_0"
    882 "DFC_MOXEMM_SMU_ALM0_1"
    883 "DFC_MOXEMM_SMU_ALM0_10"
    884 "DFC_MOXEMM_SMU_ALM0_11"
    885 "DFC_MOXEMM_SMU_ALM0_13"
    886 "DFC_MOXEMM_SMU_ALM0_14"
    887 "DFC_MOXEMM_SMU_ALM0_2"
    888 "DFC_MOXEMM_SMU_ALM0_22"
    889 "DFC_MOXEMM_SMU_ALM0_23"
    890 "DFC_MOXEMM_SMU_ALM0_4"
    891 "DFC_MOXEMM_SMU_ALM0_5"
    892 "DFC_MOXEMM_SMU_ALM0_7"
    893 "DFC_MOXEMM_SMU_ALM0_8"
    894 "DFC_MOXEMM_SMU_ALM10_16"
    895 "DFC_MOXEMM_SMU_ALM10_17"
    896 "DFC_MOXEMM_SMU_ALM10_21"
    897 "DFC_MOXEMM_SMU_ALM11_0"
    898 "DFC_MOXEMM_SMU_ALM11_1"
    899 "DFC_MOXEMM_SMU_ALM11_2"
    900 "DFC_MOXEMM_SMU_ALM11_3"
    901 "DFC_MOXEMM_SMU_ALM11_4"
    902 "DFC_MOXEMM_SMU_ALM11_5"
    903 "DFC_MOXEMM_SMU_ALM11_8"
    904 "DFC_MOXEMM_SMU_ALM11_9"
    905 "DFC_MOXEMM_SMU_ALM1_0"
    906 "DFC_MOXEMM_SMU_ALM1_1"
    907 "DFC_MOXEMM_SMU_ALM1_10"
    908 "DFC_MOXEMM_SMU_ALM1_11"
    909 "DFC_MOXEMM_SMU_ALM1_13"
    910 "DFC_MOXEMM_SMU_ALM1_14"
    911 "DFC_MOXEMM_SMU_ALM1_2"
    912 "DFC_MOXEMM_SMU_ALM1_22"
    913 "DFC_MOXEMM_SMU_ALM1_23"
    914 "DFC_MOXEMM_SMU_ALM1_4"
    915 "DFC_MOXEMM_SMU_ALM1_5"
    916 "DFC_MOXEMM_SMU_ALM1_7"
    917 "DFC_MOXEMM_SMU_ALM1_8"
    918 "DFC_MOXEMM_SMU_ALM21_0"
    919 "DFC_MOXEMM_SMU_ALM21_16"
    920 "DFC_MOXEMM_SMU_ALM21_3"
    921 "DFC_MOXEMM_SMU_ALM2_1"
    922 "DFC_MOXEMM_SMU_ALM2_10"
    923 "DFC_MOXEMM_SMU_ALM2_11"
    924 "DFC_MOXEMM_SMU_ALM2_13"
    925 "DFC_MOXEMM_SMU_ALM2_14"
    926 "DFC_MOXEMM_SMU_ALM2_2"
    927 "DFC_MOXEMM_SMU_ALM2_22"
    928 "DFC_MOXEMM_SMU_ALM2_23"
    929 "DFC_MOXEMM_SMU_ALM2_4"
    930 "DFC_MOXEMM_SMU_ALM2_5"
    931 "DFC_MOXEMM_SMU_ALM2_7"
    932 "DFC_MOXEMM_SMU_ALM2_8"
    933 "DFC_MOXEMM_SMU_ALM3_1"
    934 "DFC_MOXEMM_SMU_ALM3_10"
    935 "DFC_MOXEMM_SMU_ALM3_11"
    936 "DFC_MOXEMM_SMU_ALM3_13"
    937 "DFC_MOXEMM_SMU_ALM3_14"
    938 "DFC_MOXEMM_SMU_ALM3_2"
    939 "DFC_MOXEMM_SMU_ALM3_22"
    940 "DFC_MOXEMM_SMU_ALM3_23"
    941 "DFC_MOXEMM_SMU_ALM3_4"
    942 "DFC_MOXEMM_SMU_ALM3_5"
    943 "DFC_MOXEMM_SMU_ALM3_7"
    944 "DFC_MOXEMM_SMU_ALM3_8"
    945 "DFC_MOXEMM_SMU_ALM6_0"
    946 "DFC_MOXEMM_SMU_ALM6_11"
    947 "DFC_MOXEMM_SMU_ALM6_12"
    948 "DFC_MOXEMM_SMU_ALM6_14"
    949 "DFC_MOXEMM_SMU_ALM6_15"
    950 "DFC_MOXEMM_SMU_ALM6_17"
    951 "DFC_MOXEMM_SMU_ALM6_18"
    952 "DFC_MOXEMM_SMU_ALM6_2"
    953 "DFC_MOXEMM_SMU_ALM6_20"
    954 "DFC_MOXEMM_SMU_ALM6_21"
    955 "DFC_MOXEMM_SMU_ALM6_25"
    956 "DFC_MOXEMM_SMU_ALM6_4"
    957 "DFC_MOXEMM_SMU_ALM6_5"
    958 "DFC_MOXEMM_SMU_ALM6_7"
    959 "DFC_MOXEMM_SMU_ALM6_8"
    960 "DFC_MOXEMM_SMU_ALM7_1"
    961 "DFC_MOXEMM_SMU_ALM7_12"
    962 "DFC_MOXEMM_SMU_ALM7_13"
    963 "DFC_MOXEMM_SMU_ALM7_14"
    964 "DFC_MOXEMM_SMU_ALM7_15"
    965 "DFC_MOXEMM_SMU_ALM7_16"
    966 "DFC_MOXEMM_SMU_ALM7_17"
    967 "DFC_MOXEMM_SMU_ALM7_2"
    968 "DFC_MOXEMM_SMU_ALM7_20"
    969 "DFC_MOXEMM_SMU_ALM7_25"
    970 "DFC_MOXEMM_SMU_ALM7_26"
    971 "DFC_MOXEMM_SMU_ALM7_28"
    972 "DFC_MOXEMM_SMU_ALM7_29"
    973 "DFC_MOXEMM_SMU_ALM7_30"
    974 "DFC_MOXEMM_SMU_ALM7_31"
    975 "DFC_MOXEMM_SMU_ALM8_0"
    976 "DFC_MOXEMM_SMU_ALM8_1"
    977 "DFC_MOXEMM_SMU_ALM8_10"
    978 "DFC_MOXEMM_SMU_ALM8_11"
    979 "DFC_MOXEMM_SMU_ALM8_12"
    980 "DFC_MOXEMM_SMU_ALM8_13"
    981 "DFC_MOXEMM_SMU_ALM8_16"
    982 "DFC_MOXEMM_SMU_ALM8_18"
    983 "DFC_MOXEMM_SMU_ALM8_2"
    984 "DFC_MOXEMM_SMU_ALM8_3"
    985 "DFC_MOXEMM_SMU_ALM8_30"
    986 "DFC_MOXEMM_SMU_ALM8_31"
    987 "DFC_MOXEMM_SMU_ALM8_4"
    988 "DFC_MOXEMM_SMU_ALM9_0"
    989 "DFC_MOXEMM_SMU_ALM9_1"
    990 "DFC_MOXEMM_SMU_ALM9_15"
    991 "DFC_MOXEMM_SMU_ALM9_3"
    992 "DFC_MoCSOPICO"
    993 "DFC_MoFVarPostBldSel"
    994 "DFC_MoSysCtrlReIni"
    995 "DFC_MoXEMMHwLTMCUFW"
    996 "DFC_MoXEMMHwLTMonBIST"
    997 "DFC_MoXEMMHwLTRegMonTest"
    998 "DFC_MoXEMMHwLTStbySMUAlvTest"
    999 "DFC_MoXEMMHwLTTempSens"
    1000 "DFC_MoXEMMHwLTUCBCfg"
    1001 "DFC_OCWDAABEActv"
    1002 "DFC_OCWDACom"
    1003 "DFC_OCWDAErrPin"
    1004 "DFC_SWReset_0"
    1005 "DFC_SWReset_1"
    1006 "DFC_SWReset_2"
    1007 "DFC_bds_NoDebFault1"
    1008 "DFP_AAA"
    1009 "DFP_ZZZ"

    DEFAULT_VALUE "---"

/end COMPU_VTAB

/begin COMPU_METHOD
    DFCDSQ_Verb
    ""
    TAB_VERB
    "%2.1"
    "NO"
    COMPU_TAB_REF DFCDSQ_Verb
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DFCDSQ_Verb
    ""
    TAB_VERB
    1015
    0 "NoInhibit"
    1 "DFC_bds_TimeInRowDebFault"
    2 "DFC_bds_EventInRowDebFault"
    3 "DFC_DevLibBattUHi"
    4 "DFC_DevLibBattULo"
    5 "DFC_bds_TimeUpDownDebFault"
    6 "DFC_rbr_inA13OR"
    7 "DFC_rbr_inA13SCB"
    8 "DFC_rbr_inA13SCG"
    9 "DFC_rbr_inA14OR"
    10 "DFC_rbr_inA14SCB"
    11 "DFC_rbr_inA14SCG"
    12 "DFC_rbr_inA21OR"
    13 "DFC_rbr_inA21SCB"
    14 "DFC_rbr_inA21SCG"
    15 "DFC_rbr_inA22OR"
    16 "DFC_rbr_inA22SCB"
    17 "DFC_rbr_inA22SCG"
    18 "DFC_rbr_inA23OR"
    19 "DFC_rbr_inA23SCB"
    20 "DFC_rbr_inA23SCG"
    21 "DFC_rbr_inA24OR"
    22 "DFC_rbr_inA24SCB"
    23 "DFC_rbr_inA24SCG"
    24 "DFC_rbr_inA25OR"
    25 "DFC_rbr_inA25SCB"
    26 "DFC_rbr_inA25SCG"
    27 "DFC_rbr_inA26OR"
    28 "DFC_rbr_inA26SCB"
    29 "DFC_rbr_inA26SCG"
    30 "DFC_rbr_inA27OR"
    31 "DFC_rbr_inA27SCB"
    32 "DFC_rbr_inA27SCG"
    33 "DFC_rbr_inA28OR"
    34 "DFC_rbr_inA28SCB"
    35 "DFC_rbr_inA28SCG"
    36 "DFC_rbr_inA29OR"
    37 "DFC_rbr_inA29SCB"
    38 "DFC_rbr_inA29SCG"
    39 "DFC_rbr_inA36AicSCB"
    40 "DFC_rbr_inA36AicSCG"
    41 "DFC_rbr_inA36OR"
    42 "DFC_rbr_inA36SCB"
    43 "DFC_rbr_inA36SCG"
    44 "DFC_rbr_inA36ShuntSCB"
    45 "DFC_rbr_inA37AicSCB"
    46 "DFC_rbr_inA37AicSCG"
    47 "DFC_rbr_inA37OR"
    48 "DFC_rbr_inA37SCB"
    49 "DFC_rbr_inA37SCG"
    50 "DFC_rbr_inA37ShuntSCB"
    51 "DFC_rbr_inA38AicSCB"
    52 "DFC_rbr_inA38AicSCG"
    53 "DFC_rbr_inA38OR"
    54 "DFC_rbr_inA38SCB"
    55 "DFC_rbr_inA38SCG"
    56 "DFC_rbr_inA38ShuntSCB"
    57 "DFC_rbr_inA39AicSCB"
    58 "DFC_rbr_inA39AicSCG"
    59 "DFC_rbr_inA39OR"
    60 "DFC_rbr_inA39SCB"
    61 "DFC_rbr_inA39SCG"
    62 "DFC_rbr_inA39ShuntSCB"
    63 "DFC_rbr_inA40OR"
    64 "DFC_rbr_inA40SCB"
    65 "DFC_rbr_inA40SCG"
    66 "DFC_rbr_inA41OR"
    67 "DFC_rbr_inA41SCB"
    68 "DFC_rbr_inA41SCG"
    69 "DFC_rbr_inA42OR"
    70 "DFC_rbr_inA42SCB"
    71 "DFC_rbr_inA42SCG"
    72 "DFC_rbr_inA43AicSCB"
    73 "DFC_rbr_inA43AicSCG"
    74 "DFC_rbr_inA43OR"
    75 "DFC_rbr_inA43SCB"
    76 "DFC_rbr_inA43SCG"
    77 "DFC_rbr_inA43ShuntSCB"
    78 "DFC_rbr_inA44OL"
    79 "DFC_rbr_inA44SCB"
    80 "DFC_rbr_inA44SCG"
    81 "DFC_rbr_inA57OR"
    82 "DFC_rbr_inA57SCB"
    83 "DFC_rbr_inA57SCG"
    84 "DFC_rbr_inA59OL"
    85 "DFC_rbr_inA59SCB"
    86 "DFC_rbr_inA59SCG"
    87 "DFC_rbr_inK10OR"
    88 "DFC_rbr_inK10SCB"
    89 "DFC_rbr_inK10SCG"
    90 "DFC_rbr_inK11OR"
    91 "DFC_rbr_inK11SCB"
    92 "DFC_rbr_inK11SCG"
    93 "DFC_rbr_inK30AicSCB"
    94 "DFC_rbr_inK30AicSCG"
    95 "DFC_rbr_inK30OR"
    96 "DFC_rbr_inK30SCB"
    97 "DFC_rbr_inK30SCG"
    98 "DFC_rbr_inK30ShuntSCB"
    99 "DFC_rbr_inK31OR"
    100 "DFC_rbr_inK31SCB"
    101 "DFC_rbr_inK31SCG"
    102 "DFC_rbr_inK32OR"
    103 "DFC_rbr_inK32SCB"
    104 "DFC_rbr_inK32SCG"
    105 "DFC_rbr_inK33OR"
    106 "DFC_rbr_inK33SCB"
    107 "DFC_rbr_inK33SCG"
    108 "DFC_rbr_inK34OR"
    109 "DFC_rbr_inK34SCB"
    110 "DFC_rbr_inK34SCG"
    111 "DFC_rbr_inK35OR"
    112 "DFC_rbr_inK35SCB"
    113 "DFC_rbr_inK35SCG"
    114 "DFC_rbr_inK36OR"
    115 "DFC_rbr_inK36SCB"
    116 "DFC_rbr_inK36SCG"
    117 "DFC_rbr_inK37AicSCB"
    118 "DFC_rbr_inK37AicSCG"
    119 "DFC_rbr_inK37OR"
    120 "DFC_rbr_inK37SCB"
    121 "DFC_rbr_inK37SCG"
    122 "DFC_rbr_inK37ShuntSCB"
    123 "DFC_rbr_inK38AicSCB"
    124 "DFC_rbr_inK38AicSCG"
    125 "DFC_rbr_inK38OR"
    126 "DFC_rbr_inK38SCB"
    127 "DFC_rbr_inK38SCG"
    128 "DFC_rbr_inK38ShuntSCB"
    129 "DFC_rbr_inK39AicSCB"
    130 "DFC_rbr_inK39AicSCG"
    131 "DFC_rbr_inK39OR"
    132 "DFC_rbr_inK39SCB"
    133 "DFC_rbr_inK39SCG"
    134 "DFC_rbr_inK39ShuntSCB"
    135 "DFC_rbr_inK40AicSCB"
    136 "DFC_rbr_inK40AicSCG"
    137 "DFC_rbr_inK40OR"
    138 "DFC_rbr_inK40SCB"
    139 "DFC_rbr_inK40SCG"
    140 "DFC_rbr_inK40ShuntSCB"
    141 "DFC_rbr_inK41AicSCB"
    142 "DFC_rbr_inK41AicSCG"
    143 "DFC_rbr_inK41OR"
    144 "DFC_rbr_inK41SCB"
    145 "DFC_rbr_inK41SCG"
    146 "DFC_rbr_inK41ShuntSCB"
    147 "DFC_rbr_inK42AicSCB"
    148 "DFC_rbr_inK42AicSCG"
    149 "DFC_rbr_inK42OR"
    150 "DFC_rbr_inK42SCB"
    151 "DFC_rbr_inK42SCG"
    152 "DFC_rbr_inK42ShuntSCB"
    153 "DFC_rbr_inK43OR"
    154 "DFC_rbr_inK43SCB"
    155 "DFC_rbr_inK43SCG"
    156 "DFC_rbr_inK44AicSCB"
    157 "DFC_rbr_inK44AicSCG"
    158 "DFC_rbr_inK44OR"
    159 "DFC_rbr_inK44SCB"
    160 "DFC_rbr_inK44SCG"
    161 "DFC_rbr_inK44ShuntSCB"
    162 "DFC_rbr_inK45AicSCB"
    163 "DFC_rbr_inK45AicSCG"
    164 "DFC_rbr_inK45OR"
    165 "DFC_rbr_inK45SCB"
    166 "DFC_rbr_inK45SCG"
    167 "DFC_rbr_inK45ShuntSCB"
    168 "DFC_rbr_inK52OR"
    169 "DFC_rbr_inK52SCB"
    170 "DFC_rbr_inK52SCG"
    171 "DFC_rbr_inK53OR"
    172 "DFC_rbr_inK53SCB"
    173 "DFC_rbr_inK53SCG"
    174 "DFC_rbr_inK54AicSCB"
    175 "DFC_rbr_inK54AicSCG"
    176 "DFC_rbr_inK54OR"
    177 "DFC_rbr_inK54SCB"
    178 "DFC_rbr_inK54SCG"
    179 "DFC_rbr_inK54ShuntSCB"
    180 "DFC_rbr_inK55AicSCB"
    181 "DFC_rbr_inK55AicSCG"
    182 "DFC_rbr_inK55OR"
    183 "DFC_rbr_inK55SCB"
    184 "DFC_rbr_inK55SCG"
    185 "DFC_rbr_inK55ShuntSCB"
    186 "DFC_rbr_inK56OR"
    187 "DFC_rbr_inK56SCB"
    188 "DFC_rbr_inK56SCG"
    189 "DFC_rbr_inK57OR"
    190 "DFC_rbr_inK57SCB"
    191 "DFC_rbr_inK57SCG"
    192 "DFC_rbr_inK58OR"
    193 "DFC_rbr_inK58SCB"
    194 "DFC_rbr_inK58SCG"
    195 "DFC_rbr_inK59OR"
    196 "DFC_rbr_inK59SCB"
    197 "DFC_rbr_inK59SCG"
    198 "DFC_rbr_inK60OR"
    199 "DFC_rbr_inK60SCB"
    200 "DFC_rbr_inK60SCG"
    201 "DFC_rbr_inK61AicSCB"
    202 "DFC_rbr_inK61AicSCG"
    203 "DFC_rbr_inK61OR"
    204 "DFC_rbr_inK61SCB"
    205 "DFC_rbr_inK61SCG"
    206 "DFC_rbr_inK61ShuntSCB"
    207 "DFC_rbr_inK62OR"
    208 "DFC_rbr_inK62SCB"
    209 "DFC_rbr_inK62SCG"
    210 "DFC_rbr_inK63AicSCB"
    211 "DFC_rbr_inK63AicSCG"
    212 "DFC_rbr_inK63OR"
    213 "DFC_rbr_inK63SCB"
    214 "DFC_rbr_inK63SCG"
    215 "DFC_rbr_inK63ShuntSCB"
    216 "DFC_rbr_inK64AicSCB"
    217 "DFC_rbr_inK64AicSCG"
    218 "DFC_rbr_inK64OR"
    219 "DFC_rbr_inK64SCB"
    220 "DFC_rbr_inK64SCG"
    221 "DFC_rbr_inK64ShuntSCB"
    222 "DFC_rbr_inK65AicSCB"
    223 "DFC_rbr_inK65AicSCG"
    224 "DFC_rbr_inK65OR"
    225 "DFC_rbr_inK65SCB"
    226 "DFC_rbr_inK65SCG"
    227 "DFC_rbr_inK65ShuntSCB"
    228 "DFC_rbr_inK74OR"
    229 "DFC_rbr_inK74SCB"
    230 "DFC_rbr_inK74SCG"
    231 "DFC_rbr_inK75OR"
    232 "DFC_rbr_inK75SCB"
    233 "DFC_rbr_inK75SCG"
    234 "DFC_rbr_inK76OR"
    235 "DFC_rbr_inK76SCB"
    236 "DFC_rbr_inK76SCG"
    237 "DFC_rbr_inK77OR"
    238 "DFC_rbr_inK77SCB"
    239 "DFC_rbr_inK77SCG"
    240 "DFC_rbr_inK78OR"
    241 "DFC_rbr_inK78SCB"
    242 "DFC_rbr_inK78SCG"
    243 "DFC_rbr_mo_DvUBAT_FWs"
    244 "DFC_rbr_mo_OVErr_VPR6"
    245 "DFC_rbr_mo_OVWarn_VPR6"
    246 "DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3"
    247 "DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2"
    248 "DFC_rbr_mo_OV_UBAT_MON"
    249 "DFC_rbr_mo_OV_UBRM24_FLEXIN"
    250 "DFC_rbr_mo_OV_UBRM24_LOADS"
    251 "DFC_rbr_mo_OV_UBRM24_MON"
    252 "DFC_rbr_mo_OV_VDD5"
    253 "DFC_rbr_mo_OV_VDD5_IN"
    254 "DFC_rbr_mo_OV_VPR6"
    255 "DFC_rbr_mo_OV_VSS3"
    256 "DFC_rbr_mo_OV_VSS4"
    257 "DFC_rbr_mo_Temp1_HTErr"
    258 "DFC_rbr_mo_Temp1_HTWarn"
    259 "DFC_rbr_mo_Temp2_HTErr"
    260 "DFC_rbr_mo_Temp2_HTWarn"
    261 "DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3"
    262 "DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2"
    263 "DFC_rbr_mo_UV_VDD5"
    264 "DFC_rbr_mo_UV_VDD5_IN"
    265 "DFC_rbr_mo_UV_VPR6"
    266 "DFC_rbr_mo_UV_VSS3"
    267 "DFC_rbr_mo_UV_VSS4"
    268 "DFC_rbr_outA01OL"
    269 "DFC_rbr_outA01OT"
    270 "DFC_rbr_outA01SCB"
    271 "DFC_rbr_outA01SCG"
    272 "DFC_rbr_outA02OL"
    273 "DFC_rbr_outA02OR"
    274 "DFC_rbr_outA02OT"
    275 "DFC_rbr_outA02SCB"
    276 "DFC_rbr_outA02SCG"
    277 "DFC_rbr_outA03OL"
    278 "DFC_rbr_outA03OT"
    279 "DFC_rbr_outA03SCB"
    280 "DFC_rbr_outA03SCG"
    281 "DFC_rbr_outA04OL"
    282 "DFC_rbr_outA04OT"
    283 "DFC_rbr_outA04SCB"
    284 "DFC_rbr_outA04SCG"
    285 "DFC_rbr_outA05OL"
    286 "DFC_rbr_outA05OR"
    287 "DFC_rbr_outA05OT"
    288 "DFC_rbr_outA05SCB"
    289 "DFC_rbr_outA05SCG"
    290 "DFC_rbr_outA06OL"
    291 "DFC_rbr_outA06OR"
    292 "DFC_rbr_outA06OT"
    293 "DFC_rbr_outA06SCB"
    294 "DFC_rbr_outA06SCG"
    295 "DFC_rbr_outA07OL"
    296 "DFC_rbr_outA07OT"
    297 "DFC_rbr_outA07SCB"
    298 "DFC_rbr_outA07SCG"
    299 "DFC_rbr_outA08OL"
    300 "DFC_rbr_outA08OT"
    301 "DFC_rbr_outA08SCB"
    302 "DFC_rbr_outA08SCG"
    303 "DFC_rbr_outA09OL"
    304 "DFC_rbr_outA09OR"
    305 "DFC_rbr_outA09OT"
    306 "DFC_rbr_outA09SCB"
    307 "DFC_rbr_outA09SCG"
    308 "DFC_rbr_outA10OL"
    309 "DFC_rbr_outA10OT"
    310 "DFC_rbr_outA10SCB"
    311 "DFC_rbr_outA10SCG"
    312 "DFC_rbr_outA11OL"
    313 "DFC_rbr_outA11OT"
    314 "DFC_rbr_outA11SCB"
    315 "DFC_rbr_outA11SCG"
    316 "DFC_rbr_outA12OR"
    317 "DFC_rbr_outA12SCB"
    318 "DFC_rbr_outA12SCG"
    319 "DFC_rbr_outA16OL"
    320 "DFC_rbr_outA16OT"
    321 "DFC_rbr_outA16SCB"
    322 "DFC_rbr_outA16SCG"
    323 "DFC_rbr_outA17OL"
    324 "DFC_rbr_outA17OR"
    325 "DFC_rbr_outA17OT"
    326 "DFC_rbr_outA17SCB"
    327 "DFC_rbr_outA17SCG"
    328 "DFC_rbr_outA18OL"
    329 "DFC_rbr_outA18OT"
    330 "DFC_rbr_outA18SCB"
    331 "DFC_rbr_outA18SCG"
    332 "DFC_rbr_outA19OL"
    333 "DFC_rbr_outA19OR"
    334 "DFC_rbr_outA19OT"
    335 "DFC_rbr_outA19SCB"
    336 "DFC_rbr_outA19SCG"
    337 "DFC_rbr_outA20OL"
    338 "DFC_rbr_outA20OR"
    339 "DFC_rbr_outA20OT"
    340 "DFC_rbr_outA20SCB"
    341 "DFC_rbr_outA20SCG"
    342 "DFC_rbr_outA31OL"
    343 "DFC_rbr_outA31OR"
    344 "DFC_rbr_outA31OT"
    345 "DFC_rbr_outA31SCB"
    346 "DFC_rbr_outA31SCG"
    347 "DFC_rbr_outA32OL"
    348 "DFC_rbr_outA32OR"
    349 "DFC_rbr_outA32OT"
    350 "DFC_rbr_outA32SCB"
    351 "DFC_rbr_outA32SCG"
    352 "DFC_rbr_outA33OL"
    353 "DFC_rbr_outA33OR"
    354 "DFC_rbr_outA33OT"
    355 "DFC_rbr_outA33SCB"
    356 "DFC_rbr_outA33SCG"
    357 "DFC_rbr_outA34OL"
    358 "DFC_rbr_outA34OR"
    359 "DFC_rbr_outA34OT"
    360 "DFC_rbr_outA34SCB"
    361 "DFC_rbr_outA34SCG"
    362 "DFC_rbr_outA35OL"
    363 "DFC_rbr_outA35OR"
    364 "DFC_rbr_outA35OT"
    365 "DFC_rbr_outA35SCB"
    366 "DFC_rbr_outA35SCG"
    367 "DFC_rbr_outA46OL"
    368 "DFC_rbr_outA46OR"
    369 "DFC_rbr_outA46OT"
    370 "DFC_rbr_outA46SCB"
    371 "DFC_rbr_outA46SCG"
    372 "DFC_rbr_outA47OL"
    373 "DFC_rbr_outA47OR"
    374 "DFC_rbr_outA47OT"
    375 "DFC_rbr_outA47SCB"
    376 "DFC_rbr_outA47SCG"
    377 "DFC_rbr_outA48OL"
    378 "DFC_rbr_outA48OR"
    379 "DFC_rbr_outA48OT"
    380 "DFC_rbr_outA48SCB"
    381 "DFC_rbr_outA48SCG"
    382 "DFC_rbr_outA49OL"
    383 "DFC_rbr_outA49OT"
    384 "DFC_rbr_outA49SCB"
    385 "DFC_rbr_outA49SCG"
    386 "DFC_rbr_outA50OL"
    387 "DFC_rbr_outA50OT"
    388 "DFC_rbr_outA50SCB"
    389 "DFC_rbr_outA50SCG"
    390 "DFC_rbr_outA51OL"
    391 "DFC_rbr_outA51OR"
    392 "DFC_rbr_outA51OT"
    393 "DFC_rbr_outA51SCB"
    394 "DFC_rbr_outA51SCG"
    395 "DFC_rbr_outA52OL"
    396 "DFC_rbr_outA52OR"
    397 "DFC_rbr_outA52OT"
    398 "DFC_rbr_outA52SCB"
    399 "DFC_rbr_outA52SCG"
    400 "DFC_rbr_outA53OL"
    401 "DFC_rbr_outA53OR"
    402 "DFC_rbr_outA53OT"
    403 "DFC_rbr_outA53SCB"
    404 "DFC_rbr_outA53SCG"
    405 "DFC_rbr_outA54OL"
    406 "DFC_rbr_outA54OR"
    407 "DFC_rbr_outA54OT"
    408 "DFC_rbr_outA54SCB"
    409 "DFC_rbr_outA54SCG"
    410 "DFC_rbr_outA55OL"
    411 "DFC_rbr_outA55OT"
    412 "DFC_rbr_outA55SCB"
    413 "DFC_rbr_outA55SCG"
    414 "DFC_rbr_outA56OL"
    415 "DFC_rbr_outA56OT"
    416 "DFC_rbr_outA56SCB"
    417 "DFC_rbr_outA56SCG"
    418 "DFC_rbr_outA58OL"
    419 "DFC_rbr_outA58OT"
    420 "DFC_rbr_outA58SCB"
    421 "DFC_rbr_outA58SCG"
    422 "DFC_rbr_outK07OL"
    423 "DFC_rbr_outK07OR"
    424 "DFC_rbr_outK07OT"
    425 "DFC_rbr_outK07SCB"
    426 "DFC_rbr_outK07SCG"
    427 "DFC_rbr_outK08OL"
    428 "DFC_rbr_outK08OR"
    429 "DFC_rbr_outK08OT"
    430 "DFC_rbr_outK08SCB"
    431 "DFC_rbr_outK08SCG"
    432 "DFC_rbr_outK09OL"
    433 "DFC_rbr_outK09OR"
    434 "DFC_rbr_outK09OT"
    435 "DFC_rbr_outK09SCB"
    436 "DFC_rbr_outK09SCG"
    437 "DFC_rbr_outK12OL"
    438 "DFC_rbr_outK12OT"
    439 "DFC_rbr_outK12SCB"
    440 "DFC_rbr_outK12SCG"
    441 "DFC_rbr_outK13OL"
    442 "DFC_rbr_outK13OT"
    443 "DFC_rbr_outK13SCB"
    444 "DFC_rbr_outK13SCG"
    445 "DFC_rbr_outK14OL"
    446 "DFC_rbr_outK14OR"
    447 "DFC_rbr_outK14OT"
    448 "DFC_rbr_outK14SCB"
    449 "DFC_rbr_outK14SCG"
    450 "DFC_rbr_outK15OL"
    451 "DFC_rbr_outK15OR"
    452 "DFC_rbr_outK15OT"
    453 "DFC_rbr_outK15SCB"
    454 "DFC_rbr_outK15SCG"
    455 "DFC_rbr_outK16OL"
    456 "DFC_rbr_outK16OR"
    457 "DFC_rbr_outK16OT"
    458 "DFC_rbr_outK16SCB"
    459 "DFC_rbr_outK16SCG"
    460 "DFC_rbr_outK17OL"
    461 "DFC_rbr_outK17OR"
    462 "DFC_rbr_outK17OT"
    463 "DFC_rbr_outK17SCB"
    464 "DFC_rbr_outK17SCG"
    465 "DFC_rbr_outK25OR"
    466 "DFC_rbr_outK25SCB"
    467 "DFC_rbr_outK25SCG"
    468 "DFC_rbr_outK29OL"
    469 "DFC_rbr_outK29OR"
    470 "DFC_rbr_outK29OT"
    471 "DFC_rbr_outK29SCB"
    472 "DFC_rbr_outK29SCG"
    473 "DFC_rbr_outK51OL"
    474 "DFC_rbr_outK51OT"
    475 "DFC_rbr_outK51SCB"
    476 "DFC_rbr_outK51SCG"
    477 "DFC_rbr_outK62OR"
    478 "DFC_rbr_outK62SCB"
    479 "DFC_rbr_outK62SCG"
    480 "DFC_rbr_outK73OL"
    481 "DFC_rbr_outK73OR"
    482 "DFC_rbr_outK73OT"
    483 "DFC_rbr_outK73SCB"
    484 "DFC_rbr_outK73SCG"
    485 "DFC_rbr_outK80OL"
    486 "DFC_rbr_outK80OT"
    487 "DFC_rbr_outK80SCB"
    488 "DFC_rbr_outK80SCG"
    489 "DFC_rbr_outK81OL"
    490 "DFC_rbr_outK81OT"
    491 "DFC_rbr_outK81SCB"
    492 "DFC_rbr_outK81SCG"
    493 "DFC_rbr_outK82OL"
    494 "DFC_rbr_outK82OT"
    495 "DFC_rbr_outK82SCB"
    496 "DFC_rbr_outK82SCG"
    497 "DFC_rbr_outK83OL"
    498 "DFC_rbr_outK83OT"
    499 "DFC_rbr_outK83SCB"
    500 "DFC_rbr_outK83SCG"
    501 "DFC_rbr_outK84OL"
    502 "DFC_rbr_outK84OT"
    503 "DFC_rbr_outK84SCB"
    504 "DFC_rbr_outK84SCG"
    505 "DFC_rbr_outK85OL"
    506 "DFC_rbr_outK85OT"
    507 "DFC_rbr_outK85SCB"
    508 "DFC_rbr_outK85SCG"
    509 "DFC_rbr_outK86OL"
    510 "DFC_rbr_outK86OT"
    511 "DFC_rbr_outK86SCB"
    512 "DFC_rbr_outK86SCG"
    513 "DFC_rbr_outK87OL"
    514 "DFC_rbr_outK87OT"
    515 "DFC_rbr_outK87SCB"
    516 "DFC_rbr_outK87SCG"
    517 "DFC_bds_EventUpDownDebFault"
    518 "DFC_DSMDummy"
    519 "DFC_rbr_canGetDataNoBuf"
    520 "DFC_rbr_canGetDataParam"
    521 "DFC_rbr_canGetDataboxNoInit"
    522 "DFC_rbr_canGetDataboxParam"
    523 "DFC_rbr_canGetRxBufStatusParam"
    524 "DFC_rbr_canGetStatusParam"
    525 "DFC_rbr_canGetTxBufStatusParam"
    526 "DFC_rbr_canInitParam"
    527 "DFC_rbr_canInitRxDataboxOverlap"
    528 "DFC_rbr_canInitRxDataboxParam"
    529 "DFC_rbr_canInitTxDataboxParam"
    530 "DFC_rbr_canIpduGroupControl"
    531 "DFC_rbr_canIsDataboxFreeNoInit"
    532 "DFC_rbr_canIsDataboxFreeParam"
    533 "DFC_rbr_canIsTxEmptyParam"
    534 "DFC_rbr_canRegBusOffCallbInvState"
    535 "DFC_rbr_canRegBusOffCallbParam"
    536 "DFC_rbr_canRegRxBufInvState"
    537 "DFC_rbr_canRegRxBufOverlap"
    538 "DFC_rbr_canRegRxBufParam"
    539 "DFC_rbr_canRegRxCallbInvState"
    540 "DFC_rbr_canRegRxCallbParam"
    541 "DFC_rbr_canRegRxDataboxInvNumb"
    542 "DFC_rbr_canRegRxDataboxInvState"
    543 "DFC_rbr_canRegRxDataboxOverlap"
    544 "DFC_rbr_canRegRxDataboxParam"
    545 "DFC_rbr_canRegTxBufInvState"
    546 "DFC_rbr_canRegTxBufOverlap"
    547 "DFC_rbr_canRegTxBufParam"
    548 "DFC_rbr_canRegTxDataboxInvNumb"
    549 "DFC_rbr_canRegTxDataboxInvState"
    550 "DFC_rbr_canRegTxDataboxOverlap"
    551 "DFC_rbr_canRegTxDataboxParam"
    552 "DFC_rbr_canResetTxBufParam"
    553 "DFC_rbr_canSendDataBufOvfl"
    554 "DFC_rbr_canSendDataParam"
    555 "DFC_rbr_canSendDataboxNoInit"
    556 "DFC_rbr_canSendDataboxParam"
    557 "DFC_rbr_canSetTxCycleParam"
    558 "DFC_rbr_canStartParam"
    559 "DFC_rbr_canStopParam"
    560 "DFC_rbr_can_ClearIpduGroup"
    561 "DFC_rbr_can_ReceiveSignal"
    562 "DFC_rbr_can_SendSignal"
    563 "DFC_rbr_can_SetIpduGroup"
    564 "DFC_rbr_dsmDTCJ1939"
    565 "DFC_rbr_dsmDelDTCJ1939"
    566 "DFC_rbr_dsmDelErrors"
    567 "DFC_rbr_dsmGetDFES"
    568 "DFC_rbr_dsmGetDTCJ1939"
    569 "DFC_rbr_dsmGetErrors"
    570 "DFC_rbr_dsmGetNumErrors"
    571 "DFC_rbr_dsmInitQueueOverflow"
    572 "DFC_rbr_dsmNumDTCJ1939"
    573 "DFC_rbr_dsmTesterror"
    574 "DFC_rbr_dsmUpdateDebError"
    575 "DFC_rbr_dsmUpdateError"
    576 "DFC_rbr_dsmgetDFCStatus"
    577 "DFC_rbr_dsmtestErrorDFC"
    578 "DFC_rbr_inAi"
    579 "DFC_rbr_inAic"
    580 "DFC_rbr_inAicCfg"
    581 "DFC_rbr_inAicGetStatus"
    582 "DFC_rbr_inAid"
    583 "DFC_rbr_inAidCfg"
    584 "DFC_rbr_inAiv"
    585 "DFC_rbr_inAivCfg"
    586 "DFC_rbr_inAivGetStatus"
    587 "DFC_rbr_inDi"
    588 "DFC_rbr_inFi"
    589 "DFC_rbr_inFiCfg"
    590 "DFC_rbr_inFiGetStatus"
    591 "DFC_rbr_inFi_Buffered"
    592 "DFC_rbr_inPhase"
    593 "DFC_rbr_inPhaseGetStatus"
    594 "DFC_rbr_inPhaseResetCounter"
    595 "DFC_rbr_inRi"
    596 "DFC_rbr_inRiCfg"
    597 "DFC_rbr_inRiCfgTemp"
    598 "DFC_rbr_inRiGetStatus"
    599 "DFC_rbr_inRiGetTemp"
    600 "DFC_rbr_inSentCopyFDFifo"
    601 "DFC_rbr_inSentDisable"
    602 "DFC_rbr_inSentEnable"
    603 "DFC_rbr_inSentGetErrorStatus"
    604 "DFC_rbr_inSentGetFD"
    605 "DFC_rbr_inSentGetSD"
    606 "DFC_rbr_inSentGetSDDatabox"
    607 "DFC_rbr_inSentGetStatus"
    608 "DFC_rbr_inSentInitSDDatabox"
    609 "DFC_rbr_inSentRegisterCopyFDFifo"
    610 "DFC_rbr_inSentRegisterFDFifo"
    611 "DFC_rbr_inSentRegisterSDDataboxes"
    612 "DFC_rbr_isobusCanRxBufferOverflow"
    613 "DFC_rbr_isobusGetCaAddrParam"
    614 "DFC_rbr_isobusGetDiagnosticParam"
    615 "DFC_rbr_isobusGetRxDataboxStatusParam"
    616 "DFC_rbr_isobusGetStatusParam"
    617 "DFC_rbr_isobusInitCommCaMissing"
    618 "DFC_rbr_isobusInitCommParam"
    619 "DFC_rbr_isobusInitCommState"
    620 "DFC_rbr_isobusInitDiagnosticParam"
    621 "DFC_rbr_isobusInitFailureListParam"
    622 "DFC_rbr_isobusInitRxDataboxParam"
    623 "DFC_rbr_isobusInitTxDataboxParam"
    624 "DFC_rbr_isobusRegRxDataboxOverlap"
    625 "DFC_rbr_isobusRegRxDataboxParam"
    626 "DFC_rbr_isobusRegRxDataboxState"
    627 "DFC_rbr_isobusRegTxDataboxOverlap"
    628 "DFC_rbr_isobusRegTxDataboxParam"
    629 "DFC_rbr_isobusRegTxDataboxState"
    630 "DFC_rbr_isobusRegisterErrClrCallbackParam"
    631 "DFC_rbr_isobusRegisterInstancesOverlap"
    632 "DFC_rbr_isobusRegisterInstancesParam"
    633 "DFC_rbr_isobusRegisterInstancesState"
    634 "DFC_rbr_isobusSendDataboxParam"
    635 "DFC_rbr_isobusSendRequestPGNParam"
    636 "DFC_rbr_isobusSetCaAddrCaUsed"
    637 "DFC_rbr_isobusSetCaAddrComm"
    638 "DFC_rbr_isobusSetCaAddrInvCan"
    639 "DFC_rbr_isobusSetCaAddrParam"
    640 "DFC_rbr_isobusSetCaInfoParam"
    641 "DFC_rbr_isobusSetCaNameParam"
    642 "DFC_rbr_isobusSftyCanTxErr"
    643 "DFC_rbr_lin_ReceiveSignal"
    644 "DFC_rbr_lin_SendSignal"
    645 "DFC_rbr_lin_getStatus"
    646 "DFC_rbr_lin_gotoSleep"
    647 "DFC_rbr_lin_scheduleRequest"
    648 "DFC_rbr_lin_wakeUp"
    649 "DFC_rbr_memFlsCfgShr"
    650 "DFC_rbr_memGetStatus"
    651 "DFC_rbr_memMarkBlock"
    652 "DFC_rbr_memReadApi1Error"
    653 "DFC_rbr_memReadApi2Error"
    654 "DFC_rbr_memReadBlock"
    655 "DFC_rbr_memReadCalibInputError"
    656 "DFC_rbr_memReadCalibOuputError"
    657 "DFC_rbr_memReadSystemError"
    658 "DFC_rbr_memWriteBlock"
    659 "DFC_rbr_moOV_FirstConstADC"
    660 "DFC_rbr_moOV_SecondConstADC"
    661 "DFC_rbr_moUV_FirstConstADC"
    662 "DFC_rbr_moUV_SecondConstADC"
    663 "DFC_rbr_mo_INH"
    664 "DFC_rbr_mo_INHLatch"
    665 "DFC_rbr_mo_adcPDD_fail"
    666 "DFC_rbr_mo_memoryProtection_err"
    667 "DFC_rbr_outA02OC"
    668 "DFC_rbr_outA02Unintended"
    669 "DFC_rbr_outA03OC"
    670 "DFC_rbr_outA03Unintended"
    671 "DFC_rbr_outA04OC"
    672 "DFC_rbr_outA04Unintended"
    673 "DFC_rbr_outA05OC"
    674 "DFC_rbr_outA05Unintended"
    675 "DFC_rbr_outA07OC"
    676 "DFC_rbr_outA07Unintended"
    677 "DFC_rbr_outA08OC"
    678 "DFC_rbr_outA08Unintended"
    679 "DFC_rbr_outA09OC"
    680 "DFC_rbr_outA09Unintended"
    681 "DFC_rbr_outA10OC"
    682 "DFC_rbr_outA10Unintended"
    683 "DFC_rbr_outA17OC"
    684 "DFC_rbr_outA17Unintended"
    685 "DFC_rbr_outA18OC"
    686 "DFC_rbr_outA18Unintended"
    687 "DFC_rbr_outA19OC"
    688 "DFC_rbr_outA19Unintended"
    689 "DFC_rbr_outA20OC"
    690 "DFC_rbr_outA20Unintended"
    691 "DFC_rbr_outA31OC"
    692 "DFC_rbr_outA31Unintended"
    693 "DFC_rbr_outA32OC"
    694 "DFC_rbr_outA32Unintended"
    695 "DFC_rbr_outA33OC"
    696 "DFC_rbr_outA33Unintended"
    697 "DFC_rbr_outA34OC"
    698 "DFC_rbr_outA34Unintended"
    699 "DFC_rbr_outA35OC"
    700 "DFC_rbr_outA35Unintended"
    701 "DFC_rbr_outA46OC"
    702 "DFC_rbr_outA46Unintended"
    703 "DFC_rbr_outA47OC"
    704 "DFC_rbr_outA47Unintended"
    705 "DFC_rbr_outA48OC"
    706 "DFC_rbr_outA48Unintended"
    707 "DFC_rbr_outA51OC"
    708 "DFC_rbr_outA51Unintended"
    709 "DFC_rbr_outA52OC"
    710 "DFC_rbr_outA52Unintended"
    711 "DFC_rbr_outA53OC"
    712 "DFC_rbr_outA53Unintended"
    713 "DFC_rbr_outA54OC"
    714 "DFC_rbr_outA54Unintended"
    715 "DFC_rbr_outAov"
    716 "DFC_rbr_outAovCfg"
    717 "DFC_rbr_outAovCfgPI"
    718 "DFC_rbr_outAovGetStatus"
    719 "DFC_rbr_outAovGetVoltage"
    720 "DFC_rbr_outAovResetError"
    721 "DFC_rbr_outDo"
    722 "DFC_rbr_outDoCfgPwrLs"
    723 "DFC_rbr_outDoDisable"
    724 "DFC_rbr_outDoGetCurrent"
    725 "DFC_rbr_outDoGetStatus"
    726 "DFC_rbr_outDoResetError"
    727 "DFC_rbr_outK07OC"
    728 "DFC_rbr_outK07Unintended"
    729 "DFC_rbr_outK08OC"
    730 "DFC_rbr_outK08Unintended"
    731 "DFC_rbr_outK09OC"
    732 "DFC_rbr_outK09Unintended"
    733 "DFC_rbr_outK12OC"
    734 "DFC_rbr_outK12Unintended"
    735 "DFC_rbr_outK13OC"
    736 "DFC_rbr_outK13Unintended"
    737 "DFC_rbr_outK14OC"
    738 "DFC_rbr_outK14Unintended"
    739 "DFC_rbr_outK15OC"
    740 "DFC_rbr_outK15Unintended"
    741 "DFC_rbr_outK16OC"
    742 "DFC_rbr_outK16Unintended"
    743 "DFC_rbr_outK17OC"
    744 "DFC_rbr_outK17Unintended"
    745 "DFC_rbr_outK29OC"
    746 "DFC_rbr_outK29Unintended"
    747 "DFC_rbr_outK51OC"
    748 "DFC_rbr_outK51Unintended"
    749 "DFC_rbr_outK73OC"
    750 "DFC_rbr_outK73Unintended"
    751 "DFC_rbr_outPo"
    752 "DFC_rbr_outPoCfg"
    753 "DFC_rbr_outPoCfgPeriod"
    754 "DFC_rbr_outPoCfgPwrLs"
    755 "DFC_rbr_outPoDisable"
    756 "DFC_rbr_outPoGetCurrent"
    757 "DFC_rbr_outPoGetStatus"
    758 "DFC_rbr_outPoResetError"
    759 "DFC_rbr_outPoc"
    760 "DFC_rbr_outPocCfg"
    761 "DFC_rbr_outPocCfgDither"
    762 "DFC_rbr_outPocCfgPI"
    763 "DFC_rbr_outPod"
    764 "DFC_rbr_outPodCfg"
    765 "DFC_rbr_outPodCfgPeriod"
    766 "DFC_rbr_rsmFfiApiCallErr"
    767 "DFC_rbr_safout"
    768 "DFC_rbr_safoutCfg"
    769 "DFC_rbr_safoutChnl1"
    770 "DFC_rbr_safoutChnl10"
    771 "DFC_rbr_safoutChnl10Dev"
    772 "DFC_rbr_safoutChnl10OR"
    773 "DFC_rbr_safoutChnl11"
    774 "DFC_rbr_safoutChnl11Dev"
    775 "DFC_rbr_safoutChnl11OR"
    776 "DFC_rbr_safoutChnl12"
    777 "DFC_rbr_safoutChnl12Dev"
    778 "DFC_rbr_safoutChnl12OR"
    779 "DFC_rbr_safoutChnl13"
    780 "DFC_rbr_safoutChnl13Dev"
    781 "DFC_rbr_safoutChnl13OR"
    782 "DFC_rbr_safoutChnl14"
    783 "DFC_rbr_safoutChnl14Dev"
    784 "DFC_rbr_safoutChnl14OR"
    785 "DFC_rbr_safoutChnl15"
    786 "DFC_rbr_safoutChnl15Dev"
    787 "DFC_rbr_safoutChnl15OR"
    788 "DFC_rbr_safoutChnl16"
    789 "DFC_rbr_safoutChnl16Dev"
    790 "DFC_rbr_safoutChnl16OR"
    791 "DFC_rbr_safoutChnl17"
    792 "DFC_rbr_safoutChnl17Dev"
    793 "DFC_rbr_safoutChnl17OR"
    794 "DFC_rbr_safoutChnl18"
    795 "DFC_rbr_safoutChnl18Dev"
    796 "DFC_rbr_safoutChnl18OR"
    797 "DFC_rbr_safoutChnl1Dev"
    798 "DFC_rbr_safoutChnl1OR"
    799 "DFC_rbr_safoutChnl2"
    800 "DFC_rbr_safoutChnl2Dev"
    801 "DFC_rbr_safoutChnl2OR"
    802 "DFC_rbr_safoutChnl3"
    803 "DFC_rbr_safoutChnl3Dev"
    804 "DFC_rbr_safoutChnl3OR"
    805 "DFC_rbr_safoutChnl4"
    806 "DFC_rbr_safoutChnl4Dev"
    807 "DFC_rbr_safoutChnl4OR"
    808 "DFC_rbr_safoutChnl5"
    809 "DFC_rbr_safoutChnl5Dev"
    810 "DFC_rbr_safoutChnl5OR"
    811 "DFC_rbr_safoutChnl6"
    812 "DFC_rbr_safoutChnl6Dev"
    813 "DFC_rbr_safoutChnl6OR"
    814 "DFC_rbr_safoutChnl7"
    815 "DFC_rbr_safoutChnl7Dev"
    816 "DFC_rbr_safoutChnl7OR"
    817 "DFC_rbr_safoutChnl8"
    818 "DFC_rbr_safoutChnl8Dev"
    819 "DFC_rbr_safoutChnl8OR"
    820 "DFC_rbr_safoutChnl9"
    821 "DFC_rbr_safoutChnl9Dev"
    822 "DFC_rbr_safoutChnl9OR"
    823 "DFC_rbr_safoutDevError"
    824 "DFC_rbr_safoutGetStatus"
    825 "DFC_rbr_safoutIgnoreError"
    826 "DFC_rbr_safoutResetError"
    827 "DFC_rbr_safoutUnlock"
    828 "DFC_rbr_safout_cfgDiag"
    829 "DFC_rbr_secAccessDenied_RC"
    830 "DFC_rbr_secAccessDenied_WDBI"
    831 "DFC_rbr_secEvalRespKey"
    832 "DFC_rbr_secFlashingFailure"
    833 "DFC_rbr_secGetLevel"
    834 "DFC_rbr_secGetRnd"
    835 "DFC_rbr_secGetSeed"
    836 "DFC_rbr_secInvalidPassword"
    837 "DFC_rbr_secIsRequestAllowed"
    838 "DFC_rbr_secResetLevel"
    839 "DFC_rbr_secSaveSecret"
    840 "DFC_rbr_secSetLevel"
    841 "DFC_rbr_sysAit"
    842 "DFC_rbr_sysAiv"
    843 "DFC_rbr_sysDi"
    844 "DFC_rbr_sysDo"
    845 "DFC_rbr_sysGetVss"
    846 "DFC_rbr_sysInit"
    847 "DFC_rbr_sysOperHrIntegrityErr"
    848 "DFC_rbr_sysOperHrsSaturated"
    849 "DFC_rbr_sysSetVss"
    850 "DFC_rbr_sys_coreload"
    851 "DFC_rbr_sys_taskload"
    852 "DFC_rbr_mo_OV_VSS1"
    853 "DFC_rbr_mo_OV_VSS2"
    854 "DFC_rbr_mo_UV_VSS1"
    855 "DFC_rbr_mo_UV_VSS2"
    856 "DFC_CANSM_E_BUS_OFF_NETWORK_0"
    857 "DFC_CANSM_E_BUS_OFF_NETWORK_1"
    858 "DFC_CANSM_E_BUS_OFF_NETWORK_2"
    859 "DFC_CANSM_E_BUS_OFF_NETWORK_3"
    860 "DFC_CANTRCV_E_NO_TRCV_CONTROL_0"
    861 "DFC_CAN_E_TIMEOUT"
    862 "DFC_COMM_E_NET_START_IND_CHANNEL_0"
    863 "DFC_COMM_E_NET_START_IND_CHANNEL_1"
    864 "DFC_COMM_E_NET_START_IND_CHANNEL_2"
    865 "DFC_COMM_E_NET_START_IND_CHANNEL_3"
    866 "DFC_COMM_E_NET_START_IND_CHANNEL_4"
    867 "DFC_COMM_E_NET_START_IND_CHANNEL_5"
    868 "DFC_LIN_E_TIMEOUT"
    869 "DFC_rba_MultiStackTrace_Threshold"
    870 "DFC_ETH_E_ACCESS_0"
    871 "DFC_RBA_IOEXTLIB_KEEPALIVE_DRV"
    872 "DFC_RBA_IOEXTLIB_KEEPALIVE_INI"
    873 "DFC_rba_MRly_Diag_Stk_Event"
    874 "DFC_rba_MemDiagExtd_MemReadSngErr"
    875 "DFC_rba_MemDiag_MemReadErr"
    876 "DFC_rba_MemDiag_MemWrErr"
    877 "DFC_rba_SyC_IrrSwOffTrigEngRun_Event"
    878 "DFC_rba_T15_Diag_ComInVld_Event"
    879 "DFC_rba_T15_Diag_ComOff_HwOn_Event"
    880 "DFC_rba_T15_Diag_ComOn_HwOff_Event"
    881 "DFC_MOXEMM_SMU_ALM0_0"
    882 "DFC_MOXEMM_SMU_ALM0_1"
    883 "DFC_MOXEMM_SMU_ALM0_10"
    884 "DFC_MOXEMM_SMU_ALM0_11"
    885 "DFC_MOXEMM_SMU_ALM0_13"
    886 "DFC_MOXEMM_SMU_ALM0_14"
    887 "DFC_MOXEMM_SMU_ALM0_2"
    888 "DFC_MOXEMM_SMU_ALM0_22"
    889 "DFC_MOXEMM_SMU_ALM0_23"
    890 "DFC_MOXEMM_SMU_ALM0_4"
    891 "DFC_MOXEMM_SMU_ALM0_5"
    892 "DFC_MOXEMM_SMU_ALM0_7"
    893 "DFC_MOXEMM_SMU_ALM0_8"
    894 "DFC_MOXEMM_SMU_ALM10_16"
    895 "DFC_MOXEMM_SMU_ALM10_17"
    896 "DFC_MOXEMM_SMU_ALM10_21"
    897 "DFC_MOXEMM_SMU_ALM11_0"
    898 "DFC_MOXEMM_SMU_ALM11_1"
    899 "DFC_MOXEMM_SMU_ALM11_2"
    900 "DFC_MOXEMM_SMU_ALM11_3"
    901 "DFC_MOXEMM_SMU_ALM11_4"
    902 "DFC_MOXEMM_SMU_ALM11_5"
    903 "DFC_MOXEMM_SMU_ALM11_8"
    904 "DFC_MOXEMM_SMU_ALM11_9"
    905 "DFC_MOXEMM_SMU_ALM1_0"
    906 "DFC_MOXEMM_SMU_ALM1_1"
    907 "DFC_MOXEMM_SMU_ALM1_10"
    908 "DFC_MOXEMM_SMU_ALM1_11"
    909 "DFC_MOXEMM_SMU_ALM1_13"
    910 "DFC_MOXEMM_SMU_ALM1_14"
    911 "DFC_MOXEMM_SMU_ALM1_2"
    912 "DFC_MOXEMM_SMU_ALM1_22"
    913 "DFC_MOXEMM_SMU_ALM1_23"
    914 "DFC_MOXEMM_SMU_ALM1_4"
    915 "DFC_MOXEMM_SMU_ALM1_5"
    916 "DFC_MOXEMM_SMU_ALM1_7"
    917 "DFC_MOXEMM_SMU_ALM1_8"
    918 "DFC_MOXEMM_SMU_ALM21_0"
    919 "DFC_MOXEMM_SMU_ALM21_16"
    920 "DFC_MOXEMM_SMU_ALM21_3"
    921 "DFC_MOXEMM_SMU_ALM2_1"
    922 "DFC_MOXEMM_SMU_ALM2_10"
    923 "DFC_MOXEMM_SMU_ALM2_11"
    924 "DFC_MOXEMM_SMU_ALM2_13"
    925 "DFC_MOXEMM_SMU_ALM2_14"
    926 "DFC_MOXEMM_SMU_ALM2_2"
    927 "DFC_MOXEMM_SMU_ALM2_22"
    928 "DFC_MOXEMM_SMU_ALM2_23"
    929 "DFC_MOXEMM_SMU_ALM2_4"
    930 "DFC_MOXEMM_SMU_ALM2_5"
    931 "DFC_MOXEMM_SMU_ALM2_7"
    932 "DFC_MOXEMM_SMU_ALM2_8"
    933 "DFC_MOXEMM_SMU_ALM3_1"
    934 "DFC_MOXEMM_SMU_ALM3_10"
    935 "DFC_MOXEMM_SMU_ALM3_11"
    936 "DFC_MOXEMM_SMU_ALM3_13"
    937 "DFC_MOXEMM_SMU_ALM3_14"
    938 "DFC_MOXEMM_SMU_ALM3_2"
    939 "DFC_MOXEMM_SMU_ALM3_22"
    940 "DFC_MOXEMM_SMU_ALM3_23"
    941 "DFC_MOXEMM_SMU_ALM3_4"
    942 "DFC_MOXEMM_SMU_ALM3_5"
    943 "DFC_MOXEMM_SMU_ALM3_7"
    944 "DFC_MOXEMM_SMU_ALM3_8"
    945 "DFC_MOXEMM_SMU_ALM6_0"
    946 "DFC_MOXEMM_SMU_ALM6_11"
    947 "DFC_MOXEMM_SMU_ALM6_12"
    948 "DFC_MOXEMM_SMU_ALM6_14"
    949 "DFC_MOXEMM_SMU_ALM6_15"
    950 "DFC_MOXEMM_SMU_ALM6_17"
    951 "DFC_MOXEMM_SMU_ALM6_18"
    952 "DFC_MOXEMM_SMU_ALM6_2"
    953 "DFC_MOXEMM_SMU_ALM6_20"
    954 "DFC_MOXEMM_SMU_ALM6_21"
    955 "DFC_MOXEMM_SMU_ALM6_25"
    956 "DFC_MOXEMM_SMU_ALM6_4"
    957 "DFC_MOXEMM_SMU_ALM6_5"
    958 "DFC_MOXEMM_SMU_ALM6_7"
    959 "DFC_MOXEMM_SMU_ALM6_8"
    960 "DFC_MOXEMM_SMU_ALM7_1"
    961 "DFC_MOXEMM_SMU_ALM7_12"
    962 "DFC_MOXEMM_SMU_ALM7_13"
    963 "DFC_MOXEMM_SMU_ALM7_14"
    964 "DFC_MOXEMM_SMU_ALM7_15"
    965 "DFC_MOXEMM_SMU_ALM7_16"
    966 "DFC_MOXEMM_SMU_ALM7_17"
    967 "DFC_MOXEMM_SMU_ALM7_2"
    968 "DFC_MOXEMM_SMU_ALM7_20"
    969 "DFC_MOXEMM_SMU_ALM7_25"
    970 "DFC_MOXEMM_SMU_ALM7_26"
    971 "DFC_MOXEMM_SMU_ALM7_28"
    972 "DFC_MOXEMM_SMU_ALM7_29"
    973 "DFC_MOXEMM_SMU_ALM7_30"
    974 "DFC_MOXEMM_SMU_ALM7_31"
    975 "DFC_MOXEMM_SMU_ALM8_0"
    976 "DFC_MOXEMM_SMU_ALM8_1"
    977 "DFC_MOXEMM_SMU_ALM8_10"
    978 "DFC_MOXEMM_SMU_ALM8_11"
    979 "DFC_MOXEMM_SMU_ALM8_12"
    980 "DFC_MOXEMM_SMU_ALM8_13"
    981 "DFC_MOXEMM_SMU_ALM8_16"
    982 "DFC_MOXEMM_SMU_ALM8_18"
    983 "DFC_MOXEMM_SMU_ALM8_2"
    984 "DFC_MOXEMM_SMU_ALM8_3"
    985 "DFC_MOXEMM_SMU_ALM8_30"
    986 "DFC_MOXEMM_SMU_ALM8_31"
    987 "DFC_MOXEMM_SMU_ALM8_4"
    988 "DFC_MOXEMM_SMU_ALM9_0"
    989 "DFC_MOXEMM_SMU_ALM9_1"
    990 "DFC_MOXEMM_SMU_ALM9_15"
    991 "DFC_MOXEMM_SMU_ALM9_3"
    992 "DFC_MoCSOPICO"
    993 "DFC_MoFVarPostBldSel"
    994 "DFC_MoSysCtrlReIni"
    995 "DFC_MoXEMMHwLTMCUFW"
    996 "DFC_MoXEMMHwLTMonBIST"
    997 "DFC_MoXEMMHwLTRegMonTest"
    998 "DFC_MoXEMMHwLTStbySMUAlvTest"
    999 "DFC_MoXEMMHwLTTempSens"
    1000 "DFC_MoXEMMHwLTUCBCfg"
    1001 "DFC_OCWDAABEActv"
    1002 "DFC_OCWDACom"
    1003 "DFC_OCWDAErrPin"
    1004 "DFC_SWReset_0"
    1005 "DFC_SWReset_1"
    1006 "DFC_SWReset_2"
    1007 "DFC_bds_NoDebFault1"
    1008 "DSQ_DSMInhibitAlways"
    1009 "DSQ_ErrLmpActrMIL"
    1010 "DSQ_ErrLmpActrSVS"
    1011 "DSQ_StopLmp"
    1012 "DSQ_T15TurnOfDly"
    1013 "DSQ_WrnLmp"
    65535 "Inhibited_Trip"

    DEFAULT_VALUE "---"

/end COMPU_VTAB

/begin COMPU_METHOD
    DFC_CALPRMSTATDISBLMSK_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DFC_CALPRMSTATDISBLMSK_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DFC_CALPRMSTATDISBLMSK_SC_Compu
    ""
    TAB_VERB
    2
    0 "Disabled"
    1 "Enabled"


/end COMPU_VTAB

/begin COMPU_METHOD

    DFC_CTLDISBLLAYOUT_SY_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    DFC_CTLMSKBYTES_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DFC_CTLMSKBYTES_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DFC_CTLMSKBYTES_SY_Compu
    ""
    TAB_VERB
    2
    1 "SIZE_1_BYTE"
    2 "SIZE_2_BYTES"


/end COMPU_VTAB

/begin COMPU_METHOD
    DFC_DISBLMSKBYTES_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DFC_DISBLMSKBYTES_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DFC_DISBLMSKBYTES_SY_Compu
    ""
    TAB_VERB
    3
    1 "SIZE_1_BYTE"
    2 "SIZE_2_BYTES"
    4 "SIZE_4_BYTES"


/end COMPU_VTAB

/begin COMPU_METHOD

    DFC_OneToOne
    ""
    RAT_FUNC
    "%6.2"
    "NO"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    DFC_SETSTATDITHOAPI_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DFC_SETSTATDITHOAPI_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DFC_SETSTATDITHOAPI_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DFC_Verb
    ""
    TAB_VERB
    "%2.1"
    "NO"
    COMPU_TAB_REF DFC_Verb
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DFC_Verb
    ""
    TAB_VERB
    1008
    0 "DFC_Unused"
    2 "DFC_bds_EventInRowDebFault"
    517 "DFC_bds_EventUpDownDebFault"
    1007 "DFC_bds_NoDebFault1"
    1 "DFC_bds_TimeInRowDebFault"
    5 "DFC_bds_TimeUpDownDebFault"
    861 "DFC_CAN_E_TIMEOUT"
    856 "DFC_CANSM_E_BUS_OFF_NETWORK_0"
    857 "DFC_CANSM_E_BUS_OFF_NETWORK_1"
    858 "DFC_CANSM_E_BUS_OFF_NETWORK_2"
    859 "DFC_CANSM_E_BUS_OFF_NETWORK_3"
    860 "DFC_CANTRCV_E_NO_TRCV_CONTROL_0"
    862 "DFC_COMM_E_NET_START_IND_CHANNEL_0"
    863 "DFC_COMM_E_NET_START_IND_CHANNEL_1"
    864 "DFC_COMM_E_NET_START_IND_CHANNEL_2"
    865 "DFC_COMM_E_NET_START_IND_CHANNEL_3"
    866 "DFC_COMM_E_NET_START_IND_CHANNEL_4"
    867 "DFC_COMM_E_NET_START_IND_CHANNEL_5"
    3 "DFC_DevLibBattUHi"
    4 "DFC_DevLibBattULo"
    518 "DFC_DSMDummy"
    870 "DFC_ETH_E_ACCESS_0"
    868 "DFC_LIN_E_TIMEOUT"
    992 "DFC_MoCSOPICO"
    993 "DFC_MoFVarPostBldSel"
    994 "DFC_MoSysCtrlReIni"
    881 "DFC_MOXEMM_SMU_ALM0_0"
    882 "DFC_MOXEMM_SMU_ALM0_1"
    883 "DFC_MOXEMM_SMU_ALM0_10"
    884 "DFC_MOXEMM_SMU_ALM0_11"
    885 "DFC_MOXEMM_SMU_ALM0_13"
    886 "DFC_MOXEMM_SMU_ALM0_14"
    887 "DFC_MOXEMM_SMU_ALM0_2"
    888 "DFC_MOXEMM_SMU_ALM0_22"
    889 "DFC_MOXEMM_SMU_ALM0_23"
    890 "DFC_MOXEMM_SMU_ALM0_4"
    891 "DFC_MOXEMM_SMU_ALM0_5"
    892 "DFC_MOXEMM_SMU_ALM0_7"
    893 "DFC_MOXEMM_SMU_ALM0_8"
    894 "DFC_MOXEMM_SMU_ALM10_16"
    895 "DFC_MOXEMM_SMU_ALM10_17"
    896 "DFC_MOXEMM_SMU_ALM10_21"
    897 "DFC_MOXEMM_SMU_ALM11_0"
    898 "DFC_MOXEMM_SMU_ALM11_1"
    899 "DFC_MOXEMM_SMU_ALM11_2"
    900 "DFC_MOXEMM_SMU_ALM11_3"
    901 "DFC_MOXEMM_SMU_ALM11_4"
    902 "DFC_MOXEMM_SMU_ALM11_5"
    903 "DFC_MOXEMM_SMU_ALM11_8"
    904 "DFC_MOXEMM_SMU_ALM11_9"
    905 "DFC_MOXEMM_SMU_ALM1_0"
    906 "DFC_MOXEMM_SMU_ALM1_1"
    907 "DFC_MOXEMM_SMU_ALM1_10"
    908 "DFC_MOXEMM_SMU_ALM1_11"
    909 "DFC_MOXEMM_SMU_ALM1_13"
    910 "DFC_MOXEMM_SMU_ALM1_14"
    911 "DFC_MOXEMM_SMU_ALM1_2"
    912 "DFC_MOXEMM_SMU_ALM1_22"
    913 "DFC_MOXEMM_SMU_ALM1_23"
    914 "DFC_MOXEMM_SMU_ALM1_4"
    915 "DFC_MOXEMM_SMU_ALM1_5"
    916 "DFC_MOXEMM_SMU_ALM1_7"
    917 "DFC_MOXEMM_SMU_ALM1_8"
    918 "DFC_MOXEMM_SMU_ALM21_0"
    919 "DFC_MOXEMM_SMU_ALM21_16"
    920 "DFC_MOXEMM_SMU_ALM21_3"
    921 "DFC_MOXEMM_SMU_ALM2_1"
    922 "DFC_MOXEMM_SMU_ALM2_10"
    923 "DFC_MOXEMM_SMU_ALM2_11"
    924 "DFC_MOXEMM_SMU_ALM2_13"
    925 "DFC_MOXEMM_SMU_ALM2_14"
    926 "DFC_MOXEMM_SMU_ALM2_2"
    927 "DFC_MOXEMM_SMU_ALM2_22"
    928 "DFC_MOXEMM_SMU_ALM2_23"
    929 "DFC_MOXEMM_SMU_ALM2_4"
    930 "DFC_MOXEMM_SMU_ALM2_5"
    931 "DFC_MOXEMM_SMU_ALM2_7"
    932 "DFC_MOXEMM_SMU_ALM2_8"
    933 "DFC_MOXEMM_SMU_ALM3_1"
    934 "DFC_MOXEMM_SMU_ALM3_10"
    935 "DFC_MOXEMM_SMU_ALM3_11"
    936 "DFC_MOXEMM_SMU_ALM3_13"
    937 "DFC_MOXEMM_SMU_ALM3_14"
    938 "DFC_MOXEMM_SMU_ALM3_2"
    939 "DFC_MOXEMM_SMU_ALM3_22"
    940 "DFC_MOXEMM_SMU_ALM3_23"
    941 "DFC_MOXEMM_SMU_ALM3_4"
    942 "DFC_MOXEMM_SMU_ALM3_5"
    943 "DFC_MOXEMM_SMU_ALM3_7"
    944 "DFC_MOXEMM_SMU_ALM3_8"
    945 "DFC_MOXEMM_SMU_ALM6_0"
    946 "DFC_MOXEMM_SMU_ALM6_11"
    947 "DFC_MOXEMM_SMU_ALM6_12"
    948 "DFC_MOXEMM_SMU_ALM6_14"
    949 "DFC_MOXEMM_SMU_ALM6_15"
    950 "DFC_MOXEMM_SMU_ALM6_17"
    951 "DFC_MOXEMM_SMU_ALM6_18"
    952 "DFC_MOXEMM_SMU_ALM6_2"
    953 "DFC_MOXEMM_SMU_ALM6_20"
    954 "DFC_MOXEMM_SMU_ALM6_21"
    955 "DFC_MOXEMM_SMU_ALM6_25"
    956 "DFC_MOXEMM_SMU_ALM6_4"
    957 "DFC_MOXEMM_SMU_ALM6_5"
    958 "DFC_MOXEMM_SMU_ALM6_7"
    959 "DFC_MOXEMM_SMU_ALM6_8"
    960 "DFC_MOXEMM_SMU_ALM7_1"
    961 "DFC_MOXEMM_SMU_ALM7_12"
    962 "DFC_MOXEMM_SMU_ALM7_13"
    963 "DFC_MOXEMM_SMU_ALM7_14"
    964 "DFC_MOXEMM_SMU_ALM7_15"
    965 "DFC_MOXEMM_SMU_ALM7_16"
    966 "DFC_MOXEMM_SMU_ALM7_17"
    967 "DFC_MOXEMM_SMU_ALM7_2"
    968 "DFC_MOXEMM_SMU_ALM7_20"
    969 "DFC_MOXEMM_SMU_ALM7_25"
    970 "DFC_MOXEMM_SMU_ALM7_26"
    971 "DFC_MOXEMM_SMU_ALM7_28"
    972 "DFC_MOXEMM_SMU_ALM7_29"
    973 "DFC_MOXEMM_SMU_ALM7_30"
    974 "DFC_MOXEMM_SMU_ALM7_31"
    975 "DFC_MOXEMM_SMU_ALM8_0"
    976 "DFC_MOXEMM_SMU_ALM8_1"
    977 "DFC_MOXEMM_SMU_ALM8_10"
    978 "DFC_MOXEMM_SMU_ALM8_11"
    979 "DFC_MOXEMM_SMU_ALM8_12"
    980 "DFC_MOXEMM_SMU_ALM8_13"
    981 "DFC_MOXEMM_SMU_ALM8_16"
    982 "DFC_MOXEMM_SMU_ALM8_18"
    983 "DFC_MOXEMM_SMU_ALM8_2"
    984 "DFC_MOXEMM_SMU_ALM8_3"
    985 "DFC_MOXEMM_SMU_ALM8_30"
    986 "DFC_MOXEMM_SMU_ALM8_31"
    987 "DFC_MOXEMM_SMU_ALM8_4"
    988 "DFC_MOXEMM_SMU_ALM9_0"
    989 "DFC_MOXEMM_SMU_ALM9_1"
    990 "DFC_MOXEMM_SMU_ALM9_15"
    991 "DFC_MOXEMM_SMU_ALM9_3"
    995 "DFC_MoXEMMHwLTMCUFW"
    996 "DFC_MoXEMMHwLTMonBIST"
    997 "DFC_MoXEMMHwLTRegMonTest"
    998 "DFC_MoXEMMHwLTStbySMUAlvTest"
    999 "DFC_MoXEMMHwLTTempSens"
    1000 "DFC_MoXEMMHwLTUCBCfg"
    1001 "DFC_OCWDAABEActv"
    1002 "DFC_OCWDACom"
    1003 "DFC_OCWDAErrPin"
    871 "DFC_RBA_IOEXTLIB_KEEPALIVE_DRV"
    872 "DFC_RBA_IOEXTLIB_KEEPALIVE_INI"
    875 "DFC_rba_MemDiag_MemReadErr"
    876 "DFC_rba_MemDiag_MemWrErr"
    874 "DFC_rba_MemDiagExtd_MemReadSngErr"
    873 "DFC_rba_MRly_Diag_Stk_Event"
    869 "DFC_rba_MultiStackTrace_Threshold"
    877 "DFC_rba_SyC_IrrSwOffTrigEngRun_Event"
    878 "DFC_rba_T15_Diag_ComInVld_Event"
    879 "DFC_rba_T15_Diag_ComOff_HwOn_Event"
    880 "DFC_rba_T15_Diag_ComOn_HwOff_Event"
    560 "DFC_rbr_can_ClearIpduGroup"
    561 "DFC_rbr_can_ReceiveSignal"
    562 "DFC_rbr_can_SendSignal"
    563 "DFC_rbr_can_SetIpduGroup"
    521 "DFC_rbr_canGetDataboxNoInit"
    522 "DFC_rbr_canGetDataboxParam"
    519 "DFC_rbr_canGetDataNoBuf"
    520 "DFC_rbr_canGetDataParam"
    523 "DFC_rbr_canGetRxBufStatusParam"
    524 "DFC_rbr_canGetStatusParam"
    525 "DFC_rbr_canGetTxBufStatusParam"
    526 "DFC_rbr_canInitParam"
    527 "DFC_rbr_canInitRxDataboxOverlap"
    528 "DFC_rbr_canInitRxDataboxParam"
    529 "DFC_rbr_canInitTxDataboxParam"
    530 "DFC_rbr_canIpduGroupControl"
    531 "DFC_rbr_canIsDataboxFreeNoInit"
    532 "DFC_rbr_canIsDataboxFreeParam"
    533 "DFC_rbr_canIsTxEmptyParam"
    534 "DFC_rbr_canRegBusOffCallbInvState"
    535 "DFC_rbr_canRegBusOffCallbParam"
    536 "DFC_rbr_canRegRxBufInvState"
    537 "DFC_rbr_canRegRxBufOverlap"
    538 "DFC_rbr_canRegRxBufParam"
    539 "DFC_rbr_canRegRxCallbInvState"
    540 "DFC_rbr_canRegRxCallbParam"
    541 "DFC_rbr_canRegRxDataboxInvNumb"
    542 "DFC_rbr_canRegRxDataboxInvState"
    543 "DFC_rbr_canRegRxDataboxOverlap"
    544 "DFC_rbr_canRegRxDataboxParam"
    545 "DFC_rbr_canRegTxBufInvState"
    546 "DFC_rbr_canRegTxBufOverlap"
    547 "DFC_rbr_canRegTxBufParam"
    548 "DFC_rbr_canRegTxDataboxInvNumb"
    549 "DFC_rbr_canRegTxDataboxInvState"
    550 "DFC_rbr_canRegTxDataboxOverlap"
    551 "DFC_rbr_canRegTxDataboxParam"
    552 "DFC_rbr_canResetTxBufParam"
    555 "DFC_rbr_canSendDataboxNoInit"
    556 "DFC_rbr_canSendDataboxParam"
    553 "DFC_rbr_canSendDataBufOvfl"
    554 "DFC_rbr_canSendDataParam"
    557 "DFC_rbr_canSetTxCycleParam"
    558 "DFC_rbr_canStartParam"
    559 "DFC_rbr_canStopParam"
    565 "DFC_rbr_dsmDelDTCJ1939"
    566 "DFC_rbr_dsmDelErrors"
    564 "DFC_rbr_dsmDTCJ1939"
    576 "DFC_rbr_dsmgetDFCStatus"
    567 "DFC_rbr_dsmGetDFES"
    568 "DFC_rbr_dsmGetDTCJ1939"
    569 "DFC_rbr_dsmGetErrors"
    570 "DFC_rbr_dsmGetNumErrors"
    571 "DFC_rbr_dsmInitQueueOverflow"
    572 "DFC_rbr_dsmNumDTCJ1939"
    573 "DFC_rbr_dsmTesterror"
    577 "DFC_rbr_dsmtestErrorDFC"
    574 "DFC_rbr_dsmUpdateDebError"
    575 "DFC_rbr_dsmUpdateError"
    6 "DFC_rbr_inA13OR"
    7 "DFC_rbr_inA13SCB"
    8 "DFC_rbr_inA13SCG"
    9 "DFC_rbr_inA14OR"
    10 "DFC_rbr_inA14SCB"
    11 "DFC_rbr_inA14SCG"
    12 "DFC_rbr_inA21OR"
    13 "DFC_rbr_inA21SCB"
    14 "DFC_rbr_inA21SCG"
    15 "DFC_rbr_inA22OR"
    16 "DFC_rbr_inA22SCB"
    17 "DFC_rbr_inA22SCG"
    18 "DFC_rbr_inA23OR"
    19 "DFC_rbr_inA23SCB"
    20 "DFC_rbr_inA23SCG"
    21 "DFC_rbr_inA24OR"
    22 "DFC_rbr_inA24SCB"
    23 "DFC_rbr_inA24SCG"
    24 "DFC_rbr_inA25OR"
    25 "DFC_rbr_inA25SCB"
    26 "DFC_rbr_inA25SCG"
    27 "DFC_rbr_inA26OR"
    28 "DFC_rbr_inA26SCB"
    29 "DFC_rbr_inA26SCG"
    30 "DFC_rbr_inA27OR"
    31 "DFC_rbr_inA27SCB"
    32 "DFC_rbr_inA27SCG"
    33 "DFC_rbr_inA28OR"
    34 "DFC_rbr_inA28SCB"
    35 "DFC_rbr_inA28SCG"
    36 "DFC_rbr_inA29OR"
    37 "DFC_rbr_inA29SCB"
    38 "DFC_rbr_inA29SCG"
    39 "DFC_rbr_inA36AicSCB"
    40 "DFC_rbr_inA36AicSCG"
    41 "DFC_rbr_inA36OR"
    42 "DFC_rbr_inA36SCB"
    43 "DFC_rbr_inA36SCG"
    44 "DFC_rbr_inA36ShuntSCB"
    45 "DFC_rbr_inA37AicSCB"
    46 "DFC_rbr_inA37AicSCG"
    47 "DFC_rbr_inA37OR"
    48 "DFC_rbr_inA37SCB"
    49 "DFC_rbr_inA37SCG"
    50 "DFC_rbr_inA37ShuntSCB"
    51 "DFC_rbr_inA38AicSCB"
    52 "DFC_rbr_inA38AicSCG"
    53 "DFC_rbr_inA38OR"
    54 "DFC_rbr_inA38SCB"
    55 "DFC_rbr_inA38SCG"
    56 "DFC_rbr_inA38ShuntSCB"
    57 "DFC_rbr_inA39AicSCB"
    58 "DFC_rbr_inA39AicSCG"
    59 "DFC_rbr_inA39OR"
    60 "DFC_rbr_inA39SCB"
    61 "DFC_rbr_inA39SCG"
    62 "DFC_rbr_inA39ShuntSCB"
    63 "DFC_rbr_inA40OR"
    64 "DFC_rbr_inA40SCB"
    65 "DFC_rbr_inA40SCG"
    66 "DFC_rbr_inA41OR"
    67 "DFC_rbr_inA41SCB"
    68 "DFC_rbr_inA41SCG"
    69 "DFC_rbr_inA42OR"
    70 "DFC_rbr_inA42SCB"
    71 "DFC_rbr_inA42SCG"
    72 "DFC_rbr_inA43AicSCB"
    73 "DFC_rbr_inA43AicSCG"
    74 "DFC_rbr_inA43OR"
    75 "DFC_rbr_inA43SCB"
    76 "DFC_rbr_inA43SCG"
    77 "DFC_rbr_inA43ShuntSCB"
    78 "DFC_rbr_inA44OL"
    79 "DFC_rbr_inA44SCB"
    80 "DFC_rbr_inA44SCG"
    81 "DFC_rbr_inA57OR"
    82 "DFC_rbr_inA57SCB"
    83 "DFC_rbr_inA57SCG"
    84 "DFC_rbr_inA59OL"
    85 "DFC_rbr_inA59SCB"
    86 "DFC_rbr_inA59SCG"
    578 "DFC_rbr_inAi"
    579 "DFC_rbr_inAic"
    580 "DFC_rbr_inAicCfg"
    581 "DFC_rbr_inAicGetStatus"
    582 "DFC_rbr_inAid"
    583 "DFC_rbr_inAidCfg"
    584 "DFC_rbr_inAiv"
    585 "DFC_rbr_inAivCfg"
    586 "DFC_rbr_inAivGetStatus"
    587 "DFC_rbr_inDi"
    588 "DFC_rbr_inFi"
    591 "DFC_rbr_inFi_Buffered"
    589 "DFC_rbr_inFiCfg"
    590 "DFC_rbr_inFiGetStatus"
    87 "DFC_rbr_inK10OR"
    88 "DFC_rbr_inK10SCB"
    89 "DFC_rbr_inK10SCG"
    90 "DFC_rbr_inK11OR"
    91 "DFC_rbr_inK11SCB"
    92 "DFC_rbr_inK11SCG"
    93 "DFC_rbr_inK30AicSCB"
    94 "DFC_rbr_inK30AicSCG"
    95 "DFC_rbr_inK30OR"
    96 "DFC_rbr_inK30SCB"
    97 "DFC_rbr_inK30SCG"
    98 "DFC_rbr_inK30ShuntSCB"
    99 "DFC_rbr_inK31OR"
    100 "DFC_rbr_inK31SCB"
    101 "DFC_rbr_inK31SCG"
    102 "DFC_rbr_inK32OR"
    103 "DFC_rbr_inK32SCB"
    104 "DFC_rbr_inK32SCG"
    105 "DFC_rbr_inK33OR"
    106 "DFC_rbr_inK33SCB"
    107 "DFC_rbr_inK33SCG"
    108 "DFC_rbr_inK34OR"
    109 "DFC_rbr_inK34SCB"
    110 "DFC_rbr_inK34SCG"
    111 "DFC_rbr_inK35OR"
    112 "DFC_rbr_inK35SCB"
    113 "DFC_rbr_inK35SCG"
    114 "DFC_rbr_inK36OR"
    115 "DFC_rbr_inK36SCB"
    116 "DFC_rbr_inK36SCG"
    117 "DFC_rbr_inK37AicSCB"
    118 "DFC_rbr_inK37AicSCG"
    119 "DFC_rbr_inK37OR"
    120 "DFC_rbr_inK37SCB"
    121 "DFC_rbr_inK37SCG"
    122 "DFC_rbr_inK37ShuntSCB"
    123 "DFC_rbr_inK38AicSCB"
    124 "DFC_rbr_inK38AicSCG"
    125 "DFC_rbr_inK38OR"
    126 "DFC_rbr_inK38SCB"
    127 "DFC_rbr_inK38SCG"
    128 "DFC_rbr_inK38ShuntSCB"
    129 "DFC_rbr_inK39AicSCB"
    130 "DFC_rbr_inK39AicSCG"
    131 "DFC_rbr_inK39OR"
    132 "DFC_rbr_inK39SCB"
    133 "DFC_rbr_inK39SCG"
    134 "DFC_rbr_inK39ShuntSCB"
    135 "DFC_rbr_inK40AicSCB"
    136 "DFC_rbr_inK40AicSCG"
    137 "DFC_rbr_inK40OR"
    138 "DFC_rbr_inK40SCB"
    139 "DFC_rbr_inK40SCG"
    140 "DFC_rbr_inK40ShuntSCB"
    141 "DFC_rbr_inK41AicSCB"
    142 "DFC_rbr_inK41AicSCG"
    143 "DFC_rbr_inK41OR"
    144 "DFC_rbr_inK41SCB"
    145 "DFC_rbr_inK41SCG"
    146 "DFC_rbr_inK41ShuntSCB"
    147 "DFC_rbr_inK42AicSCB"
    148 "DFC_rbr_inK42AicSCG"
    149 "DFC_rbr_inK42OR"
    150 "DFC_rbr_inK42SCB"
    151 "DFC_rbr_inK42SCG"
    152 "DFC_rbr_inK42ShuntSCB"
    153 "DFC_rbr_inK43OR"
    154 "DFC_rbr_inK43SCB"
    155 "DFC_rbr_inK43SCG"
    156 "DFC_rbr_inK44AicSCB"
    157 "DFC_rbr_inK44AicSCG"
    158 "DFC_rbr_inK44OR"
    159 "DFC_rbr_inK44SCB"
    160 "DFC_rbr_inK44SCG"
    161 "DFC_rbr_inK44ShuntSCB"
    162 "DFC_rbr_inK45AicSCB"
    163 "DFC_rbr_inK45AicSCG"
    164 "DFC_rbr_inK45OR"
    165 "DFC_rbr_inK45SCB"
    166 "DFC_rbr_inK45SCG"
    167 "DFC_rbr_inK45ShuntSCB"
    168 "DFC_rbr_inK52OR"
    169 "DFC_rbr_inK52SCB"
    170 "DFC_rbr_inK52SCG"
    171 "DFC_rbr_inK53OR"
    172 "DFC_rbr_inK53SCB"
    173 "DFC_rbr_inK53SCG"
    174 "DFC_rbr_inK54AicSCB"
    175 "DFC_rbr_inK54AicSCG"
    176 "DFC_rbr_inK54OR"
    177 "DFC_rbr_inK54SCB"
    178 "DFC_rbr_inK54SCG"
    179 "DFC_rbr_inK54ShuntSCB"
    180 "DFC_rbr_inK55AicSCB"
    181 "DFC_rbr_inK55AicSCG"
    182 "DFC_rbr_inK55OR"
    183 "DFC_rbr_inK55SCB"
    184 "DFC_rbr_inK55SCG"
    185 "DFC_rbr_inK55ShuntSCB"
    186 "DFC_rbr_inK56OR"
    187 "DFC_rbr_inK56SCB"
    188 "DFC_rbr_inK56SCG"
    189 "DFC_rbr_inK57OR"
    190 "DFC_rbr_inK57SCB"
    191 "DFC_rbr_inK57SCG"
    192 "DFC_rbr_inK58OR"
    193 "DFC_rbr_inK58SCB"
    194 "DFC_rbr_inK58SCG"
    195 "DFC_rbr_inK59OR"
    196 "DFC_rbr_inK59SCB"
    197 "DFC_rbr_inK59SCG"
    198 "DFC_rbr_inK60OR"
    199 "DFC_rbr_inK60SCB"
    200 "DFC_rbr_inK60SCG"
    201 "DFC_rbr_inK61AicSCB"
    202 "DFC_rbr_inK61AicSCG"
    203 "DFC_rbr_inK61OR"
    204 "DFC_rbr_inK61SCB"
    205 "DFC_rbr_inK61SCG"
    206 "DFC_rbr_inK61ShuntSCB"
    207 "DFC_rbr_inK62OR"
    208 "DFC_rbr_inK62SCB"
    209 "DFC_rbr_inK62SCG"
    210 "DFC_rbr_inK63AicSCB"
    211 "DFC_rbr_inK63AicSCG"
    212 "DFC_rbr_inK63OR"
    213 "DFC_rbr_inK63SCB"
    214 "DFC_rbr_inK63SCG"
    215 "DFC_rbr_inK63ShuntSCB"
    216 "DFC_rbr_inK64AicSCB"
    217 "DFC_rbr_inK64AicSCG"
    218 "DFC_rbr_inK64OR"
    219 "DFC_rbr_inK64SCB"
    220 "DFC_rbr_inK64SCG"
    221 "DFC_rbr_inK64ShuntSCB"
    222 "DFC_rbr_inK65AicSCB"
    223 "DFC_rbr_inK65AicSCG"
    224 "DFC_rbr_inK65OR"
    225 "DFC_rbr_inK65SCB"
    226 "DFC_rbr_inK65SCG"
    227 "DFC_rbr_inK65ShuntSCB"
    228 "DFC_rbr_inK74OR"
    229 "DFC_rbr_inK74SCB"
    230 "DFC_rbr_inK74SCG"
    231 "DFC_rbr_inK75OR"
    232 "DFC_rbr_inK75SCB"
    233 "DFC_rbr_inK75SCG"
    234 "DFC_rbr_inK76OR"
    235 "DFC_rbr_inK76SCB"
    236 "DFC_rbr_inK76SCG"
    237 "DFC_rbr_inK77OR"
    238 "DFC_rbr_inK77SCB"
    239 "DFC_rbr_inK77SCG"
    240 "DFC_rbr_inK78OR"
    241 "DFC_rbr_inK78SCB"
    242 "DFC_rbr_inK78SCG"
    592 "DFC_rbr_inPhase"
    593 "DFC_rbr_inPhaseGetStatus"
    594 "DFC_rbr_inPhaseResetCounter"
    595 "DFC_rbr_inRi"
    596 "DFC_rbr_inRiCfg"
    597 "DFC_rbr_inRiCfgTemp"
    598 "DFC_rbr_inRiGetStatus"
    599 "DFC_rbr_inRiGetTemp"
    600 "DFC_rbr_inSentCopyFDFifo"
    601 "DFC_rbr_inSentDisable"
    602 "DFC_rbr_inSentEnable"
    603 "DFC_rbr_inSentGetErrorStatus"
    604 "DFC_rbr_inSentGetFD"
    605 "DFC_rbr_inSentGetSD"
    606 "DFC_rbr_inSentGetSDDatabox"
    607 "DFC_rbr_inSentGetStatus"
    608 "DFC_rbr_inSentInitSDDatabox"
    609 "DFC_rbr_inSentRegisterCopyFDFifo"
    610 "DFC_rbr_inSentRegisterFDFifo"
    611 "DFC_rbr_inSentRegisterSDDataboxes"
    612 "DFC_rbr_isobusCanRxBufferOverflow"
    613 "DFC_rbr_isobusGetCaAddrParam"
    614 "DFC_rbr_isobusGetDiagnosticParam"
    615 "DFC_rbr_isobusGetRxDataboxStatusParam"
    616 "DFC_rbr_isobusGetStatusParam"
    617 "DFC_rbr_isobusInitCommCaMissing"
    618 "DFC_rbr_isobusInitCommParam"
    619 "DFC_rbr_isobusInitCommState"
    620 "DFC_rbr_isobusInitDiagnosticParam"
    621 "DFC_rbr_isobusInitFailureListParam"
    622 "DFC_rbr_isobusInitRxDataboxParam"
    623 "DFC_rbr_isobusInitTxDataboxParam"
    630 "DFC_rbr_isobusRegisterErrClrCallbackParam"
    631 "DFC_rbr_isobusRegisterInstancesOverlap"
    632 "DFC_rbr_isobusRegisterInstancesParam"
    633 "DFC_rbr_isobusRegisterInstancesState"
    624 "DFC_rbr_isobusRegRxDataboxOverlap"
    625 "DFC_rbr_isobusRegRxDataboxParam"
    626 "DFC_rbr_isobusRegRxDataboxState"
    627 "DFC_rbr_isobusRegTxDataboxOverlap"
    628 "DFC_rbr_isobusRegTxDataboxParam"
    629 "DFC_rbr_isobusRegTxDataboxState"
    634 "DFC_rbr_isobusSendDataboxParam"
    635 "DFC_rbr_isobusSendRequestPGNParam"
    636 "DFC_rbr_isobusSetCaAddrCaUsed"
    637 "DFC_rbr_isobusSetCaAddrComm"
    638 "DFC_rbr_isobusSetCaAddrInvCan"
    639 "DFC_rbr_isobusSetCaAddrParam"
    640 "DFC_rbr_isobusSetCaInfoParam"
    641 "DFC_rbr_isobusSetCaNameParam"
    642 "DFC_rbr_isobusSftyCanTxErr"
    645 "DFC_rbr_lin_getStatus"
    646 "DFC_rbr_lin_gotoSleep"
    643 "DFC_rbr_lin_ReceiveSignal"
    647 "DFC_rbr_lin_scheduleRequest"
    644 "DFC_rbr_lin_SendSignal"
    648 "DFC_rbr_lin_wakeUp"
    649 "DFC_rbr_memFlsCfgShr"
    650 "DFC_rbr_memGetStatus"
    651 "DFC_rbr_memMarkBlock"
    652 "DFC_rbr_memReadApi1Error"
    653 "DFC_rbr_memReadApi2Error"
    654 "DFC_rbr_memReadBlock"
    655 "DFC_rbr_memReadCalibInputError"
    656 "DFC_rbr_memReadCalibOuputError"
    657 "DFC_rbr_memReadSystemError"
    658 "DFC_rbr_memWriteBlock"
    665 "DFC_rbr_mo_adcPDD_fail"
    243 "DFC_rbr_mo_DvUBAT_FWs"
    663 "DFC_rbr_mo_INH"
    664 "DFC_rbr_mo_INHLatch"
    666 "DFC_rbr_mo_memoryProtection_err"
    246 "DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3"
    247 "DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2"
    248 "DFC_rbr_mo_OV_UBAT_MON"
    249 "DFC_rbr_mo_OV_UBRM24_FLEXIN"
    250 "DFC_rbr_mo_OV_UBRM24_LOADS"
    251 "DFC_rbr_mo_OV_UBRM24_MON"
    252 "DFC_rbr_mo_OV_VDD5"
    253 "DFC_rbr_mo_OV_VDD5_IN"
    254 "DFC_rbr_mo_OV_VPR6"
    852 "DFC_rbr_mo_OV_VSS1"
    853 "DFC_rbr_mo_OV_VSS2"
    255 "DFC_rbr_mo_OV_VSS3"
    256 "DFC_rbr_mo_OV_VSS4"
    244 "DFC_rbr_mo_OVErr_VPR6"
    245 "DFC_rbr_mo_OVWarn_VPR6"
    257 "DFC_rbr_mo_Temp1_HTErr"
    258 "DFC_rbr_mo_Temp1_HTWarn"
    259 "DFC_rbr_mo_Temp2_HTErr"
    260 "DFC_rbr_mo_Temp2_HTWarn"
    261 "DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3"
    262 "DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2"
    263 "DFC_rbr_mo_UV_VDD5"
    264 "DFC_rbr_mo_UV_VDD5_IN"
    265 "DFC_rbr_mo_UV_VPR6"
    854 "DFC_rbr_mo_UV_VSS1"
    855 "DFC_rbr_mo_UV_VSS2"
    266 "DFC_rbr_mo_UV_VSS3"
    267 "DFC_rbr_mo_UV_VSS4"
    659 "DFC_rbr_moOV_FirstConstADC"
    660 "DFC_rbr_moOV_SecondConstADC"
    661 "DFC_rbr_moUV_FirstConstADC"
    662 "DFC_rbr_moUV_SecondConstADC"
    268 "DFC_rbr_outA01OL"
    269 "DFC_rbr_outA01OT"
    270 "DFC_rbr_outA01SCB"
    271 "DFC_rbr_outA01SCG"
    667 "DFC_rbr_outA02OC"
    272 "DFC_rbr_outA02OL"
    273 "DFC_rbr_outA02OR"
    274 "DFC_rbr_outA02OT"
    275 "DFC_rbr_outA02SCB"
    276 "DFC_rbr_outA02SCG"
    668 "DFC_rbr_outA02Unintended"
    669 "DFC_rbr_outA03OC"
    277 "DFC_rbr_outA03OL"
    278 "DFC_rbr_outA03OT"
    279 "DFC_rbr_outA03SCB"
    280 "DFC_rbr_outA03SCG"
    670 "DFC_rbr_outA03Unintended"
    671 "DFC_rbr_outA04OC"
    281 "DFC_rbr_outA04OL"
    282 "DFC_rbr_outA04OT"
    283 "DFC_rbr_outA04SCB"
    284 "DFC_rbr_outA04SCG"
    672 "DFC_rbr_outA04Unintended"
    673 "DFC_rbr_outA05OC"
    285 "DFC_rbr_outA05OL"
    286 "DFC_rbr_outA05OR"
    287 "DFC_rbr_outA05OT"
    288 "DFC_rbr_outA05SCB"
    289 "DFC_rbr_outA05SCG"
    674 "DFC_rbr_outA05Unintended"
    290 "DFC_rbr_outA06OL"
    291 "DFC_rbr_outA06OR"
    292 "DFC_rbr_outA06OT"
    293 "DFC_rbr_outA06SCB"
    294 "DFC_rbr_outA06SCG"
    675 "DFC_rbr_outA07OC"
    295 "DFC_rbr_outA07OL"
    296 "DFC_rbr_outA07OT"
    297 "DFC_rbr_outA07SCB"
    298 "DFC_rbr_outA07SCG"
    676 "DFC_rbr_outA07Unintended"
    677 "DFC_rbr_outA08OC"
    299 "DFC_rbr_outA08OL"
    300 "DFC_rbr_outA08OT"
    301 "DFC_rbr_outA08SCB"
    302 "DFC_rbr_outA08SCG"
    678 "DFC_rbr_outA08Unintended"
    679 "DFC_rbr_outA09OC"
    303 "DFC_rbr_outA09OL"
    304 "DFC_rbr_outA09OR"
    305 "DFC_rbr_outA09OT"
    306 "DFC_rbr_outA09SCB"
    307 "DFC_rbr_outA09SCG"
    680 "DFC_rbr_outA09Unintended"
    681 "DFC_rbr_outA10OC"
    308 "DFC_rbr_outA10OL"
    309 "DFC_rbr_outA10OT"
    310 "DFC_rbr_outA10SCB"
    311 "DFC_rbr_outA10SCG"
    682 "DFC_rbr_outA10Unintended"
    312 "DFC_rbr_outA11OL"
    313 "DFC_rbr_outA11OT"
    314 "DFC_rbr_outA11SCB"
    315 "DFC_rbr_outA11SCG"
    316 "DFC_rbr_outA12OR"
    317 "DFC_rbr_outA12SCB"
    318 "DFC_rbr_outA12SCG"
    319 "DFC_rbr_outA16OL"
    320 "DFC_rbr_outA16OT"
    321 "DFC_rbr_outA16SCB"
    322 "DFC_rbr_outA16SCG"
    683 "DFC_rbr_outA17OC"
    323 "DFC_rbr_outA17OL"
    324 "DFC_rbr_outA17OR"
    325 "DFC_rbr_outA17OT"
    326 "DFC_rbr_outA17SCB"
    327 "DFC_rbr_outA17SCG"
    684 "DFC_rbr_outA17Unintended"
    685 "DFC_rbr_outA18OC"
    328 "DFC_rbr_outA18OL"
    329 "DFC_rbr_outA18OT"
    330 "DFC_rbr_outA18SCB"
    331 "DFC_rbr_outA18SCG"
    686 "DFC_rbr_outA18Unintended"
    687 "DFC_rbr_outA19OC"
    332 "DFC_rbr_outA19OL"
    333 "DFC_rbr_outA19OR"
    334 "DFC_rbr_outA19OT"
    335 "DFC_rbr_outA19SCB"
    336 "DFC_rbr_outA19SCG"
    688 "DFC_rbr_outA19Unintended"
    689 "DFC_rbr_outA20OC"
    337 "DFC_rbr_outA20OL"
    338 "DFC_rbr_outA20OR"
    339 "DFC_rbr_outA20OT"
    340 "DFC_rbr_outA20SCB"
    341 "DFC_rbr_outA20SCG"
    690 "DFC_rbr_outA20Unintended"
    691 "DFC_rbr_outA31OC"
    342 "DFC_rbr_outA31OL"
    343 "DFC_rbr_outA31OR"
    344 "DFC_rbr_outA31OT"
    345 "DFC_rbr_outA31SCB"
    346 "DFC_rbr_outA31SCG"
    692 "DFC_rbr_outA31Unintended"
    693 "DFC_rbr_outA32OC"
    347 "DFC_rbr_outA32OL"
    348 "DFC_rbr_outA32OR"
    349 "DFC_rbr_outA32OT"
    350 "DFC_rbr_outA32SCB"
    351 "DFC_rbr_outA32SCG"
    694 "DFC_rbr_outA32Unintended"
    695 "DFC_rbr_outA33OC"
    352 "DFC_rbr_outA33OL"
    353 "DFC_rbr_outA33OR"
    354 "DFC_rbr_outA33OT"
    355 "DFC_rbr_outA33SCB"
    356 "DFC_rbr_outA33SCG"
    696 "DFC_rbr_outA33Unintended"
    697 "DFC_rbr_outA34OC"
    357 "DFC_rbr_outA34OL"
    358 "DFC_rbr_outA34OR"
    359 "DFC_rbr_outA34OT"
    360 "DFC_rbr_outA34SCB"
    361 "DFC_rbr_outA34SCG"
    698 "DFC_rbr_outA34Unintended"
    699 "DFC_rbr_outA35OC"
    362 "DFC_rbr_outA35OL"
    363 "DFC_rbr_outA35OR"
    364 "DFC_rbr_outA35OT"
    365 "DFC_rbr_outA35SCB"
    366 "DFC_rbr_outA35SCG"
    700 "DFC_rbr_outA35Unintended"
    701 "DFC_rbr_outA46OC"
    367 "DFC_rbr_outA46OL"
    368 "DFC_rbr_outA46OR"
    369 "DFC_rbr_outA46OT"
    370 "DFC_rbr_outA46SCB"
    371 "DFC_rbr_outA46SCG"
    702 "DFC_rbr_outA46Unintended"
    703 "DFC_rbr_outA47OC"
    372 "DFC_rbr_outA47OL"
    373 "DFC_rbr_outA47OR"
    374 "DFC_rbr_outA47OT"
    375 "DFC_rbr_outA47SCB"
    376 "DFC_rbr_outA47SCG"
    704 "DFC_rbr_outA47Unintended"
    705 "DFC_rbr_outA48OC"
    377 "DFC_rbr_outA48OL"
    378 "DFC_rbr_outA48OR"
    379 "DFC_rbr_outA48OT"
    380 "DFC_rbr_outA48SCB"
    381 "DFC_rbr_outA48SCG"
    706 "DFC_rbr_outA48Unintended"
    382 "DFC_rbr_outA49OL"
    383 "DFC_rbr_outA49OT"
    384 "DFC_rbr_outA49SCB"
    385 "DFC_rbr_outA49SCG"
    386 "DFC_rbr_outA50OL"
    387 "DFC_rbr_outA50OT"
    388 "DFC_rbr_outA50SCB"
    389 "DFC_rbr_outA50SCG"
    707 "DFC_rbr_outA51OC"
    390 "DFC_rbr_outA51OL"
    391 "DFC_rbr_outA51OR"
    392 "DFC_rbr_outA51OT"
    393 "DFC_rbr_outA51SCB"
    394 "DFC_rbr_outA51SCG"
    708 "DFC_rbr_outA51Unintended"
    709 "DFC_rbr_outA52OC"
    395 "DFC_rbr_outA52OL"
    396 "DFC_rbr_outA52OR"
    397 "DFC_rbr_outA52OT"
    398 "DFC_rbr_outA52SCB"
    399 "DFC_rbr_outA52SCG"
    710 "DFC_rbr_outA52Unintended"
    711 "DFC_rbr_outA53OC"
    400 "DFC_rbr_outA53OL"
    401 "DFC_rbr_outA53OR"
    402 "DFC_rbr_outA53OT"
    403 "DFC_rbr_outA53SCB"
    404 "DFC_rbr_outA53SCG"
    712 "DFC_rbr_outA53Unintended"
    713 "DFC_rbr_outA54OC"
    405 "DFC_rbr_outA54OL"
    406 "DFC_rbr_outA54OR"
    407 "DFC_rbr_outA54OT"
    408 "DFC_rbr_outA54SCB"
    409 "DFC_rbr_outA54SCG"
    714 "DFC_rbr_outA54Unintended"
    410 "DFC_rbr_outA55OL"
    411 "DFC_rbr_outA55OT"
    412 "DFC_rbr_outA55SCB"
    413 "DFC_rbr_outA55SCG"
    414 "DFC_rbr_outA56OL"
    415 "DFC_rbr_outA56OT"
    416 "DFC_rbr_outA56SCB"
    417 "DFC_rbr_outA56SCG"
    418 "DFC_rbr_outA58OL"
    419 "DFC_rbr_outA58OT"
    420 "DFC_rbr_outA58SCB"
    421 "DFC_rbr_outA58SCG"
    715 "DFC_rbr_outAov"
    716 "DFC_rbr_outAovCfg"
    717 "DFC_rbr_outAovCfgPI"
    718 "DFC_rbr_outAovGetStatus"
    719 "DFC_rbr_outAovGetVoltage"
    720 "DFC_rbr_outAovResetError"
    721 "DFC_rbr_outDo"
    722 "DFC_rbr_outDoCfgPwrLs"
    723 "DFC_rbr_outDoDisable"
    724 "DFC_rbr_outDoGetCurrent"
    725 "DFC_rbr_outDoGetStatus"
    726 "DFC_rbr_outDoResetError"
    727 "DFC_rbr_outK07OC"
    422 "DFC_rbr_outK07OL"
    423 "DFC_rbr_outK07OR"
    424 "DFC_rbr_outK07OT"
    425 "DFC_rbr_outK07SCB"
    426 "DFC_rbr_outK07SCG"
    728 "DFC_rbr_outK07Unintended"
    729 "DFC_rbr_outK08OC"
    427 "DFC_rbr_outK08OL"
    428 "DFC_rbr_outK08OR"
    429 "DFC_rbr_outK08OT"
    430 "DFC_rbr_outK08SCB"
    431 "DFC_rbr_outK08SCG"
    730 "DFC_rbr_outK08Unintended"
    731 "DFC_rbr_outK09OC"
    432 "DFC_rbr_outK09OL"
    433 "DFC_rbr_outK09OR"
    434 "DFC_rbr_outK09OT"
    435 "DFC_rbr_outK09SCB"
    436 "DFC_rbr_outK09SCG"
    732 "DFC_rbr_outK09Unintended"
    733 "DFC_rbr_outK12OC"
    437 "DFC_rbr_outK12OL"
    438 "DFC_rbr_outK12OT"
    439 "DFC_rbr_outK12SCB"
    440 "DFC_rbr_outK12SCG"
    734 "DFC_rbr_outK12Unintended"
    735 "DFC_rbr_outK13OC"
    441 "DFC_rbr_outK13OL"
    442 "DFC_rbr_outK13OT"
    443 "DFC_rbr_outK13SCB"
    444 "DFC_rbr_outK13SCG"
    736 "DFC_rbr_outK13Unintended"
    737 "DFC_rbr_outK14OC"
    445 "DFC_rbr_outK14OL"
    446 "DFC_rbr_outK14OR"
    447 "DFC_rbr_outK14OT"
    448 "DFC_rbr_outK14SCB"
    449 "DFC_rbr_outK14SCG"
    738 "DFC_rbr_outK14Unintended"
    739 "DFC_rbr_outK15OC"
    450 "DFC_rbr_outK15OL"
    451 "DFC_rbr_outK15OR"
    452 "DFC_rbr_outK15OT"
    453 "DFC_rbr_outK15SCB"
    454 "DFC_rbr_outK15SCG"
    740 "DFC_rbr_outK15Unintended"
    741 "DFC_rbr_outK16OC"
    455 "DFC_rbr_outK16OL"
    456 "DFC_rbr_outK16OR"
    457 "DFC_rbr_outK16OT"
    458 "DFC_rbr_outK16SCB"
    459 "DFC_rbr_outK16SCG"
    742 "DFC_rbr_outK16Unintended"
    743 "DFC_rbr_outK17OC"
    460 "DFC_rbr_outK17OL"
    461 "DFC_rbr_outK17OR"
    462 "DFC_rbr_outK17OT"
    463 "DFC_rbr_outK17SCB"
    464 "DFC_rbr_outK17SCG"
    744 "DFC_rbr_outK17Unintended"
    465 "DFC_rbr_outK25OR"
    466 "DFC_rbr_outK25SCB"
    467 "DFC_rbr_outK25SCG"
    745 "DFC_rbr_outK29OC"
    468 "DFC_rbr_outK29OL"
    469 "DFC_rbr_outK29OR"
    470 "DFC_rbr_outK29OT"
    471 "DFC_rbr_outK29SCB"
    472 "DFC_rbr_outK29SCG"
    746 "DFC_rbr_outK29Unintended"
    747 "DFC_rbr_outK51OC"
    473 "DFC_rbr_outK51OL"
    474 "DFC_rbr_outK51OT"
    475 "DFC_rbr_outK51SCB"
    476 "DFC_rbr_outK51SCG"
    748 "DFC_rbr_outK51Unintended"
    477 "DFC_rbr_outK62OR"
    478 "DFC_rbr_outK62SCB"
    479 "DFC_rbr_outK62SCG"
    749 "DFC_rbr_outK73OC"
    480 "DFC_rbr_outK73OL"
    481 "DFC_rbr_outK73OR"
    482 "DFC_rbr_outK73OT"
    483 "DFC_rbr_outK73SCB"
    484 "DFC_rbr_outK73SCG"
    750 "DFC_rbr_outK73Unintended"
    485 "DFC_rbr_outK80OL"
    486 "DFC_rbr_outK80OT"
    487 "DFC_rbr_outK80SCB"
    488 "DFC_rbr_outK80SCG"
    489 "DFC_rbr_outK81OL"
    490 "DFC_rbr_outK81OT"
    491 "DFC_rbr_outK81SCB"
    492 "DFC_rbr_outK81SCG"
    493 "DFC_rbr_outK82OL"
    494 "DFC_rbr_outK82OT"
    495 "DFC_rbr_outK82SCB"
    496 "DFC_rbr_outK82SCG"
    497 "DFC_rbr_outK83OL"
    498 "DFC_rbr_outK83OT"
    499 "DFC_rbr_outK83SCB"
    500 "DFC_rbr_outK83SCG"
    501 "DFC_rbr_outK84OL"
    502 "DFC_rbr_outK84OT"
    503 "DFC_rbr_outK84SCB"
    504 "DFC_rbr_outK84SCG"
    505 "DFC_rbr_outK85OL"
    506 "DFC_rbr_outK85OT"
    507 "DFC_rbr_outK85SCB"
    508 "DFC_rbr_outK85SCG"
    509 "DFC_rbr_outK86OL"
    510 "DFC_rbr_outK86OT"
    511 "DFC_rbr_outK86SCB"
    512 "DFC_rbr_outK86SCG"
    513 "DFC_rbr_outK87OL"
    514 "DFC_rbr_outK87OT"
    515 "DFC_rbr_outK87SCB"
    516 "DFC_rbr_outK87SCG"
    751 "DFC_rbr_outPo"
    759 "DFC_rbr_outPoc"
    760 "DFC_rbr_outPocCfg"
    761 "DFC_rbr_outPocCfgDither"
    762 "DFC_rbr_outPocCfgPI"
    752 "DFC_rbr_outPoCfg"
    753 "DFC_rbr_outPoCfgPeriod"
    754 "DFC_rbr_outPoCfgPwrLs"
    763 "DFC_rbr_outPod"
    764 "DFC_rbr_outPodCfg"
    765 "DFC_rbr_outPodCfgPeriod"
    755 "DFC_rbr_outPoDisable"
    756 "DFC_rbr_outPoGetCurrent"
    757 "DFC_rbr_outPoGetStatus"
    758 "DFC_rbr_outPoResetError"
    766 "DFC_rbr_rsmFfiApiCallErr"
    767 "DFC_rbr_safout"
    828 "DFC_rbr_safout_cfgDiag"
    768 "DFC_rbr_safoutCfg"
    769 "DFC_rbr_safoutChnl1"
    770 "DFC_rbr_safoutChnl10"
    771 "DFC_rbr_safoutChnl10Dev"
    772 "DFC_rbr_safoutChnl10OR"
    773 "DFC_rbr_safoutChnl11"
    774 "DFC_rbr_safoutChnl11Dev"
    775 "DFC_rbr_safoutChnl11OR"
    776 "DFC_rbr_safoutChnl12"
    777 "DFC_rbr_safoutChnl12Dev"
    778 "DFC_rbr_safoutChnl12OR"
    779 "DFC_rbr_safoutChnl13"
    780 "DFC_rbr_safoutChnl13Dev"
    781 "DFC_rbr_safoutChnl13OR"
    782 "DFC_rbr_safoutChnl14"
    783 "DFC_rbr_safoutChnl14Dev"
    784 "DFC_rbr_safoutChnl14OR"
    785 "DFC_rbr_safoutChnl15"
    786 "DFC_rbr_safoutChnl15Dev"
    787 "DFC_rbr_safoutChnl15OR"
    788 "DFC_rbr_safoutChnl16"
    789 "DFC_rbr_safoutChnl16Dev"
    790 "DFC_rbr_safoutChnl16OR"
    791 "DFC_rbr_safoutChnl17"
    792 "DFC_rbr_safoutChnl17Dev"
    793 "DFC_rbr_safoutChnl17OR"
    794 "DFC_rbr_safoutChnl18"
    795 "DFC_rbr_safoutChnl18Dev"
    796 "DFC_rbr_safoutChnl18OR"
    797 "DFC_rbr_safoutChnl1Dev"
    798 "DFC_rbr_safoutChnl1OR"
    799 "DFC_rbr_safoutChnl2"
    800 "DFC_rbr_safoutChnl2Dev"
    801 "DFC_rbr_safoutChnl2OR"
    802 "DFC_rbr_safoutChnl3"
    803 "DFC_rbr_safoutChnl3Dev"
    804 "DFC_rbr_safoutChnl3OR"
    805 "DFC_rbr_safoutChnl4"
    806 "DFC_rbr_safoutChnl4Dev"
    807 "DFC_rbr_safoutChnl4OR"
    808 "DFC_rbr_safoutChnl5"
    809 "DFC_rbr_safoutChnl5Dev"
    810 "DFC_rbr_safoutChnl5OR"
    811 "DFC_rbr_safoutChnl6"
    812 "DFC_rbr_safoutChnl6Dev"
    813 "DFC_rbr_safoutChnl6OR"
    814 "DFC_rbr_safoutChnl7"
    815 "DFC_rbr_safoutChnl7Dev"
    816 "DFC_rbr_safoutChnl7OR"
    817 "DFC_rbr_safoutChnl8"
    818 "DFC_rbr_safoutChnl8Dev"
    819 "DFC_rbr_safoutChnl8OR"
    820 "DFC_rbr_safoutChnl9"
    821 "DFC_rbr_safoutChnl9Dev"
    822 "DFC_rbr_safoutChnl9OR"
    823 "DFC_rbr_safoutDevError"
    824 "DFC_rbr_safoutGetStatus"
    825 "DFC_rbr_safoutIgnoreError"
    826 "DFC_rbr_safoutResetError"
    827 "DFC_rbr_safoutUnlock"
    829 "DFC_rbr_secAccessDenied_RC"
    830 "DFC_rbr_secAccessDenied_WDBI"
    831 "DFC_rbr_secEvalRespKey"
    832 "DFC_rbr_secFlashingFailure"
    833 "DFC_rbr_secGetLevel"
    834 "DFC_rbr_secGetRnd"
    835 "DFC_rbr_secGetSeed"
    836 "DFC_rbr_secInvalidPassword"
    837 "DFC_rbr_secIsRequestAllowed"
    838 "DFC_rbr_secResetLevel"
    839 "DFC_rbr_secSaveSecret"
    840 "DFC_rbr_secSetLevel"
    850 "DFC_rbr_sys_coreload"
    851 "DFC_rbr_sys_taskload"
    841 "DFC_rbr_sysAit"
    842 "DFC_rbr_sysAiv"
    843 "DFC_rbr_sysDi"
    844 "DFC_rbr_sysDo"
    845 "DFC_rbr_sysGetVss"
    846 "DFC_rbr_sysInit"
    847 "DFC_rbr_sysOperHrIntegrityErr"
    848 "DFC_rbr_sysOperHrsSaturated"
    849 "DFC_rbr_sysSetVss"
    1004 "DFC_SWReset_0"
    1005 "DFC_SWReset_1"
    1006 "DFC_SWReset_2"

    DEFAULT_VALUE "---"

/end COMPU_VTAB

/begin COMPU_METHOD
    DFES_ACTVENHMTSIMCONDPID9F_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DFES_ACTVENHMTSIMCONDPID9F_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DFES_ACTVENHMTSIMCONDPID9F_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DFES_ACTVSIMRCDNPID03_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DFES_ACTVSIMRCDNPID03_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DFES_ACTVSIMRCDNPID03_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DFES_ADDLMILMOD_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DFES_ADDLMILMOD_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DFES_ADDLMILMOD_SC_Compu
    ""
    TAB_VERB
    2
    0 "NO_ADDLMILMOD"
    1 "ADDLMILMOD_SET1"


/end COMPU_VTAB

/begin COMPU_METHOD
    DFES_ADDWARNLMP_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DFES_ADDWARNLMP_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DFES_ADDWARNLMP_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DFES_BLKENTRY_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DFES_BLKENTRY_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DFES_BLKENTRY_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DFES_COMMILDEB_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DFES_COMMILDEB_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DFES_COMMILDEB_SY_Compu
    ""
    TAB_VERB
    2
    0 "DISABLED"
    1 "ENABLED"


/end COMPU_VTAB

/begin COMPU_METHOD
    DFES_DsplStgy
    ""
    TAB_VERB
    "%6.3"
    "-"
    COMPU_TAB_REF DFES_DsplStgy
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DFES_DsplStgy
    ""
    TAB_VERB
    3
    0 "DiscrmDsplStgy"
    1 "NonDiscrmDsplStgy"
    2 "SelDsplStgy"


/end COMPU_VTAB

/begin COMPU_METHOD
    DFES_DTCCFMD_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DFES_DTCCFMD_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DFES_DTCCFMD_SC_Compu
    ""
    TAB_VERB
    2
    0 "MODE03_VISIBLE_STATE"
    1 "ANY_STATE"


/end COMPU_VTAB

/begin COMPU_METHOD
    DFES_DTCTFSLC_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DFES_DTCTFSLC_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DFES_DTCTFSLC_SC_Compu
    ""
    TAB_VERB
    2
    0 "NotSupported"
    1 "FailedResult"


/end COMPU_VTAB

/begin COMPU_METHOD
    DFES_DTCTNCSLC_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DFES_DTCTNCSLC_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DFES_DTCTNCSLC_SC_Compu
    ""
    TAB_VERB
    2
    0 "NotSupported"
    1 "TestNotComplete"


/end COMPU_VTAB

/begin COMPU_METHOD
    DFES_DTCTyp_Verb
    ""
    TAB_VERB
    "%6.3"
    "-"
    COMPU_TAB_REF DFES_DTCTyp_Verb
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DFES_DTCTyp_Verb
    ""
    TAB_VERB
    4
    0 "DTCO"
    3 "DTCM"
    4 "DTCX"
    255 "None"


/end COMPU_VTAB

/begin COMPU_METHOD
    DFES_DTC_TSTFAIL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DFES_DTC_TSTFAIL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DFES_DTC_TSTFAIL_SY_Compu
    ""
    TAB_VERB
    2
    0 "0"
    1 "1"


/end COMPU_VTAB

/begin COMPU_METHOD
    DFES_Enable
    ""
    TAB_VERB
    "%6.3"
    "-"
    COMPU_TAB_REF DFES_Enable
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DFES_Enable
    ""
    TAB_VERB
    2
    0 "Disabled"
    1 "Enabled"


/end COMPU_VTAB

/begin COMPU_METHOD
    DFES_Entry_Verb
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DFES_Entry_Verb
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DFES_Entry_Verb
    ""
    TAB_VERB
    31
    0 "Empty"
    1 "Erased"
    2 "Erased_PdtcClrd"
    3 "Erased_PdtcClrdMinTrip"
    4 "Erased_PdtcClrdOk"
    5 "FrzFrm"
    6 "FrzFrm_PdtcClrd"
    7 "FrzFrm_PdtcClrdMinTrip"
    8 "FrzFrm_PdtcClrdOk"
    9 "Shadow"
    10 "Shadow_PdtcClrd"
    11 "Shadow_PdtcClrdMinTrip"
    12 "Shadow_PdtcClrdOk"
    13 "Service"
    14 "Service_PdtcClrdOk"
    15 "Service_Shdw"
    16 "Service_ShdwPdtcClrdOk"
    17 "Service_FrzFrm"
    18 "Service_FrzFrmPdtcClrdOk"
    19 "Pending"
    20 "Pending_PdtcClrd"
    21 "Pending_PdtcClrdMinTrip"
    22 "Pending_PdtcClrdOk"
    23 "Confirmed"
    24 "Confirmed_Pdtc"
    25 "ConfirmedHealing"
    26 "ConfirmedHealing_Pdtc"
    27 "ConfirmedPending"
    28 "ConfirmedAging"
    29 "HealPending"
    30 "HealPending_Pdtc"


/end COMPU_VTAB

/begin COMPU_METHOD
    DFES_ENVDATA2HEAL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DFES_ENVDATA2HEAL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DFES_ENVDATA2HEAL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DFES_EnvTabVerb
    ""
    TAB_VERB
    "%2.1"
    "NO"
    COMPU_TAB_REF DFES_EnvTabVerb
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DFES_EnvTabVerb
    ""
    TAB_VERB
    5
    0 "xSet1"
    1 "xSet2"
    2 "xSet3"
    3 "xSet4"
    4 "xSet5"

    DEFAULT_VALUE "---"

/end COMPU_VTAB

/begin COMPU_METHOD
    DFES_EOBDCV_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DFES_EOBDCV_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DFES_EOBDCV_SY_Compu
    ""
    TAB_VERB
    2
    0 "FALSE"
    1 "TRUE"


/end COMPU_VTAB

/begin COMPU_METHOD
    DFES_EOLCLR_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DFES_EOLCLR_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DFES_EOLCLR_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DFES_EXTDFLT_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DFES_EXTDFLT_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DFES_EXTDFLT_SY_Compu
    ""
    TAB_VERB
    2
    0 "DISABLED"
    1 "ENABLED"


/end COMPU_VTAB

/begin COMPU_METHOD
    DFES_IRV_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DFES_IRV_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DFES_IRV_SY_Compu
    ""
    TAB_VERB
    2
    0 "DFES_IRV_DISBL"
    1 "DFES_IRV_ENA"


/end COMPU_VTAB

/begin COMPU_METHOD
    DFES_LampFltAWL
    ""
    TAB_VERB
    "%2.1"
    "NO"
    COMPU_TAB_REF DFES_LampFltAWL
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DFES_LampFltAWL
    ""
    TAB_VERB
    6
    0 "NO_Lamp_Activation"
    1 "Continous_Lamp_Support"
    2 "Blinking_Lamp_Support"
    3 "Blinking_and_Continous_Lamp_Supp"
    4 "Continuous_AWL_Support_LDF"
    8 "Continuous_AWL_Support_LDF_FLC"


/end COMPU_VTAB

/begin COMPU_METHOD
    DFES_LampFltMIL
    ""
    TAB_VERB
    "%2.1"
    "NO"
    COMPU_TAB_REF DFES_LampFltMIL
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DFES_LampFltMIL
    ""
    TAB_VERB
    4
    0 "NO_Lamp_Activation"
    1 "Continous_Lamp_Support"
    2 "Blinking_Lamp_Support"
    3 "Blinking_and_Continous_Lamp_Supp"


/end COMPU_VTAB

/begin COMPU_METHOD
    DFES_LampFltRSL
    ""
    TAB_VERB
    "%2.1"
    "NO"
    COMPU_TAB_REF DFES_LampFltRSL
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DFES_LampFltRSL
    ""
    TAB_VERB
    6
    0 "NO_Lamp_Activation"
    1 "Continous_Lamp_Support"
    2 "Blinking_Lamp_Support"
    3 "Blinking_and_Continous_Lamp_Supp"
    4 "Continuous_RSL_Support_LDF"
    8 "Continuous_RSL_Support_LDF_FLC"


/end COMPU_VTAB

/begin COMPU_METHOD
    DFES_LampFltSVS
    ""
    TAB_VERB
    "%2.1"
    "NO"
    COMPU_TAB_REF DFES_LampFltSVS
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DFES_LampFltSVS
    ""
    TAB_VERB
    6
    0 "NO_Lamp_Activation"
    1 "Continous_Lamp_Support"
    2 "Blinking_Lamp_Support"
    3 "Blinking_and_Continous_Lamp_Supp"
    4 "Continuous_SVS_Support_LDF"
    8 "Continuous_SVS_Support_LDF_FLC"


/end COMPU_VTAB

/begin COMPU_METHOD
    DFES_MILBLINKDEB_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DFES_MILBLINKDEB_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DFES_MILBLINKDEB_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DFES_Mon_Verb
    ""
    TAB_VERB
    "%6.3"
    "-"
    COMPU_TAB_REF DFES_Mon_Verb
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DFES_Mon_Verb
    ""
    TAB_VERB
    22
    0 "-----"
    257 "double entry"
    1025 "LDF_Diff DFCst - ORD"
    513 "Counter exceeds"
    258 "MEM missing"
    1032 "retry entry"
    514 "DEL Counter Serv ex"
    260 "MEM no Entry"
    516 "DEL Counter Pend ex"
    1026 "Deb ok missing"
    520 "DEL Counter OBD ex"
    1028 "Deb def missing"
    2049 "EepQueOvfl"
    2050 "EepIniFailed"
    2051 "EepIniNoSucss"
    4097 "Erased_prioHigh"
    4098 "slow_scan"
    8193 "miss diumpr Fid"
    16385 "invalid DTR limit"
    32770 "event lost due to rollback limit"
    32785 "number active InhUdp negative"
    32786 "non zero InhUpd counter used"


/end COMPU_VTAB

/begin COMPU_METHOD

    DFES_nPID0C
    ""
    RAT_FUNC
    "%6.3"
    "rpm"

    COEFFS 0 4 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    DFES_OFFROADDRVGTIFLCTRIG_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DFES_OFFROADDRVGTIFLCTRIG_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DFES_OFFROADDRVGTIFLCTRIG_SC_Compu
    ""
    TAB_VERB
    2
    0 "TIME_FLC_NOTAVL"
    1 "TIME_FLC_AVL"


/end COMPU_VTAB

/begin COMPU_METHOD
    DFES_OFFROADTITRIGFLTCNTR_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DFES_OFFROADTITRIGFLTCNTR_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DFES_OFFROADTITRIGFLTCNTR_SC_Compu
    ""
    TAB_VERB
    2
    0 "TIME_FLC_OVRMULDCY_NOTAVL"
    1 "TIME_FLC_OVRMULDCY_AVL"


/end COMPU_VTAB

/begin COMPU_METHOD

    DFES_OneToOne
    ""
    RAT_FUNC
    "%6.2"
    "-"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    DFES_PDTC_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DFES_PDTC_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DFES_PDTC_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DFES_PRVTSTRDLT_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DFES_PRVTSTRDLT_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DFES_PRVTSTRDLT_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    DFES_rPID04
    ""
    RAT_FUNC
    "%6.3"
    "%"

    COEFFS 0 2.55 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    DFES_SELFHEAL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DFES_SELFHEAL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DFES_SELFHEAL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DFES_SIMRCONDFLTDEB_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DFES_SIMRCONDFLTDEB_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DFES_SIMRCONDFLTDEB_SC_Compu
    ""
    TAB_VERB
    2
    0 "0"
    1 "1"


/end COMPU_VTAB

/begin COMPU_METHOD
    DFES_stCheck_Verb
    ""
    TAB_VERB
    "%6.3"
    "-"
    COMPU_TAB_REF DFES_stCheck_Verb
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DFES_stCheck_Verb
    ""
    TAB_VERB
    8
    0 "OkNoTst"
    1 "OkTested"
    2 "OkHealed"
    3 "OkRstNoTst"
    4 "DefectNoTst"
    5 "DefectDelay"
    6 "Defect"
    7 "DefectRstNoTst"


/end COMPU_VTAB

/begin COMPU_METHOD
    DFES_stCnt_Verb
    ""
    TAB_VERB
    "%6.3"
    "-"
    COMPU_TAB_REF DFES_stCnt_Verb
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DFES_stCnt_Verb
    ""
    TAB_VERB
    36
    0 "SVS_NONE__MIL_NONE"
    1 "SVS_NONE__MIL_HLC_TRG"
    2 "SVS_NONE__MIL_HLC_ELAP"
    3 "SVS_NONE__MIL_FLC_CNT"
    4 "SVS_NONE__MIL_FLC_TIME"
    5 "SVS_NONE__MIL_HLC_TIME"
    16 "SVS_HLC_TRG__MIL_NONE"
    17 "SVS_HLC_TRG__MIL_HLC_TRG"
    18 "SVS_HLC_TRG__MIL_HLC_ELAP"
    19 "SVS_HLC_TRG__MIL_FLC_CNT"
    20 "SVS_HLC_TRG__MIL_FLC_TIME"
    21 "SVS_HLC_TRG__MIL_HLC_TIME"
    32 "SVS_HLC_ELAP__MIL_NONE"
    33 "SVS_HLC_ELAP__MIL_HLC_TRG"
    34 "SVS_HLC_ELAP__MIL_HLC_ELAP"
    35 "SVS_HLC_ELAP__MIL_FLC_CNT"
    36 "SVS_HLC_ELAP__MIL_FLC_TIME"
    37 "SVS_HLC_ELAP__MIL_HLC_TIME"
    48 "SVS_FLC_CNT__MIL_NONE"
    49 "SVS_FLC_CNT__MIL_HLC_TRG"
    50 "SVS_FLC_CNT__MIL_HLC_ELAP"
    51 "SVS_FLC_CNT__MIL_FLC_CNT"
    52 "SVS_FLC_CNT__MIL_FLC_TIME"
    53 "SVS_FLC_CNT__MIL_HLC_TIME"
    64 "SVS_FLC_TIME__MIL_NONE"
    65 "SVS_FLC_TIME__MIL_HLC_TRG"
    66 "SVS_FLC_TIME__MIL_HLC_ELAP"
    67 "SVS_FLC_TIME__MIL_FLC_CNT"
    68 "SVS_FLC_TIME__MIL_FLC_TIME"
    69 "SVS_FLC_TIME__MIL_HLC_TIME"
    80 "SVS_HLC_TIME__MIL_NONE"
    81 "SVS_HLC_TIME__MIL_HLC_TRG"
    82 "SVS_HLC_TIME__MIL_HLC_ELAP"
    83 "SVS_HLC_TIME__MIL_FLC_CNT"
    84 "SVS_HLC_TIME__MIL_FLC_TIME"
    85 "SVS_HLC_TIME__MIL_HLC_TIME"


/end COMPU_VTAB

/begin COMPU_METHOD
    DFES_stDataImdt_Verb
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DFES_stDataImdt_Verb
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DFES_stDataImdt_Verb
    ""
    TAB_VERB
    22
    0 "ERASED"
    1 "ERASED_ACTSEQ_FRZ_ENV"
    2 "FRZONLY"
    3 "FRZONLY_ACTSEQ_FRZ_ENV"
    4 "SHADOW"
    5 "SHADOW_ACTSEQ_FRZ_ENV"
    12 "OKENTRY"
    13 "OKENTRY_ACTSEQ_LCK"
    14 "OKENTRY_ACTSEQ_LCK_ENV_LCK"
    15 "OKENTRY_ACTSEQ_FRZ_ENV_LCK"
    16 "OKENTRY_ACTSEQ_ENV_LCK"
    17 "ERROR"
    18 "ERROR_ACTSEQ_LCK"
    19 "ERROR_ACTSEQ_LCK_ENV_LCK"
    20 "ERROR_ACTSEQ_FRZ_ENV_LCK"
    21 "ERROR_ACTSEQ_ENV_LCK"
    6 "SHADOWFRZ"
    7 "SHADOWFRZ_ACTSEQ_FRZ_ENV"
    8 "SHADOWOK"
    9 "SHADOWOK_ACTSEQ_FRZ_ENV"
    10 "SHADOWOKFRZ"
    11 "SHADOWOKFRZ_ACTSEQ_FRZ_ENV"


/end COMPU_VTAB

/begin COMPU_METHOD
    DFES_stEntry_Verb
    ""
    TAB_VERB
    "%6.3"
    "-"
    COMPU_TAB_REF DFES_stEntry_Verb
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DFES_stEntry_Verb
    ""
    TAB_VERB
    208
    0 "NoEntry"
    1 "Erased"
    2 "PrivateTemporary"
    3 "SVSOff_FreezeFrameOnly"
    4 "SVSOff_DelayActiveDefect"
    5 "SVSOff_ServiceHistoryNoDefect"
    6 "SVSOff_DelayActiveNoDefect"
    7 "SVSOff_PendingDefect"
    8 "SVSOff_DebouncedDefect"
    9 "SVSOff_HealPendingDefect"
    10 "SVSOff_HistoryPendingDefect"
    11 "SVSOff_HealingNoDefect"
    12 "SVSOff_HistoryNoDefect"
    16 "DelD_NoEntry"
    17 "DelD_Erased"
    18 "DelD_PrivateTemporary"
    19 "SVSOff_DelD_FreezeFrameOnly"
    20 "SVSOff_DelD_DelayActiveDefect"
    21 "SVSOff_DelD_ServiceHistoryNoDefect"
    22 "SVSOff_DelD_DelayActiveNoDefect"
    23 "SVSOff_DelD_PendingDefect"
    24 "SVSOff_DelD_DebouncedDefect"
    25 "SVSOff_DelD_HealPendingDefect"
    26 "SVSOff_DelD_HistoryPendingDefect"
    27 "SVSOff_DelD_HealingNoDefect"
    28 "SVSOff_DelD_HistoryNoDefect"
    32 "P_NoEntry"
    33 "P_Erased"
    34 "P_PrivateTemporary"
    35 "SVSOff_P_FreezeFrameOnly"
    36 "SVSOff_P_DelayActiveDefect"
    37 "SVSOff_P_ServiceHistoryNoDefect"
    38 "SVSOff_P_DelayActiveNoDefect"
    39 "SVSOff_P_PendingDefect"
    40 "SVSOff_P_DebouncedDefect"
    41 "SVSOff_P_HealPendingDefect"
    42 "SVSOff_P_HistoryPendingDefect"
    43 "SVSOff_P_HealingNoDefect"
    44 "SVSOff_P_HistoryNoDefect"
    48 "P_DelD_NoEntry"
    49 "P_DelD_Erased"
    50 "P_DelD_PrivateTemporary"
    51 "SVSOff_P_DelD_FreezeFrameOnly"
    52 "SVSOff_P_DelD_DelayActiveDefect"
    53 "SVSOff_P_DelD_ServiceHistoryNoDefect"
    54 "SVSOff_P_DelD_DelayActiveNoDefect"
    55 "SVSOff_P_DelD_PendingDefect"
    56 "SVSOff_P_DelD_DebouncedDefect"
    57 "SVSOff_P_DelD_HealPendingDefect"
    58 "SVSOff_P_DelD_HistoryPendingDefect"
    59 "SVSOff_P_DelD_HealingNoDefect"
    60 "SVSOff_P_DelD_HistoryNoDefect"
    64 "PS_NoEntry"
    65 "PS_Erased"
    66 "PS_PrivateTemporary"
    67 "SVSOff_PS_FreezeFrameOnly"
    68 "SVSOff_PS_DelayActiveDefect"
    69 "SVSOff_PS_ServiceHistoryNoDefect"
    70 "SVSOff_PS_DelayActiveNoDefect"
    71 "SVSOff_PS_PendingDefect"
    72 "SVSOff_PS_DebouncedDefect"
    73 "SVSOff_PS_HealPendingDefect"
    74 "SVSOff_PS_HistoryPendingDefect"
    75 "SVSOff_PS_HealingNoDefect"
    76 "SVSOff_PS_HistoryNoDefect"
    80 "PS_DelD_NoEntry"
    81 "PS_DelD_Erased"
    82 "PS_DelD_PrivateTemporary"
    83 "SVSOff_PS_DelD_FreezeFrameOnly"
    84 "SVSOff_PS_DelD_DelayActiveDefect"
    85 "SVSOff_PS_DelD_ServiceHistoryNoDefect"
    86 "SVSOff_PS_DelD_DelayActiveNoDefect"
    87 "SVSOff_PS_DelD_PendingDefect"
    88 "SVSOff_PS_DelD_DebouncedDefect"
    89 "SVSOff_PS_DelD_HealPendingDefect"
    90 "SVSOff_PS_DelD_HistoryPendingDefect"
    91 "SVSOff_PS_DelD_HealingNoDefect"
    92 "SVSOff_PS_DelD_HistoryNoDefect"
    96 "PS_P_NoEntry"
    97 "PS_P_Erased"
    98 "PS_P_PrivateTemporary"
    99 "SVSOff_PS_P_FreezeFrameOnly"
    100 "SVSOff_PS_P_DelayActiveDefect"
    101 "SVSOff_PS_P_ServiceHistoryNoDefect"
    102 "SVSOff_PS_P_DelayActiveNoDefect"
    103 "SVSOff_PS_P_PendingDefect"
    104 "SVSOff_PS_P_DebouncedDefect"
    105 "SVSOff_PS_P_HealPendingDefect"
    106 "SVSOff_PS_P_HistoryPendingDefect"
    107 "SVSOff_PS_P_HealingNoDefect"
    108 "SVSOff_PS_P_HistoryNoDefect"
    112 "PS_P_DelD_NoEntry"
    113 "PS_P_DelD_Erased"
    114 "PS_P_DelD_PrivateTemporary"
    115 "SVSOff_PS_P_DelD_FreezeFrameOnly"
    116 "SVSOff_PS_P_DelD_DelayActiveDefect"
    117 "SVSOff_PS_P_DelD_ServiceHistoryNoDefect"
    118 "SVSOff_PS_P_DelD_DelayActiveNoDefect"
    119 "SVSOff_PS_P_DelD_PendingDefect"
    120 "SVSOff_PS_P_DelD_DebouncedDefect"
    121 "SVSOff_PS_P_DelD_HealPendingDefect"
    122 "SVSOff_PS_P_DelD_HistoryPendingDefect"
    123 "SVSOff_PS_P_DelD_HealingNoDefect"
    124 "SVSOff_PS_P_DelD_HistoryNoDefect"
    128 "SVSOn_NoEntry"
    129 "SVSOn_Erased"
    130 "SVSOn_PrivateTemporary"
    131 "SVSOn_FreezeFrameOnly"
    132 "SVSOn_DelayActiveDefect"
    133 "SVSOn_ServiceHistoryNoDefect"
    134 "SVSOn_DelayActiveNoDefect"
    135 "SVSOn_PendingDefect"
    136 "SVSOn_DebouncedDefect"
    137 "SVSOn_HealPendingDefect"
    138 "SVSOn_HistoryPendingDefect"
    139 "SVSOn_HealingNoDefect"
    140 "SVSOn_HistoryNoDefect"
    144 "SVSOn_DelD_NoEntry"
    145 "SVSOn_DelD_Erased"
    146 "SVSOn_DelD_PrivateTemporary"
    147 "SVSOn_DelD_FreezeFrameOnly"
    148 "SVSOn_DelD_DelayActiveDefect"
    149 "SVSOn_DelD_ServiceHistoryNoDefect"
    150 "SVSOn_DelD_DelayActiveNoDefect"
    151 "SVSOn_DelD_PendingDefect"
    152 "SVSOn_DelD_DebouncedDefect"
    153 "SVSOn_DelD_HealPendingDefect"
    154 "SVSOn_DelD_HistoryPendingDefect"
    155 "SVSOn_DelD_HealingNoDefect"
    156 "SVSOn_DelD_HistoryNoDefect"
    160 "SVSOn_P_NoEntry"
    161 "SVSOn_P_Erased"
    162 "SVSOn_P_PrivateTemporary"
    163 "SVSOn_P_FreezeFrameOnly"
    164 "SVSOn_P_DelayActiveDefect"
    165 "SVSOn_P_ServiceHistoryNoDefect"
    166 "SVSOn_P_DelayActiveNoDefect"
    167 "SVSOn_P_PendingDefect"
    168 "SVSOn_P_DebouncedDefect"
    169 "SVSOn_P_HealPendingDefect"
    170 "SVSOn_P_HistoryPendingDefect"
    171 "SVSOn_P_HealingNoDefect"
    172 "SVSOn_P_HistoryNoDefect"
    176 "SVSOn_P_DelD_NoEntry"
    177 "SVSOn_P_DelD_Erased"
    178 "SVSOn_P_DelD_PrivateTemporary"
    179 "SVSOn_P_DelD_FreezeFrameOnly"
    180 "SVSOn_P_DelD_DelayActiveDefect"
    181 "SVSOn_P_DelD_ServiceHistoryNoDefect"
    182 "SVSOn_P_DelD_DelayActiveNoDefect"
    183 "SVSOn_P_DelD_PendingDefect"
    184 "SVSOn_P_DelD_DebouncedDefect"
    185 "SVSOn_P_DelD_HealPendingDefect"
    186 "SVSOn_P_DelD_HistoryPendingDefect"
    187 "SVSOn_P_DelD_HealingNoDefect"
    188 "SVSOn_P_DelD_HistoryNoDefect"
    192 "SVSOn_PS_NoEntry"
    193 "SVSOn_PS_Erased"
    194 "SVSOn_PS_PrivateTemporary"
    195 "SVSOn_PS_FreezeFrameOnly"
    196 "SVSOn_PS_DelayActiveDefect"
    197 "SVSOn_PS_ServiceHistoryNoDefect"
    198 "SVSOn_PS_DelayActiveNoDefect"
    199 "SVSOn_PS_PendingDefect"
    200 "SVSOn_PS_DebouncedDefect"
    201 "SVSOn_PS_HealPendingDefect"
    202 "SVSOn_PS_HistoryPendingDefect"
    203 "SVSOn_PS_HealingNoDefect"
    204 "SVSOn_PS_HistoryNoDefect"
    208 "SVSOn_PS_DelD_NoEntry"
    209 "SVSOn_PS_DelD_Erased"
    210 "SVSOn_PS_DelD_PrivateTemporary"
    211 "SVSOn_PS_DelD_FreezeFrameOnly"
    212 "SVSOn_PS_DelD_DelayActiveDefect"
    213 "SVSOn_PS_DelD_ServiceHistoryNoDefect"
    214 "SVSOn_PS_DelD_DelayActiveNoDefect"
    215 "SVSOn_PS_DelD_PendingDefect"
    216 "SVSOn_PS_DelD_DebouncedDefect"
    217 "SVSOn_PS_DelD_HealPendingDefect"
    218 "SVSOn_PS_DelD_HistoryPendingDefect"
    219 "SVSOn_PS_DelD_HealingNoDefect"
    220 "SVSOn_PS_DelD_HistoryNoDefect"
    224 "SVSOn_PS_P_NoEntry"
    225 "SVSOn_PS_P_Erased"
    226 "SVSOn_PS_P_PrivateTemporary"
    227 "SVSOn_PS_P_FreezeFrameOnly"
    228 "SVSOn_PS_P_DelayActiveDefect"
    229 "SVSOn_PS_P_ServiceHistoryNoDefect"
    230 "SVSOn_PS_P_DelayActiveNoDefect"
    231 "SVSOn_PS_P_PendingDefect"
    232 "SVSOn_PS_P_DebouncedDefect"
    233 "SVSOn_PS_P_HealPendingDefect"
    234 "SVSOn_PS_P_HistoryPendingDefect"
    235 "SVSOn_PS_P_HealingNoDefect"
    236 "SVSOn_PS_P_HistoryNoDefect"
    240 "SVSOn_PS_P_DelD_NoEntry"
    241 "SVSOn_PS_P_DelD_Erased"
    242 "SVSOn_PS_P_DelD_PrivateTemporary"
    243 "SVSOn_PS_P_DelD_FreezeFrameOnly"
    244 "SVSOn_PS_P_DelD_DelayActiveDefect"
    245 "SVSOn_PS_P_DelD_ServiceHistoryNoDefect"
    246 "SVSOn_PS_P_DelD_DelayActiveNoDefect"
    247 "SVSOn_PS_P_DelD_PendingDefect"
    248 "SVSOn_PS_P_DelD_DebouncedDefect"
    249 "SVSOn_PS_P_DelD_HealPendingDefect"
    250 "SVSOn_PS_P_DelD_HistoryPendingDefect"
    251 "SVSOn_PS_P_DelD_HealingNoDefect"
    252 "SVSOn_PS_P_DelD_HistoryNoDefect"


/end COMPU_VTAB

/begin COMPU_METHOD
    DFES_SUPRTFASTBLINK_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DFES_SUPRTFASTBLINK_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DFES_SUPRTFASTBLINK_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    DFES_tiDefCntr_compu
    ""
    RAT_FUNC
    "%6.4"
    "Mnts"

    COEFFS 0 60 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    DFES_Time_1min
    ""
    RAT_FUNC
    "%6.2"
    "min"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    DFES_tPID05
    ""
    RAT_FUNC
    "%6.2"
    "deg C"

    COEFFS 0 1 40 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    DFES_TstVisAndPrio
    ""
    TAB_VERB
    "%6.3"
    "-"
    COMPU_TAB_REF DFES_TstVisAndPrio
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DFES_TstVisAndPrio
    ""
    TAB_VERB
    12
    3 "invisible_for_all_Testers"
    5 "ServiceLow"
    7 "ServiceHigh"
    201 "ClassCLow"
    203 "ClassCHigh"
    205 "ClassB2Low"
    207 "ClassB2High"
    209 "ClassB1Low"
    211 "ClassB1High"
    213 "ClassALow"
    215 "ClassAHigh"
    231 "ServiceHigh_MaxPrio"


/end COMPU_VTAB

/begin COMPU_METHOD
    DFES_VIS_BUF_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DFES_VIS_BUF_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DFES_VIS_BUF_SY_Compu
    ""
    TAB_VERB
    2
    0 "0"
    1 "1"


/end COMPU_VTAB

/begin COMPU_METHOD

    dFlConsum
    ""
    RAT_FUNC
    "%6.4"
    "l/h/s"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    DiaActrElecPsDiag_stSig_COMPU_VERB
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DiaActrElecPsDiag_stSig_COMPU_VERB
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DiaActrElecPsDiag_stSig_COMPU_VERB
    ""
    TAB_VERB
    7
    0 "INVALID"
    1 "NOTEST"
    2 "NOFAULT"
    3 "FAULT"
    4 "PREFAULT"
    5 "HEALFAULT"
    6 "WAITSTATE"

    DEFAULT_VALUE "0"

/end COMPU_VTAB

/begin COMPU_METHOD
    DiaActrElecPsDiag_stTestPls_COMPU_VERB
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DiaActrElecPsDiag_stTestPls_COMPU_VERB
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DiaActrElecPsDiag_stTestPls_COMPU_VERB
    ""
    TAB_VERB
    5
    1 "NO"
    2 "REQUESTED"
    3 "RUNNING"
    4 "FINISHED"
    5 "RE-TRIGGERED"

    DEFAULT_VALUE "1"

/end COMPU_VTAB

/begin COMPU_METHOD
    DiaActrElecPsDiag_stTmngTestPls_COMPU_VERB
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DiaActrElecPsDiag_stTmngTestPls_COMPU_VERB
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DiaActrElecPsDiag_stTmngTestPls_COMPU_VERB
    ""
    TAB_VERB
    4
    1 "EVERY_RASTER"
    2 "TIME_BETWEEN_TEST_1"
    3 "TIME_BETWEEN_TEST_2"
    0 "NO"

    DEFAULT_VALUE "0"

/end COMPU_VTAB

/begin COMPU_METHOD
    DIAACTR_ELECCTRLLINEDIAGCPTENA_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DIAACTR_ELECCTRLLINEDIAGCPTENA_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DIAACTR_ELECCTRLLINEDIAGCPTENA_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DIAACTR_ELECHBRDGDIAGENA_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DIAACTR_ELECHBRDGDIAGENA_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DIAACTR_ELECHBRDGDIAGENA_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DiaActr_ElecHBrdgDiag_DbgSigType_COMPU_VERB
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DiaActr_ElecHBrdgDiag_DbgSigType_COMPU_VERB
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DiaActr_ElecHBrdgDiag_DbgSigType_COMPU_VERB
    ""
    TAB_VERB
    2
    0 "HBR_SIGNAL"
    1 "HLFBR_SIGNAL"

    DEFAULT_VALUE "0"

/end COMPU_VTAB

/begin COMPU_METHOD
    DiaActr_ElecHBrdgDiag_OlEnaSwtOff_COMPU_VERB
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DiaActr_ElecHBrdgDiag_OlEnaSwtOff_COMPU_VERB
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DiaActr_ElecHBrdgDiag_OlEnaSwtOff_COMPU_VERB
    ""
    TAB_VERB
    2
    0 "NO_SWITCHOFF"
    1 "SWITCHOFF"

    DEFAULT_VALUE "0"

/end COMPU_VTAB

/begin COMPU_METHOD
    DIAACTR_ELECPSDIAGCMPNENA_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DIAACTR_ELECPSDIAGCMPNENA_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DIAACTR_ELECPSDIAGCMPNENA_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DIAACTR_ELECPSDIAGERRINFO_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DIAACTR_ELECPSDIAGERRINFO_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DIAACTR_ELECPSDIAGERRINFO_SC_Compu
    ""
    TAB_VERB
    2
    0 "LSTRAWINFO"
    1 "LSTTESTRSLT"


/end COMPU_VTAB

/begin COMPU_METHOD
    DiaActr_ElecPsDiag_DbgSigTyp_COMPU_VERB
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DiaActr_ElecPsDiag_DbgSigTyp_COMPU_VERB
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DiaActr_ElecPsDiag_DbgSigTyp_COMPU_VERB
    ""
    TAB_VERB
    4
    1 "DIGITAL_OUTPUT"
    2 "PWM_OUTPUT"
    3 "PMD_OUTPUT"
    0 "NONE"

    DEFAULT_VALUE "0"

/end COMPU_VTAB

/begin COMPU_METHOD
    DIABAS_ATSLRGIDSUPRT_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DIABAS_ATSLRGIDSUPRT_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DIABAS_ATSLRGIDSUPRT_SC_Compu
    ""
    TAB_VERB
    2
    0 "DISABLE"
    1 "ENABLE"


/end COMPU_VTAB

/begin COMPU_METHOD
    DIABAS_ATSSUSP_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DIABAS_ATSSUSP_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DIABAS_ATSSUSP_SC_Compu
    ""
    TAB_VERB
    2
    1 "Temporary"
    2 "Permanent"


/end COMPU_VTAB

/begin COMPU_METHOD
    DIABAS_ATS_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DIABAS_ATS_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DIABAS_ATS_SC_Compu
    ""
    TAB_VERB
    2
    0 "ATS inactive"
    1 "ATS active"


/end COMPU_VTAB

/begin COMPU_METHOD
    DIABAS_AVS_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DIABAS_AVS_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DIABAS_AVS_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DIABAS_BSWVERS_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DIABAS_BSWVERS_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DIABAS_BSWVERS_SC_Compu
    ""
    TAB_VERB
    20
    10 "BSW_1703"
    11 "BSW_1706"
    12 "BSW_1709"
    13 "BSW_1712"
    20 "BSW_1803"
    21 "BSW_1806"
    22 "BSW_1809"
    23 "BSW_1812"
    30 "BSW_1903"
    31 "BSW_1906"
    32 "BSW_1909"
    33 "BSW_1912"
    40 "BSW_2003"
    41 "BSW_2006"
    42 "BSW_2009"
    43 "BSW_2012"
    50 "BSW_2103"
    51 "BSW_2106"
    52 "BSW_2109"
    53 "BSW_2112"


/end COMPU_VTAB

/begin COMPU_METHOD
    DIABAS_CALIDCVNCTRL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DIABAS_CALIDCVNCTRL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DIABAS_CALIDCVNCTRL_SC_Compu
    ""
    TAB_VERB
    3
    0 "CALIDCVN_LEG"
    1 "CALIDCVN_MIX"
    2 "CALIDCVN_AUTO"


/end COMPU_VTAB

/begin COMPU_METHOD

    DIABAS_CALIDCVNLENSEQ_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    DIABAS_CRCTAB_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DIABAS_CRCTAB_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DIABAS_CRCTAB_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DIABAS_ETCINTSTATE_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DIABAS_ETCINTSTATE_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DIABAS_ETCINTSTATE_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DIABAS_IFFLOATSIG_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DIABAS_IFFLOATSIG_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DIABAS_IFFLOATSIG_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DIABAS_PNDRPRTMOD2_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DIABAS_PNDRPRTMOD2_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DIABAS_PNDRPRTMOD2_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DIABAS_PRMIDAUTVIEW_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DIABAS_PRMIDAUTVIEW_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DIABAS_PRMIDAUTVIEW_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DIABAS_SCRCTL_RCNT_RESET_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DIABAS_SCRCTL_RCNT_RESET_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DIABAS_SCRCTL_RCNT_RESET_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    DIABAS_SRV8_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    DIAGCOM_CALCAN_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DIAGCOM_CALCAN_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DIAGCOM_CALCAN_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DIAGCOM_CANFD_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DIAGCOM_CANFD_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DIAGCOM_CANFD_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    DINH_ct_Compu
    ""
    RAT_FUNC
    "%6.0"
    ""

    COEFFS 0 -1 4096 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    DINH_DEF25DEB0DI_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DINH_DEF25DEB0DI_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DINH_DEF25DEB0DI_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DINH_FIdVerb
    ""
    TAB_VERB
    "%2.1"
    "NO"
    COMPU_TAB_REF DINH_FIdVerb
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DINH_FIdVerb
    ""
    TAB_VERB
    25
    0 "FId_Unused"
    1 "FId_InhibitAlways"
    2 "FId_ComCILAddCond0"
    3 "FId_ComCILAddCond1"
    4 "FId_ComCILAddCond2"
    5 "FId_ComCILAddCond3"
    6 "FId_ComNEngNPL"
    7 "FId_DELibEnvP"
    8 "FId_DELibEnvT"
    9 "FId_DELibPRelPfilDs"
    10 "FId_DIUMPRGenDenom1"
    11 "FId_DIUMPRGenDenom1PDTC"
    12 "FId_DIUMPRGenDenom2"
    13 "FId_DIUMPRGenDenom3"
    14 "FId_DIUMPRIgn"
    15 "FId_DSMWarmUpCycle"
    16 "FId_I15031_srv9_VT_Freeze"
    17 "FId_InhibitNever"
    18 "FId_MILLmpPwrStg"
    19 "FId_SVSLmpPwrStg"
    20 "FId_StopLmpPwrStg"
    21 "FId_WrnLmpPwrStg"
    22 "Function_Id_1"
    23 "Function_Id_2"
    24 "Function_Id_3"

    DEFAULT_VALUE "---"

/end COMPU_VTAB

/begin COMPU_METHOD
    DINH_FID_VIEW_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DINH_FID_VIEW_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DINH_FID_VIEW_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DINH_LimDFCVerb
    ""
    TAB_VERB
    "%6.3"
    "NO"
    COMPU_TAB_REF DINH_LimDFCVerb
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DINH_LimDFCVerb
    ""
    TAB_VERB
    19
    0 "No_Inhibit"
    1 "Def50_Deb100"
    2 "Def100_Deb100"
    3 "Def50_Deb100_Tst"
    4 "Def100_Deb100_Tst"
    5 "Def50_Deb100_or_NTst"
    6 "Def100_Deb100_or_NTst"
    7 "Tested"
    8 "NotTested"
    9 "Def100_Deb0"
    10 "Def50_Deb0"
    11 "Def25_Deb0"
    12 "Def0_Deb0"
    13 "Def50_Deb100_Tst_Trip"
    14 "Def100_Deb100_Tst_Trip"
    15 "Def50_Deb100_MILOn"
    16 "Def50_Deb100_Trip"
    17 "Def100_Deb100_Trip"
    18 "Def50_Deb100_NHealCfm"


/end COMPU_VTAB

/begin COMPU_METHOD
    DINH_LimDSQVerb
    ""
    TAB_VERB
    "%6.3"
    "NO"
    COMPU_TAB_REF DINH_LimDSQVerb
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DINH_LimDSQVerb
    ""
    TAB_VERB
    17
    0 "Qual_AllOk_0"
    1 "Qual_1"
    2 "Qual_Meas_2"
    3 "Qual_PremFrozen_3"
    4 "Qual_Model_4"
    5 "Qual_5"
    6 "Qual_6"
    7 "Qual_7"
    8 "Qual_Frozen_8"
    9 "Qual_9"
    10 "Qual_10"
    11 "Qual_Tester_11"
    12 "Qual_Default_12"
    13 "Qual_13"
    14 "Qual_14"
    15 "Qual_Invalid_15"
    16 "No_Inhibit"


/end COMPU_VTAB

/begin COMPU_METHOD
    DINH_NEWTRIPWITHFCMCLR_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DINH_NEWTRIPWITHFCMCLR_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DINH_NEWTRIPWITHFCMCLR_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    DINH_OneToOne
    ""
    RAT_FUNC
    "%6.2"
    "NO"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    DIPO_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DIPO_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DIPO_SY_Compu
    ""
    TAB_VERB
    2
    0 "0"
    1 "1"


/end COMPU_VTAB

/begin COMPU_METHOD
    DISTAB_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DISTAB_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DISTAB_SY_Compu
    ""
    TAB_VERB
    2
    0 "No Distab"
    1 "Distab"


/end COMPU_VTAB

/begin COMPU_METHOD
    DIUMPR_500MD_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DIUMPR_500MD_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DIUMPR_500MD_SY_Compu
    ""
    TAB_VERB
    2
    0 "0"
    1 "1"


/end COMPU_VTAB

/begin COMPU_METHOD
    DIUMPR_COLDSTARTDEN_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DIUMPR_COLDSTARTDEN_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DIUMPR_COLDSTARTDEN_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DIUMPR_DATAFROMCAN_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DIUMPR_DATAFROMCAN_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DIUMPR_DATAFROMCAN_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DIUMPR_DSTTRVLDSNCERST_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DIUMPR_DSTTRVLDSNCERST_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DIUMPR_DSTTRVLDSNCERST_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DIUMPR_EVAPDENOMTIPRPSYSOFF_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DIUMPR_EVAPDENOMTIPRPSYSOFF_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DIUMPR_EVAPDENOMTIPRPSYSOFF_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DIUMPR_EVAPDEN_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DIUMPR_EVAPDEN_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DIUMPR_EVAPDEN_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DIUMPR_FUENGOPERTI_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DIUMPR_FUENGOPERTI_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DIUMPR_FUENGOPERTI_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DIUMPR_IGNCYCTMR_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DIUMPR_IGNCYCTMR_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DIUMPR_IGNCYCTMR_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DIUMPR_J1939_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DIUMPR_J1939_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DIUMPR_J1939_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DIUMPR_J1979_GroupVerb
    ""
    TAB_VERB
    "%2.1"
    "NO"
    COMPU_TAB_REF DIUMPR_J1979_GroupVerb
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DIUMPR_J1979_GroupVerb
    ""
    TAB_VERB
    9
    0 "NMHCCatalyst"
    1 "NOxCatalyst"
    2 "NOxAdsorber"
    3 "PMFilter"
    4 "EGSensor"
    5 "EGR_VVT"
    6 "BoostPressure"
    7 "Private"
    8 "Unused"

    DEFAULT_VALUE "---"

/end COMPU_VTAB

/begin COMPU_METHOD

    DIUMPR_l10km
    ""
    RAT_FUNC
    "%6.1"
    "km"

    COEFFS 0 1 0 0 0 10 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    DIUMPR_NUMDENOMIDXGRP_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DIUMPR_NUMDENOMIDXGRP_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DIUMPR_NUMDENOMIDXGRP_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    DIUMPR_ti100ms
    ""
    RAT_FUNC
    "%6.3"
    "s"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    DOIP_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DOIP_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DOIP_SC_Compu
    ""
    TAB_VERB
    2
    0 "INACTIVE"
    1 "ACTIVE"


/end COMPU_VTAB

/begin COMPU_METHOD

    DRVPRGSWT_NUMSPRT_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    DRVPRGSWT_NUMWNTR_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    DSCHED_COEOMEXT_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSCHED_COEOMEXT_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSCHED_COEOMEXT_SC_Compu
    ""
    TAB_VERB
    2
    0 "Standard_Only"
    1 "Extended_SubModes"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSCHED_COEOM_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSCHED_COEOM_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSCHED_COEOM_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSCHED_DFCSPEC_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSCHED_DFCSPEC_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSCHED_DFCSPEC_SY_Compu
    ""
    TAB_VERB
    2
    0 "DSCHED_DFCSPECIFIC_DISBL"
    1 "DSCHED_DFCSPECIFIC_ENA"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSCHED_FIdExcCauseVerb
    ""
    TAB_VERB
    "%2.1"
    "NO"
    COMPU_TAB_REF DSCHED_FIdExcCauseVerb
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSCHED_FIdExcCauseVerb
    ""
    TAB_VERB
    5
    0 "No_exclusion"
    1 "FId_InhibitAlways"
    253 "NO_PRIO"
    254 "MODE_IMPOSSIBLE"
    255 "NO_RUN"

    DEFAULT_VALUE "---"

/end COMPU_VTAB

/begin COMPU_METHOD

    DSCHED_FIDMAXPRIOLST_SY_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    DSCHED_FTI_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSCHED_FTI_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSCHED_FTI_SY_Compu
    ""
    TAB_VERB
    2
    0 "DSCHED_FTI_DISBL"
    1 "DSCHED_FTI_ENA"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSCHED_PRIOACTVJMP_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSCHED_PRIOACTVJMP_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSCHED_PRIOACTVJMP_SY_Compu
    ""
    TAB_VERB
    2
    0 "DSCHED_PRIOACTVJMP_DISBL"
    1 "DSCHED_PRIOACTVJMP_ENA"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSCHED_PRIODFCSTLDF_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSCHED_PRIODFCSTLDF_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSCHED_PRIODFCSTLDF_SY_Compu
    ""
    TAB_VERB
    3
    0 "DSCHED_DFCSTLDF_DISBL"
    1 "DSCHED_DFCSTLDF_ENA_UNIF"
    2 "DSCHED_DFCSTLDF_ENA_INDIV"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSCHED_PRIODFCSTTST_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSCHED_PRIODFCSTTST_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSCHED_PRIODFCSTTST_SY_Compu
    ""
    TAB_VERB
    3
    0 "DSCHED_DFCSTTST_DISBL"
    1 "DSCHED_DFCSTTST_ENA_UNIF"
    2 "DSCHED_DFCSTTST_ENA_INDIV"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSCHED_PRIOPHYSURGENCY_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSCHED_PRIOPHYSURGENCY_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSCHED_PRIOPHYSURGENCY_SY_Compu
    ""
    TAB_VERB
    2
    0 "DSCHED_PHYSURGENCY_DISBL"
    1 "DSCHED_PHYSURGENCY_ENA"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSCHED_PRIORMPCALC_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSCHED_PRIORMPCALC_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSCHED_PRIORMPCALC_SY_Compu
    ""
    TAB_VERB
    2
    0 "DSCHED_PRIORMPCALC_DISBL"
    1 "DSCHED_PRIORMPCALC_ENA"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSCHED_RATECALC_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSCHED_RATECALC_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSCHED_RATECALC_SY_Compu
    ""
    TAB_VERB
    2
    0 "DSCHED_RATECALC_DISBL"
    1 "DSCHED_RATECALC_ENA"


/end COMPU_VTAB

/begin COMPU_METHOD

    DSCHED_RmpSlp
    ""
    RAT_FUNC
    "%6.2"
    "counts/s"

    COEFFS 0 1 0 0 0 5 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    DSCHED_StVerb
    ""
    TAB_VERB
    "%6.3"
    "NO"
    COMPU_TAB_REF DSCHED_StVerb
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSCHED_StVerb
    ""
    TAB_VERB
    64
    0 "____________________________"
    2 "_____________________RawPerm"
    4 "_________________Act________"
    6 "_________________Act_RawPerm"
    8 "_____________Lck____________"
    10 "_____________Lck_____RawPerm"
    12 "_____________Lck_Act________"
    14 "_____________Lck_Act_RawPerm"
    32 "_________Val________________"
    34 "_________Val_________RawPerm"
    36 "_________Val_____Act________"
    38 "_________Val_____Act_RawPerm"
    40 "_________Val_Lck____________"
    42 "_________Val_Lck_____RawPerm"
    44 "_________Val_Lck_Act________"
    46 "_________Val_Lck_Act_RawPerm"
    64 "____Perm____________________"
    66 "____Perm_____________RawPerm"
    68 "____Perm_________Act________"
    70 "____Perm_________Act_RawPerm"
    72 "____Perm_____Lck____________"
    74 "____Perm_____Lck_____RawPerm"
    76 "____Perm_____Lck_Act________"
    78 "____Perm_____Lck_Act_RawPerm"
    96 "____Perm_Val________________"
    98 "____Perm_Val_________RawPerm"
    100 "____Perm_Val_____Act________"
    102 "____Perm_Val_____Act_RawPerm"
    104 "____Perm_Val_Lck____________"
    106 "____Perm_Val_Lck_____RawPerm"
    108 "____Perm_Val_Lck_Act________"
    110 "____Perm_Val_Lck_Act_RawPerm"
    128 "Rdy_________________________"
    130 "Rdy__________________RawPerm"
    132 "Rdy______________Act________"
    134 "Rdy______________Act_RawPerm"
    136 "Rdy__________Lck____________"
    138 "Rdy__________Lck_____RawPerm"
    140 "Rdy__________Lck_Act________"
    142 "Rdy__________Lck_Act_RawPerm"
    160 "Rdy______Val________________"
    162 "Rdy______Val_________RawPerm"
    164 "Rdy______Val_____Act________"
    166 "Rdy______Val_____Act_RawPerm"
    168 "Rdy______Val_Lck____________"
    170 "Rdy______Val_Lck_____RawPerm"
    172 "Rdy______Val_Lck_Act________"
    174 "Rdy______Val_Lck_Act_RawPerm"
    192 "Rdy_Perm____________________"
    194 "Rdy_Perm_____________RawPerm"
    196 "Rdy_Perm_________Act________"
    198 "Rdy_Perm_________Act_RawPerm"
    200 "Rdy_Perm_____Lck____________"
    202 "Rdy_Perm_____Lck_____RawPerm"
    204 "Rdy_Perm_____Lck_Act________"
    206 "Rdy_Perm_____Lck_Act_RawPerm"
    224 "Rdy_Perm_Val________________"
    226 "Rdy_Perm_Val_________RawPerm"
    228 "Rdy_Perm_Val_____Act________"
    230 "Rdy_Perm_Val_____Act_RawPerm"
    232 "Rdy_Perm_Val_Lck____________"
    234 "Rdy_Perm_Val_Lck_____RawPerm"
    236 "Rdy_Perm_Val_Lck_Act________"
    238 "Rdy_Perm_Val_Lck_Act_RawPerm"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSCHED_WTT_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSCHED_WTT_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSCHED_WTT_SY_Compu
    ""
    TAB_VERB
    2
    0 "DSCHED_WTT_DISBL"
    1 "DSCHED_WTT_ENA"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSM2AUTOSAR_ASWPF_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSM2AUTOSAR_ASWPF_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSM2AUTOSAR_ASWPF_SC_Compu
    ""
    TAB_VERB
    2
    0 "No_Support"
    1 "Support_BAC"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSM2AUTOSAR_DCMIF_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSM2AUTOSAR_DCMIF_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSM2AUTOSAR_DCMIF_SC_Compu
    ""
    TAB_VERB
    3
    0 "Platform"
    1 "Volvo"
    2 "BMW"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSM2AUTOSAR_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSM2AUTOSAR_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSM2AUTOSAR_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSM2AUTOSAR_SECFCM_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSM2AUTOSAR_SECFCM_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSM2AUTOSAR_SECFCM_SC_Compu
    ""
    TAB_VERB
    2
    0 "No_Support"
    1 "Support_3_Cond"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSM2SG_DFC_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSM2SG_DFC_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSM2SG_DFC_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSM2SG_DSQ_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSM2SG_DSQ_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSM2SG_DSQ_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSM2SG_EXCH_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSM2SG_EXCH_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSM2SG_EXCH_SC_Compu
    ""
    TAB_VERB
    2
    0 "FALSE"
    1 "TRUE"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSM2SG_FID_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSM2SG_FID_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSM2SG_FID_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSMAUX_DTRGVerb
    ""
    TAB_VERB
    "%2.1"
    "NO"
    COMPU_TAB_REF DSMAUX_DTRGVerb
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSMAUX_DTRGVerb
    ""
    TAB_VERB
    11
    3 "DTRG_AlwaysTrue"
    9 "DTRG_Distance100m"
    2 "DTRG_DrivingCycleFLC"
    7 "DTRG_DrivingCycleHLC"
    6 "DTRG_DrivingCycleSpeed"
    8 "DTRG_NoTrigger"
    1 "DTRG_SimilarCondHLC"
    0 "DTRG_Time200ms"
    10 "DTRG_TimeFLCOFFROAD"
    5 "DTRG_WarmUpCycle"
    4 "DTRG_WarmUpCycleTime"

    DEFAULT_VALUE "---"

/end COMPU_VTAB

/begin COMPU_METHOD
    DSMAUX_stDCyVerb
    ""
    TAB_VERB
    "%6.3"
    "NO"
    COMPU_TAB_REF DSMAUX_stDCyVerb
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSMAUX_stDCyVerb
    ""
    TAB_VERB
    4
    0 "DCy_New"
    1 "DCy_Qualified"
    2 "DCy_KeyOnCyc"
    3 "DCy_Completed"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSMAUX_TCSORT_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSMAUX_TCSORT_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSMAUX_TCSORT_SY_Compu
    ""
    TAB_VERB
    2
    0 "TCSORT_disabled"
    1 "TCSORT_enabled"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSMBAS_CENSUPPDIUMPR_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSMBAS_CENSUPPDIUMPR_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSMBAS_CENSUPPDIUMPR_SC_Compu
    ""
    TAB_VERB
    2
    0 "Disabled"
    1 "Enabled"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSMBAS_CENSUPPDTR_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSMBAS_CENSUPPDTR_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSMBAS_CENSUPPDTR_SC_Compu
    ""
    TAB_VERB
    2
    0 "Disabled"
    1 "Enabled"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSMBAS_DTRRPRTDI_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSMBAS_DTRRPRTDI_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSMBAS_DTRRPRTDI_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSMBAS_ENASIMRCDN_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSMBAS_ENASIMRCDN_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSMBAS_ENASIMRCDN_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSMBAS_ENVTLBLKUPD_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSMBAS_ENVTLBLKUPD_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSMBAS_ENVTLBLKUPD_SC_Compu
    ""
    TAB_VERB
    2
    0 "Frequency_Count"
    1 "Fail_Count"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSMBAS_KEYONCYCFLCTRIG_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSMBAS_KEYONCYCFLCTRIG_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSMBAS_KEYONCYCFLCTRIG_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSMBAS_NODFP_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSMBAS_NODFP_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSMBAS_NODFP_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSMBAS_NODIAGCSDL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSMBAS_NODIAGCSDL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSMBAS_NODIAGCSDL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSMBAS_NODTR_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSMBAS_NODTR_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSMBAS_NODTR_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSMBAS_PNDRPRTMOD2_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSMBAS_PNDRPRTMOD2_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSMBAS_PNDRPRTMOD2_SC_Compu
    ""
    TAB_VERB
    2
    0 "CONFIRMED"
    1 "PENDING"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSMBAS_PREFAILDINTDEB_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSMBAS_PREFAILDINTDEB_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSMBAS_PREFAILDINTDEB_SC_Compu
    ""
    TAB_VERB
    2
    0 "Disable"
    1 "Enable"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSMBAS_REINIMETHSELN_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSMBAS_REINIMETHSELN_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSMBAS_REINIMETHSELN_SC_Compu
    ""
    TAB_VERB
    2
    0 "CYCLIC_TASK"
    1 "INIDRV_TASK"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSMBAS_SELPID41BHVR_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSMBAS_SELPID41BHVR_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSMBAS_SELPID41BHVR_SC_Compu
    ""
    TAB_VERB
    2
    0 "PID41_DCYBASED"
    1 "PID41_KEYONBASED"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSMBAS_SRVLAMPSCTRLSTGY_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSMBAS_SRVLAMPSCTRLSTGY_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSMBAS_SRVLAMPSCTRLSTGY_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSMBAS_TESTFAILDSNCELSTCLR_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSMBAS_TESTFAILDSNCELSTCLR_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSMBAS_TESTFAILDSNCELSTCLR_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSMBDEP_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSMBDEP_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSMBDEP_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSMCONF_DEBMULDCY_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSMCONF_DEBMULDCY_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSMCONF_DEBMULDCY_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    DSMDUR_10m_Counter
    ""
    RAT_FUNC
    "%6.4"
    "km"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    DSMDUR_ENACOND_LDF_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSMDUR_ENACOND_LDF_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSMDUR_ENACOND_LDF_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSMDur_EvntSel_Verb
    ""
    TAB_VERB
    "%6.3"
    "NO"
    COMPU_TAB_REF DSMDur_EvntSel_Verb
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSMDur_EvntSel_Verb
    ""
    TAB_VERB
    5
    0 "NoCountEvent"
    1 "DistanceEvents"
    2 "TimeEvents"
    4 "WarmUpCycleEvents"
    8 "DistanceEvents10m"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSMDUR_MIL_GLB_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSMDUR_MIL_GLB_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSMDUR_MIL_GLB_SY_Compu
    ""
    TAB_VERB
    2
    0 "FALSE"
    1 "TRUE"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSMDur_StDispl_Verb
    ""
    TAB_VERB
    "%6.3"
    "NO"
    COMPU_TAB_REF DSMDur_StDispl_Verb
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSMDur_StDispl_Verb
    ""
    TAB_VERB
    3
    0 "NotEnabled"
    1 "CountingEnabled"
    2 "ResetCondition"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSMDUR_SUPPID4D_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSMDUR_SUPPID4D_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSMDUR_SUPPID4D_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSMDUR_SUPPID4E_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSMDUR_SUPPID4E_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSMDUR_SUPPID4E_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSMDUR_SUPRTPID93_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSMDUR_SUPRTPID93_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSMDUR_SUPRTPID93_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSMRDY_ENA_FLSYSFORCELABEL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSMRDY_ENA_FLSYSFORCELABEL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSMRDY_ENA_FLSYSFORCELABEL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSMRDY_ENGSPEC_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSMRDY_ENGSPEC_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSMRDY_ENGSPEC_SY_Compu
    ""
    TAB_VERB
    2
    0 "FALSE"
    1 "TRUE"


/end COMPU_VTAB

/begin COMPU_METHOD

    DSMRDY_INHP41_SY_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    DSMRDY_J1939_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSMRDY_J1939_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSMRDY_J1939_SY_Compu
    ""
    TAB_VERB
    2
    0 "0"
    1 "1"


/end COMPU_VTAB

/begin COMPU_METHOD

    DSMRdy_OneToOne
    ""
    RAT_FUNC
    "%6.2"
    "NO"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    DSMRDY_PID41DIDLY_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSMRDY_PID41DIDLY_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSMRDY_PID41DIDLY_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSMRDY_PTORST_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSMRDY_PTORST_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSMRDY_PTORST_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSMRDY_SUPPID41_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSMRDY_SUPPID41_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSMRDY_SUPPID41_SY_Compu
    ""
    TAB_VERB
    2
    0 "FALSE"
    1 "TRUE"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSMRDY_VERS_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSMRDY_VERS_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSMRDY_VERS_SC_Compu
    ""
    TAB_VERB
    2
    0 "DSMRDY_PRE_2009"
    1 "DSMRDY_2009"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSM_B1CNTRSPDUP_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSM_B1CNTRSPDUP_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSM_B1CNTRSPDUP_SC_Compu
    ""
    TAB_VERB
    2
    0 "Disbl_B1CntrSpdUp"
    1 "Enbl_B1CntrSpdUp"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSM_B1CNTR_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSM_B1CNTR_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSM_B1CNTR_SC_Compu
    ""
    TAB_VERB
    2
    0 "Single"
    1 "Multiple"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSM_CHINA6PDTC_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSM_CHINA6PDTC_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSM_CHINA6PDTC_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    DSM_DISBLGRPSIZE_SY_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    DSM_DOBD_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSM_DOBD_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSM_DOBD_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSM_DSM2SG_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSM_DSM2SG_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSM_DSM2SG_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSM_DTRINTCOMPUVLDN_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSM_DTRINTCOMPUVLDN_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSM_DTRINTCOMPUVLDN_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSM_FAILCNT_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSM_FAILCNT_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSM_FAILCNT_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSM_FAULTSEQ_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSM_FAULTSEQ_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSM_FAULTSEQ_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSM_FLTTYP_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSM_FLTTYP_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSM_FLTTYP_SC_Compu
    ""
    TAB_VERB
    2
    0 "NON_OBD"
    1 "OBD"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSM_HDOBD_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSM_HDOBD_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSM_HDOBD_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSM_INHRLS_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSM_INHRLS_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSM_INHRLS_SY_Compu
    ""
    TAB_VERB
    2
    0 "0"
    1 "1"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSM_MDOBD_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSM_MDOBD_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSM_MDOBD_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSM_PDTCTSTRA_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSM_PDTCTSTRA_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSM_PDTCTSTRA_SY_Compu
    ""
    TAB_VERB
    2
    0 "DISABLED"
    1 "ENABLED"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSM_TESTMODDIAGCODLAMP_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSM_TESTMODDIAGCODLAMP_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSM_TESTMODDIAGCODLAMP_SC_Compu
    ""
    TAB_VERB
    2
    0 "Disabled"
    1 "Enabled"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSM_WUCDET_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSM_WUCDET_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSM_WUCDET_SY_Compu
    ""
    TAB_VERB
    3
    0 "0"
    1 "1"
    2 "2"


/end COMPU_VTAB

/begin COMPU_METHOD
    DSM_WWHOBDCV_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DSM_WWHOBDCV_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DSM_WWHOBDCV_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    DTR_LEGIFC_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF DTR_LEGIFC_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DTR_LEGIFC_SY_Compu
    ""
    TAB_VERB
    2
    0 "DISABLED"
    1 "ENABLED"


/end COMPU_VTAB

/begin COMPU_METHOD
    DTR_Suprt_Compu
    ""
    TAB_VERB
    "%6.3"
    "-"
    COMPU_TAB_REF DTR_Suprt_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    DTR_Suprt_Compu
    ""
    TAB_VERB
    2
    0 "Not supported"
    1 "Supported"


/end COMPU_VTAB

/begin COMPU_METHOD

    DtyCyc
    ""
    RAT_FUNC
    "%6.4"
    "%"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    dt_TempKelv_p_s
    ""
    RAT_FUNC
    "%6.3"
    "K/s"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    ECBVLV_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ECBVLV_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ECBVLV_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "FALSE"
    1 "TRUE"


/end COMPU_VTAB

/begin COMPU_METHOD
    ECUOFF_TMR_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ECUOFF_TMR_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ECUOFF_TMR_SY_Compu
    ""
    TAB_VERB
    7
    0 "0"
    1 "1"
    2 "2"
    3 "3"
    4 "4"
    5 "5"
    6 "6"


/end COMPU_VTAB

/begin COMPU_METHOD
    ECUTYP_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ECUTYP_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ECUTYP_SC_Compu
    ""
    TAB_VERB
    6
    0 "EngEcu"
    1 "PwrEcu"
    2 "VehEcu"
    3 "BattEcu"
    4 "DCU"
    5 "InvrEcu"


/end COMPU_VTAB

/begin COMPU_METHOD
    ECU_GENR_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ECU_GENR_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ECU_GENR_SY_Compu
    ""
    TAB_VERB
    7
    0 "Mx7"
    1 "Mx9"
    2 "Mx17"
    3 "EDC17"
    4 "VMx17"
    5 "DCU17"
    6 "MDGC1"


/end COMPU_VTAB

/begin COMPU_METHOD
    Eep_MainStates_Verb
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF Eep_MainStates_Verb
    
/end COMPU_METHOD

/begin COMPU_VTAB

    Eep_MainStates_Verb
    ""
    TAB_VERB
    15
    0 "EEP_SHUTDWN_RUN"
    1 "EEP_INI_RUN"
    2 "EEP_MIGRATION_RUN"
    3 "EEP_INI_INTERNAL"
    4 "EEP_NORMAL_RUN"
    5 "EEP_BEGPD_REQUEST"
    6 "EEP_BEGPD_RUN"
    7 "EEP_ENDPD_REQUEST"
    8 "EEP_ENDPD_RUN"
    9 "EEP_PREDRV_REQUEST"
    10 "EEP_PREDRV_RUN"
    11 "EEP_FIRSTINIT_INI"
    12 "EEP_RAM_INI"
    13 "EEP_ENVRAM_INI"
    14 "EEP_REINIT_INI"


/end COMPU_VTAB

/begin COMPU_METHOD
    Eep_PostDrvState_Verb
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF Eep_PostDrvState_Verb
    
/end COMPU_METHOD

/begin COMPU_VTAB

    Eep_PostDrvState_Verb
    ""
    TAB_VERB
    5
    0 "EEP_POSTDRV_INI"
    1 "EEP_POSTDRV_SEARCHBLKIDX"
    2 "EEP_POSTDRV_SAVEBLK"
    3 "EEP_POSTDRV_SAVEBLK_PENDING"
    4 "EEP_POSTDRV_WAIT"


/end COMPU_VTAB

/begin COMPU_METHOD
    EGREVAPRUSFLDP_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EGREVAPRUSFLDP_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EGREVAPRUSFLDP_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    EGRVLVINSDT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EGRVLVINSDT_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EGRVLVINSDT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    EGRVLVI_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EGRVLVI_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EGRVLVI_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    EGRVLVLPI_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EGRVLVLPI_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EGRVLVLPI_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    EGTSwt
    ""
    RAT_FUNC
    "%10.9"
    "-"

    COEFFS 0 16384000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    EGTSwt_S16
    ""
    RAT_FUNC
    "%7.6"
    "-"

    COEFFS 0 16384 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    EMGYSHOFFIN2_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EMGYSHOFFIN2_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EMGYSHOFFIN2_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "FALSE"
    1 "TRUE"


/end COMPU_VTAB

/begin COMPU_METHOD
    EMGYSTRTSWT2_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EMGYSTRTSWT2_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EMGYSTRTSWT2_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    ENADATASETID_CALPAR_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ENADATASETID_CALPAR_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ENADATASETID_CALPAR_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    Energy
    ""
    RAT_FUNC
    "%6.2"
    "kJ"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Energy_J_HiRes
    ""
    RAT_FUNC
    "%6.2"
    "J"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Energy_q0p0001
    ""
    RAT_FUNC
    "%7.6"
    "kJ"

    COEFFS 0 10000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Energy_q0p001_COMPU
    ""
    RAT_FUNC
    "%6.5"
    "kJ"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    ENGCMPTMTT_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ENGCMPTMTT_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ENGCMPTMTT_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    ENGDA_CTFLD_NUM_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    ENGMIDT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ENGMIDT_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ENGMIDT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    EngN
    ""
    RAT_FUNC
    "%6.3"
    "rpm"

    COEFFS 0 2 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    EngN_LRes
    ""
    RAT_FUNC
    "%6.1"
    "rpm"

    COEFFS 0 0.025 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    ENGOILT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ENGOILT_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ENGOILT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    ENGRESTRT_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ENGRESTRT_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ENGRESTRT_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    ENGSPD_SWTENA_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ENGSPD_SWTENA_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ENGSPD_SWTENA_SY_Compu
    ""
    TAB_VERB
    2
    0 "FALSE"
    1 "TRUE"


/end COMPU_VTAB

/begin COMPU_METHOD

    EnrgPerMass
    ""
    RAT_FUNC
    "%6.3"
    "MJ/Kg"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    ENVP_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ENVP_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ENVP_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    ENVT_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ENVT_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ENVT_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    EPMBCA_FACSEGTIMEACC_CURX_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    EPMBCR_DTINCSTRT_CURX_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    EPMBCR_FACWEIGHTPAS_DSTX_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    EPMBCR_FACWEIGHT_DSTX_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    EPMCAS_DIAGSRC2_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    EPMCAS_FACPLAUS_DSTX_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    EPMCAS_NUMSEGLEN_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    EPMCAS_NUMSEG_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    EPMCAS_PHINCOR_CURX_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    EPMCAS_PHITEMPADAPCORSIZEDSTX_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    EPMCAS_PHITEMPCOR05_DSTX_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    EPMCAS_PRODCORRNVAL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPMCAS_PRODCORRNVAL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPMCAS_PRODCORRNVAL_SC_Compu
    ""
    TAB_VERB
    2
    0 "OFF"
    1 "ON"


/end COMPU_VTAB

/begin COMPU_METHOD

    EPMCAS_REFADPNTSTRENARESP_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    EPMCAS_REFADPNTSTR_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPMCAS_REFADPNTSTR_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPMCAS_REFADPNTSTR_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    EPMCAS_SELNDIAGFAILRADPN_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPMCAS_SELNDIAGFAILRADPN_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPMCAS_SELNDIAGFAILRADPN_SC_Compu
    ""
    TAB_VERB
    2
    0 "DISAD_DIAG_FAILRADPN"
    1 "ENAD_DIAG_FAILRADPN"


/end COMPU_VTAB

/begin COMPU_METHOD

    EPMCRS_DGIPLSCORRNACTVD_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    EPMCRS_DIAGDETAILEXTD_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPMCRS_DIAGDETAILEXTD_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPMCRS_DIAGDETAILEXTD_SC_Compu
    ""
    TAB_VERB
    3
    0 "DISABLE"
    1 "ENABLE_SIGNAL"
    2 "ENABLE_NOSIGNAL"


/end COMPU_VTAB

/begin COMPU_METHOD

    EPMCRS_DIAGSRC_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    EPMCRS_DIAGSYNCLOST_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPMCRS_DIAGSYNCLOST_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPMCRS_DIAGSYNCLOST_SC_Compu
    ""
    TAB_VERB
    2
    0 "DISABLE_DIAGSYNCLOST"
    1 "ENABLE_DIAGSYNCLOST"


/end COMPU_VTAB

/begin COMPU_METHOD
    EPMCRS_ENASIGLVLDIAG_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPMCRS_ENASIGLVLDIAG_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPMCRS_ENASIGLVLDIAG_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    EPMCRS_MAXAXISPNTSTIPLSCRV_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    EPMCRS_NRENGSPDSEGPLAUS_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    EPMCRS_NUMINCOUT_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    EPMCRS_PLSWIDTHAPPLACTVD_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPMCRS_PLSWIDTHAPPLACTVD_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPMCRS_PLSWIDTHAPPLACTVD_SC_Compu
    ""
    TAB_VERB
    2
    0 "0"
    1 "1"


/end COMPU_VTAB

/begin COMPU_METHOD
    EPMCRS_RESLTOTREV_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPMCRS_RESLTOTREV_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPMCRS_RESLTOTREV_SC_Compu
    ""
    TAB_VERB
    3
    0 "RESL1000"
    1 "RESL100"
    2 "RESL10"


/end COMPU_VTAB

/begin COMPU_METHOD
    EPMCRS_REVSTRTCONT_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPMCRS_REVSTRTCONT_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPMCRS_REVSTRTCONT_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    EPMCRS_TIINCOUTPVBL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPMCRS_TIINCOUTPVBL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPMCRS_TIINCOUTPVBL_SC_Compu
    ""
    TAB_VERB
    3
    1 "TIINC"
    2 "TIINCLRES"
    3 "TIINC_TIINCLRES"


/end COMPU_VTAB

/begin COMPU_METHOD
    EPMCRS_TIINCOUT_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPMCRS_TIINCOUT_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPMCRS_TIINCOUT_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    EPMERR_NRERRINFOARY_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPMERR_NRERRINFOARY_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPMERR_NRERRINFOARY_SC_Compu
    ""
    TAB_VERB
    3
    1 "small block size"
    2 "medium block size"
    3 "big block size"


/end COMPU_VTAB

/begin COMPU_METHOD
    EPMHWE_RTM_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPMHWE_RTM_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPMHWE_RTM_SY_Compu
    ""
    TAB_VERB
    2
    0 "NO_RTM"
    1 "RTM"


/end COMPU_VTAB

/begin COMPU_METHOD
    EPMRRS_IGNLOCKRELSIMDT_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPMRRS_IGNLOCKRELSIMDT_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPMRRS_IGNLOCKRELSIMDT_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    EPMRRS_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPMRRS_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPMRRS_SY_Compu
    ""
    TAB_VERB
    3
    0 "NO_RRS"
    1 "REV"
    2 "REV_STOP"


/end COMPU_VTAB

/begin COMPU_METHOD

    EPMRRS_TITEMP_CURX_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    EPMRVSROTYMETH_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPMRVSROTYMETH_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPMRVSROTYMETH_SY_Compu
    ""
    TAB_VERB
    2
    0 "TOOTHPERD"
    1 "PLSTI"


/end COMPU_VTAB

/begin COMPU_METHOD
    EPMSYN_INJRLS_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPMSYN_INJRLS_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPMSYN_INJRLS_SC_Compu
    ""
    TAB_VERB
    2
    0 "INJRLS_ALWAYS"
    1 "INJRLS_AFTERANGLE"


/end COMPU_VTAB

/begin COMPU_METHOD

    EPMSYN_PHIINCCOR_CURX_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    EPMTDC_PRODCORRNVAL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPMTDC_PRODCORRNVAL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPMTDC_PRODCORRNVAL_SC_Compu
    ""
    TAB_VERB
    2
    0 "OFF"
    1 "ON"


/end COMPU_VTAB

/begin COMPU_METHOD
    EPM_ATS_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPM_ATS_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPM_ATS_SY_Compu
    ""
    TAB_VERB
    2
    0 "NO_ACCESS"
    1 "ACCESS"


/end COMPU_VTAB

/begin COMPU_METHOD
    EPM_CAMSFTSNSRDEACTVN_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPM_CAMSFTSNSRDEACTVN_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPM_CAMSFTSNSRDEACTVN_SC_Compu
    ""
    TAB_VERB
    2
    0 "CANNOT_DEACTIVATE"
    1 "BY_CALIBRATION"


/end COMPU_VTAB

/begin COMPU_METHOD
    EPM_CUSTADP_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPM_CUSTADP_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPM_CUSTADP_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    EPM_DGIDIRCORRN_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPM_DGIDIRCORRN_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPM_DGIDIRCORRN_SC_Compu
    ""
    TAB_VERB
    2
    0 "DIRCORRN_OFF"
    1 "DIRCORRN_ON"


/end COMPU_VTAB

/begin COMPU_METHOD
    EPM_DGIDIRFRCD_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPM_DGIDIRFRCD_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPM_DGIDIRFRCD_SC_Compu
    ""
    TAB_VERB
    2
    0 "DIRFRCD_OFF"
    1 "DIRFRCD_ON"


/end COMPU_VTAB

/begin COMPU_METHOD
    EPM_DGIDYNCHG_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPM_DGIDYNCHG_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPM_DGIDYNCHG_SC_Compu
    ""
    TAB_VERB
    2
    0 "DYNCHG_OFF"
    1 "DYNCHG_ON"


/end COMPU_VTAB

/begin COMPU_METHOD
    EPM_DGIPLSRNG_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPM_DGIPLSRNG_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPM_DGIPLSRNG_SC_Compu
    ""
    TAB_VERB
    2
    0 "PLSRNG_OFF"
    1 "PLSRNG_ON"


/end COMPU_VTAB

/begin COMPU_METHOD
    EPM_HIRESLSEGLENCAL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPM_HIRESLSEGLENCAL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPM_HIRESLSEGLENCAL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    EPM_INDCAMSFTCFG_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPM_INDCAMSFTCFG_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPM_INDCAMSFTCFG_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    EPM_KEEPDGISYNC_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPM_KEEPDGISYNC_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPM_KEEPDGISYNC_SC_Compu
    ""
    TAB_VERB
    2
    0 "STD"
    1 "KEEPDGISYNC"


/end COMPU_VTAB

/begin COMPU_METHOD
    EPM_MEASURE_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPM_MEASURE_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPM_MEASURE_SY_Compu
    ""
    TAB_VERB
    3
    0 "NO_MP"
    1 "TEST_MP"
    2 "RAW_AG_TEST_MP"


/end COMPU_VTAB

/begin COMPU_METHOD

    EPM_NRAGEVE_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    EPM_RVSROTPRED_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPM_RVSROTPRED_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPM_RVSROTPRED_SC_Compu
    ""
    TAB_VERB
    2
    0 "Deactvd"
    1 "Inct_Ti_Thd"


/end COMPU_VTAB

/begin COMPU_METHOD
    EPM_SPD_CALC_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPM_SPD_CALC_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPM_SPD_CALC_SY_Compu
    ""
    TAB_VERB
    4
    0 "SPD_IN_IGNEDGE"
    1 "SPD_IN_WAITGAP"
    2 "SPD_LOW_NEG"
    3 "SPD_LOW_NEG_HIRES"


/end COMPU_VTAB

/begin COMPU_METHOD
    EPM_STRTSELECT_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPM_STRTSELECT_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPM_STRTSELECT_SC_Compu
    ""
    TAB_VERB
    5
    0 "NO_SELECT"
    1 "SEL_StaActV_C"
    2 "SEL_StaActV_CA02"
    3 "SEL_StaActV_CA03"
    4 "SEL_StaActV_CA04"


/end COMPU_VTAB

/begin COMPU_METHOD
    EPM_STRTWOCAMSFTSIGDETN_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPM_STRTWOCAMSFTSIGDETN_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPM_STRTWOCAMSFTSIGDETN_SC_Compu
    ""
    TAB_VERB
    2
    0 "Disabled"
    1 "Enabled"


/end COMPU_VTAB

/begin COMPU_METHOD
    EPM_SYNCSLV_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPM_SYNCSLV_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPM_SYNCSLV_SY_Compu
    ""
    TAB_VERB
    2
    0 "NO_SLV_SYNC"
    1 "SLV_VIA_CAN_SYNC"


/end COMPU_VTAB

/begin COMPU_METHOD
    EPM_TDCDSTCLB_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPM_TDCDSTCLB_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPM_TDCDSTCLB_SC_Compu
    ""
    TAB_VERB
    2
    0 "STANDARD"
    1 "ARRAY"


/end COMPU_VTAB

/begin COMPU_METHOD
    EPM_TIMING_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPM_TIMING_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPM_TIMING_SY_Compu
    ""
    TAB_VERB
    3
    0 "STD"
    1 "HE_ONEBOX"
    2 "RC_MASLV"


/end COMPU_VTAB

/begin COMPU_METHOD
    ERCLNTVLVT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ERCLNTVLVT_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ERCLNTVLVT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    ERRLMP_ATSINTVMOD_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ERRLMP_ATSINTVMOD_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ERRLMP_ATSINTVMOD_SY_Compu
    ""
    TAB_VERB
    2
    0 "FALSE"
    1 "TRUE"


/end COMPU_VTAB

/begin COMPU_METHOD
    ERRLMP_CALCSTMILALWAYS_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ERRLMP_CALCSTMILALWAYS_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ERRLMP_CALCSTMILALWAYS_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    ERRLMP_CUST_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ERRLMP_CUST_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ERRLMP_CUST_SY_Compu
    ""
    TAB_VERB
    4
    0 "ERRLMP_RB"
    1 "ERRLMP_VAG"
    2 "ERRLMP_BMW"
    3 "ERRLMP_DAcom"


/end COMPU_VTAB

/begin COMPU_METHOD
    ERRLMP_PSPRS_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ERRLMP_PSPRS_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ERRLMP_PSPRS_SY_Compu
    ""
    TAB_VERB
    2
    0 "FALSE"
    1 "TRUE"


/end COMPU_VTAB

/begin COMPU_METHOD
    ERRLMP_UNIFY_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ERRLMP_UNIFY_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ERRLMP_UNIFY_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    ERRLMP_VLDTSTDSQ_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ERRLMP_VLDTSTDSQ_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ERRLMP_VLDTSTDSQ_SC_Compu
    ""
    TAB_VERB
    2
    0 "Not_Supported"
    1 "Vrnt_1"


/end COMPU_VTAB

/begin COMPU_METHOD
    ESC_ACTVTSYNCHAINCFG_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ESC_ACTVTSYNCHAINCFG_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ESC_ACTVTSYNCHAINCFG_SC_Compu
    ""
    TAB_VERB
    3
    0 "ACTVTSYNCHAIN_NONE"
    1 "ACTVTSYNCHAIN_EBOS"
    2 "ACTVTSYNCHAIN_ESC"


/end COMPU_VTAB

/begin COMPU_METHOD
    ESC_ACTVTSYNTSKCHAIN_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ESC_ACTVTSYNTSKCHAIN_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ESC_ACTVTSYNTSKCHAIN_SC_Compu
    ""
    TAB_VERB
    2
    0 "DEACTIVE"
    1 "ACTIVE"


/end COMPU_VTAB

/begin COMPU_METHOD
    ESC_ENAPROCGROUP_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ESC_ENAPROCGROUP_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ESC_ENAPROCGROUP_SC_Compu
    ""
    TAB_VERB
    2
    0 "DISABLED"
    1 "ENABLED"


/end COMPU_VTAB

/begin COMPU_METHOD

    ESC_NRAGEVEWCYC_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    ESC_NRTSKAGEVE_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    ESC_SAMPLETICALCN_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ESC_SAMPLETICALCN_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ESC_SAMPLETICALCN_SC_Compu
    ""
    TAB_VERB
    2
    0 "SEG_AG_BASD"
    1 "TSK_TI_STAMP_BASD"


/end COMPU_VTAB

/begin COMPU_METHOD
    ESC_SELNCAMSFTTSKACTVN_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ESC_SELNCAMSFTTSKACTVN_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ESC_SELNCAMSFTTSKACTVN_SC_Compu
    ""
    TAB_VERB
    3
    0 "NO_CAMSFTTSKACTVN"
    1 "PLAT_CAMSFTTSKACTVN"
    2 "HDP_CAMSFTTSKACTVN"


/end COMPU_VTAB

/begin COMPU_METHOD
    ESC_SELNMETHSYNSDL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ESC_SELNMETHSYNSDL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ESC_SELNMETHSYNSDL_SC_Compu
    ""
    TAB_VERB
    2
    0 "OS_TSK_BASD_SDL"
    1 "ESC_CNTNR_BASD_SDL"


/end COMPU_VTAB

/begin COMPU_METHOD
    ESC_SELNNOTSTDTISYNCNTSK_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ESC_SELNNOTSTDTISYNCNTSK_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ESC_SELNNOTSTDTISYNCNTSK_SC_Compu
    ""
    TAB_VERB
    2
    0 "NO_SELN"
    1 "40ms"


/end COMPU_VTAB

/begin COMPU_METHOD
    ESC_SELSAMPLETICFGMETHOD_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ESC_SELSAMPLETICFGMETHOD_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ESC_SELSAMPLETICFGMETHOD_SC_Compu
    ""
    TAB_VERB
    2
    0 "MAN_CFG_METHOD"
    1 "AUT_CFG_METHOD"


/end COMPU_VTAB

/begin COMPU_METHOD
    ESC_SWTSYNRTMEASMT_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ESC_SWTSYNRTMEASMT_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ESC_SWTSYNRTMEASMT_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    ESC_SYNCTASK_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ESC_SYNCTASK_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ESC_SYNCTASK_SC_Compu
    ""
    TAB_VERB
    3
    0 "0"
    1 "1"
    2 "2"


/end COMPU_VTAB

/begin COMPU_METHOD

    Eta2
    ""
    RAT_FUNC
    "%6.4"
    ""

    COEFFS 0 128 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    ETC_Act_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ETC_Act_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ETC_Act_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    ETHIPCORETYPE_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ETHIPCORETYPE_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ETHIPCORETYPE_SC_Compu
    ""
    TAB_VERB
    3
    0 "0"
    1 "1"
    2 "2"


/end COMPU_VTAB

/begin COMPU_METHOD
    ETHSWT_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ETHSWT_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ETHSWT_SC_Compu
    ""
    TAB_VERB
    3
    0 "0"
    1 "1"
    2 "2"


/end COMPU_VTAB

/begin COMPU_METHOD
    ETHTSYN_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ETHTSYN_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ETHTSYN_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    ETH_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ETH_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ETH_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    ETKS_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ETKS_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ETKS_SY_Compu
    ""
    TAB_VERB
    2
    0 "No ETKS"
    1 "ETKS"


/end COMPU_VTAB

/begin COMPU_METHOD

    ETS_LEAN_SY_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    ETS_NSC_SY_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    ETS_PFLT1_SY_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    ETS_PFLT2_SY_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    ETS_PHC_SY_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    ETS_SOX_SY_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    EVAPRDSMIXFLDP_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EVAPRDSMIXFLDP_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EVAPRDSMIXFLDP_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    EVAPRDSMIXFLDT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EVAPRDSMIXFLDT_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EVAPRDSMIXFLDT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    EVTYP_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EVTYP_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EVTYP_SY_Compu
    ""
    TAB_VERB
    2
    0 "NOEV"
    1 "EV"


/end COMPU_VTAB

/begin COMPU_METHOD
    ExeCon_State_01
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ExeCon_State_01
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ExeCon_State_01
    ""
    TAB_VERB
    4
    0 "SYC_BOOT"
    1 "SYC_PROC_INIT"
    2 "SYC_PROC_EXEC"
    3 "SYC_SHUTDOWN"


/end COMPU_VTAB

/begin COMPU_METHOD
    ExeCon_State_02
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ExeCon_State_02
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ExeCon_State_02
    ""
    TAB_VERB
    7
    0 "SYC_INI"
    1 "SYC_INISYN"
    2 "SYC_INIEND"
    3 "SYC_PREDRIVE"
    4 "SYC_DRIVE"
    5 "SYC_POSTDRIVE"
    6 "SYC_POST_OS_EXIT"


/end COMPU_VTAB

/begin COMPU_METHOD
    EXHEVAPRDSFLDT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EXHEVAPRDSFLDT_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EXHEVAPRDSFLDT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    EXHEVAPRDSGAST_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EXHEVAPRDSGAST_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EXHEVAPRDSGAST_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    EXHEVAPRUSFLDP_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EXHEVAPRUSFLDP_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EXHEVAPRUSFLDP_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    EXHEVAPRUSFLDT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EXHEVAPRUSFLDT_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EXHEVAPRUSFLDT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    EXHEVAPRUSGAST_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EXHEVAPRUSGAST_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EXHEVAPRUSGAST_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    EXHFLPLPI_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EXHFLPLPI_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EXHFLPLPI_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    EXHPPFLT_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EXHPPFLT_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EXHPPFLT_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    Fact
    ""
    RAT_FUNC
    "%6.5"
    "-"

    COEFFS 0 8192 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Fact1
    ""
    RAT_FUNC
    "%6.4"
    "-"

    COEFFS 0 128 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    FactLow
    ""
    RAT_FUNC
    "%6.5"
    "-"

    COEFFS 0 1024 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Fact_NSC
    ""
    RAT_FUNC
    "%6.5"
    "-"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Fact_NSCEff
    ""
    RAT_FUNC
    "%7.6"
    "-"

    COEFFS 0 10000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Fact_q0p001
    ""
    RAT_FUNC
    "%6.5"
    "-"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Fact_q0p1_COMPU
    ""
    RAT_FUNC
    "%6.3"
    "-"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Fact_VolNSC
    ""
    RAT_FUNC
    "%9.8"
    "-"

    COEFFS 0 1000000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    FDE_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF FDE_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    FDE_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    FlConsum_l_h
    ""
    RAT_FUNC
    "%6.4"
    "l/h"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    FlConsum_ul
    ""
    RAT_FUNC
    "%6.2"
    "ul"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    FLEXPSCTRLRNR_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF FLEXPSCTRLRNR_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    FLEXPSCTRLRNR_SC_Compu
    ""
    TAB_VERB
    2
    0 "0"
    1 "1"


/end COMPU_VTAB

/begin COMPU_METHOD
    FLFLTDSP_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF FLFLTDSP_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    FLFLTDSP_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    FLOATIFRESLSELN_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF FLOATIFRESLSELN_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    FLOATIFRESLSELN_SC_Compu
    ""
    TAB_VERB
    2
    0 "Integer_calculation"
    1 "Floating_point_calculation"


/end COMPU_VTAB

/begin COMPU_METHOD
    FLXR_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF FLXR_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    FLXR_SY_Compu
    ""
    TAB_VERB
    2
    0 "FALSE"
    1 "TRUE"


/end COMPU_VTAB

/begin COMPU_METHOD

    Fl_Vol_q0p05
    ""
    RAT_FUNC
    "%6.4"
    "l"

    COEFFS 0 20 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    FRARTP_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF FRARTP_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    FRARTP_SC_Compu
    ""
    TAB_VERB
    2
    0 "NO_FRARTP"
    1 "FRARTP_USED"


/end COMPU_VTAB

/begin COMPU_METHOD
    FRNM_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF FRNM_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    FRNM_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    FRTP_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF FRTP_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    FRTP_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    FRTSYN_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF FRTSYN_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    FRTSYN_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    FSPDSFLDP_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF FSPDSFLDP_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    FSPDSFLDP_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    FUELP_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF FUELP_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    FUELP_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    FUELT2_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF FUELT2_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    FUELT2_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    FUELT_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF FUELT_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    FUELT_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    GBXOILP_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF GBXOILP_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    GBXOILP_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    GBXOILT_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF GBXOILT_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    GBXOILT_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    GDI_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF GDI_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    GDI_SY_Compu
    ""
    TAB_VERB
    2
    0 "GDI_NO"
    1 "GDI"


/end COMPU_VTAB

/begin COMPU_METHOD
    GLBDA_ACTRACTVN_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF GLBDA_ACTRACTVN_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    GLBDA_ACTRACTVN_SC_Compu
    ""
    TAB_VERB
    2
    0 "Disable_Actuator_Activation"
    1 "Enable_Actuator_Activation"


/end COMPU_VTAB

/begin COMPU_METHOD

    GptaClc6_ti_COMPU
    ""
    RAT_FUNC
    "%6.3"
    "us"

    COEFFS 0 2.5 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    GSSYS_TYPEEXHFLW_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF GSSYS_TYPEEXHFLW_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    GSSYS_TYPEEXHFLW_SY_Compu
    ""
    TAB_VERB
    2
    1 "HESRV_SNGLFLW"
    2 "HESRV_TWFLW"


/end COMPU_VTAB

/begin COMPU_METHOD
    GSSYS_TYPPCR_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF GSSYS_TYPPCR_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    GSSYS_TYPPCR_SY_Compu
    ""
    TAB_VERB
    2
    1 "HESRV_SNGLFLW"
    2 "HESRV_TWFLW"


/end COMPU_VTAB

/begin COMPU_METHOD

    HCMassPerTime_q0p0000004
    ""
    RAT_FUNC
    "%9.8"
    "kg/s"

    COEFFS 0 2500000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    HEATRCORET_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF HEATRCORET_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    HEATRCORET_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    HEM_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF HEM_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    HEM_SY_Compu
    ""
    TAB_VERB
    3
    0 "NO_HEM"
    1 "HEM_CYL"
    2 "HEM_BNK"


/end COMPU_VTAB

/begin COMPU_METHOD
    HESRV_HETYP_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF HESRV_HETYP_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    HESRV_HETYP_SY_Compu
    ""
    TAB_VERB
    4
    1 "HESRV_MASTERSLAVE"
    2 "HESRV_VCU"
    3 "HESRV_HCU"
    255 "HESRV_ONEBOX"


/end COMPU_VTAB

/begin COMPU_METHOD
    HEVCHGR_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF HEVCHGR_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    HEVCHGR_SY_Compu
    ""
    TAB_VERB
    5
    0 "NOCHGR"
    1 "CHGR_UHV"
    2 "CHGR_UHVLV"
    3 "CHGR_BHV"
    4 "CHGR_BHVLV"


/end COMPU_VTAB

/begin COMPU_METHOD
    HEVPLINAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF HEVPLINAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    HEVPLINAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    HEVTYP_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF HEVTYP_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    HEVTYP_SY_Compu
    ""
    TAB_VERB
    8
    0 "0"
    1 "HEVTYP_SER"
    2 "HEVTYP_SERPARL"
    3 "HEVTYP_PWRSPLT"
    4 "HEVTYP_PARL"
    5 "HEVTYP_EAD"
    6 "HEVTYP_EDCT"
    7 "HEVTYP_PARLSER"


/end COMPU_VTAB

/begin COMPU_METHOD
    HPDIFF_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF HPDIFF_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    HPDIFF_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    HPIN_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF HPIN_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    HPIN_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    HPOUTPRR_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF HPOUTPRR_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    HPOUTPRR_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    HTANKP_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF HTANKP_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    HTANKP_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    HTANKT_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF HTANKT_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    HTANKT_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    HTIN_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF HTIN_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    HTIN_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    HTOUT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF HTOUT_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    HTOUT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    HVACHEATPMPP_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF HVACHEATPMPP_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    HVACHEATPMPP_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    HVACHEATPMPT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF HVACHEATPMPT_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    HVACHEATPMPT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    HVACSPT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF HVACSPT_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    HVACSPT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    HWDPD_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF HWDPD_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    HWDPD_SC_Compu
    ""
    TAB_VERB
    3
    0 "HWDPD_NEUT"
    1 "HWDPD_SWNOTSEL"
    2 "HWDPD_SWSEL"


/end COMPU_VTAB

/begin COMPU_METHOD
    HYDSTORGHIPT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF HYDSTORGHIPT_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    HYDSTORGHIPT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    HYDSTORGLOPT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF HYDSTORGLOPT_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    HYDSTORGLOPT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    HYDSYSHIPTSEC_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF HYDSYSHIPTSEC_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    HYDSYSHIPTSEC_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    HYDSYSLOPT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF HYDSYSLOPT_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    HYDSYSLOPT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    I15031SRV9NOXBIN_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF I15031SRV9NOXBIN_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    I15031SRV9NOXBIN_SC_Compu
    ""
    TAB_VERB
    2
    0 "FALSE"
    1 "TRUE"


/end COMPU_VTAB

/begin COMPU_METHOD
    I15031SRV9VT_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF I15031SRV9VT_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    I15031SRV9VT_SC_Compu
    ""
    TAB_VERB
    2
    0 "VT_disabled"
    1 "VT_enabled"


/end COMPU_VTAB

/begin COMPU_METHOD
    I15031SRV9VT_STORGRSTBHVR_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF I15031SRV9VT_STORGRSTBHVR_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    I15031SRV9VT_STORGRSTBHVR_SC_Compu
    ""
    TAB_VERB
    3
    1 "ENVRAM_IUMPRReset"
    2 "EEPROM_NoReset"
    3 "EEPROM_CalibrationReset"


/end COMPU_VTAB

/begin COMPU_METHOD
    I15031_CVNALG_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF I15031_CVNALG_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    I15031_CVNALG_SC_Compu
    ""
    TAB_VERB
    4
    1 "CVN_ALG_CRC32_DIABAS"
    2 "CVN_ALG_CRC32_SECULIBS"
    3 "CVN_ALG_SHA256_BCL"
    4 "CVN_ALG_SHA256_HSM"


/end COMPU_VTAB

/begin COMPU_METHOD
    I15031_EXTCVNSTORGBHVR_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF I15031_EXTCVNSTORGBHVR_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    I15031_EXTCVNSTORGBHVR_SC_Compu
    ""
    TAB_VERB
    2
    1 "PSTDRV"
    2 "RAS1s"


/end COMPU_VTAB

/begin COMPU_METHOD
    I15031_OBD_CNTL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF I15031_OBD_CNTL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    I15031_OBD_CNTL_SC_Compu
    ""
    TAB_VERB
    4
    0 "I15031_ACTIVE"
    1 "I15031_SRV_ADJUST"
    2 "I15031_INACTIVE"
    3 "I15031_NOT_EXISTING"


/end COMPU_VTAB

/begin COMPU_METHOD
    I15031_PID1CVerb
    ""
    TAB_VERB
    "%6.3"
    "-"
    COMPU_TAB_REF I15031_PID1CVerb
    
/end COMPU_METHOD

/begin COMPU_VTAB

    I15031_PID1CVerb
    ""
    TAB_VERB
    40
    1 "OBD II"
    2 "OBD"
    3 "OBD and OBD II"
    4 "OBD I"
    5 "No OBD"
    6 "EOBD"
    7 "EOBD and OBD II"
    8 "EOBD and OBD"
    9 "EOBD, OBD and OBD II"
    10 "JOBD"
    11 "JOBD and OBD II"
    12 "JOBD and EOBD"
    13 "JOBD, EOBD and OBD II"
    14 "OBD, EOBD and KOBD"
    15 "OBD, OBD II, EOBD and KOBD"
    17 "EMD"
    18 "EMD+"
    19 "HD OBD-C"
    20 "HD OBD"
    21 "WWH OBD"
    23 "HD EOBD-I"
    24 "HD EOBD-I N"
    25 "HD EOBD-II"
    26 "HD EOBD-II N"
    28 "OBDBr-1"
    29 "OBDBr-2"
    30 "KOBD"
    31 "IOBD I"
    32 "IOBD II"
    33 "HD EOBD-VI"
    34 "OBD, OBD II and HD OBD"
    35 "OBDBr-3"
    36 "MC EOBD-I"
    37 "MC EOBD-II"
    38 "MC COBD-I"
    39 "MC TOBD-I"
    40 "MC JOBD-I"
    41 "CN-OBD-6"
    42 "OBDBr-D"
    43 "CN-HDOBD-VI"


/end COMPU_VTAB

/begin COMPU_METHOD
    I15031_PID5FVerb
    ""
    TAB_VERB
    "%6.3"
    "-"
    COMPU_TAB_REF I15031_PID5FVerb
    
/end COMPU_METHOD

/begin COMPU_VTAB

    I15031_PID5FVerb
    ""
    TAB_VERB
    4
    14 "EURO IV B1"
    15 "EURO V B2"
    16 "EURO C"
    17 "EURO VI"


/end COMPU_VTAB

/begin COMPU_METHOD
    I15031_SRV8_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF I15031_SRV8_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    I15031_SRV8_SY_Compu
    ""
    TAB_VERB
    2
    0 "0"
    1 "1"


/end COMPU_VTAB

/begin COMPU_METHOD
    I15031_srv9_CVN_CalcVerb
    ""
    TAB_VERB
    "%2.1"
    "-"
    COMPU_TAB_REF I15031_srv9_CVN_CalcVerb
    
/end COMPU_METHOD

/begin COMPU_VTAB

    I15031_srv9_CVN_CalcVerb
    ""
    TAB_VERB
    7
    0 "NOTAVAILABLE"
    1 "CALC_START"
    2 "CALC_BUSY"
    3 "CALC_WRITE"
    4 "CALC_READY"
    5 "CALC_CLEAR"
    6 "CALC_CLEARBUSY"


/end COMPU_VTAB

/begin COMPU_METHOD
    I15031_srv9_VT_SupprRecent_CalVerb
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF I15031_srv9_VT_SupprRecent_CalVerb
    
/end COMPU_METHOD

/begin COMPU_VTAB

    I15031_srv9_VT_SupprRecent_CalVerb
    ""
    TAB_VERB
    2
    0 "OFF"
    1 "ON"


/end COMPU_VTAB

/begin COMPU_METHOD
    I27145_CANID_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF I27145_CANID_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    I27145_CANID_SC_Compu
    ""
    TAB_VERB
    3
    0 "WWHOBD_0"
    1 "WWHOBD_1"
    2 "WWHOBD_2"


/end COMPU_VTAB

/begin COMPU_METHOD
    I27145_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF I27145_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    I27145_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    IDLSHTDWN_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF IDLSHTDWN_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    IDLSHTDWN_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    IGNCL_QAG_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF IGNCL_QAG_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    IGNCL_QAG_SY_Compu
    ""
    TAB_VERB
    2
    1 "0.75 GradKW"
    2 "0.10 GradKW"


/end COMPU_VTAB

/begin COMPU_METHOD

    INJCRV_INJMASSPIIFACT_SY_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    InjMass
    ""
    RAT_FUNC
    "%6.4"
    "mg/hub"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    InjMassCyc
    ""
    RAT_FUNC
    "%6.4"
    "mg/cyc"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    InjMassInj
    ""
    RAT_FUNC
    "%6.4"
    "mg/inj"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    InjMs_q0p1_COMPU
    ""
    RAT_FUNC
    "%6.3"
    "mg/hub"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    InjMs_q0p2_COMPU
    ""
    RAT_FUNC
    "%6.3"
    "mg/hub"

    COEFFS 0 5 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    InjQnt
    ""
    RAT_FUNC
    "%6.3"
    "mm^3/hub"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    InjQntInj
    ""
    RAT_FUNC
    "%6.4"
    "mm^3/inj"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    INJSYS_POI1SETPOINT_SY_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    INJSYS_POI2SETPOINT_SY_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    INJSYS_POI3SETPOINT_SY_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    InjTime_us
    ""
    RAT_FUNC
    "%6.3"
    "us"

    COEFFS 0 2.5 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    INJVLV_ABE_ACTIVE_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF INJVLV_ABE_ACTIVE_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    INJVLV_ABE_ACTIVE_Compu
    ""
    TAB_VERB
    2
    0 "0"
    1 "1"


/end COMPU_VTAB

/begin COMPU_METHOD
    INJVLV_ABE_NOTACTIVE_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF INJVLV_ABE_NOTACTIVE_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    INJVLV_ABE_NOTACTIVE_Compu
    ""
    TAB_VERB
    2
    0 "0"
    1 "1"


/end COMPU_VTAB

/begin COMPU_METHOD
    INTKAIRT_INTKMNFLD_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF INTKAIRT_INTKMNFLD_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    INTKAIRT_INTKMNFLD_SC_Compu
    ""
    TAB_VERB
    3
    0 "no_signal"
    1 "sensor"
    2 "model"


/end COMPU_VTAB

/begin COMPU_METHOD
    INTKAIRT_SNSR1POS_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF INTKAIRT_SNSR1POS_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    INTKAIRT_SNSR1POS_SC_Compu
    ""
    TAB_VERB
    6
    0 "no_sensor"
    1 "IntkMnfld"
    2 "MnfldIcoDs"
    3 "ThrVlvUs"
    4 "CmprDs"
    5 "AirFltDs"


/end COMPU_VTAB

/begin COMPU_METHOD
    INTKAIRT_SNSR2POS_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF INTKAIRT_SNSR2POS_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    INTKAIRT_SNSR2POS_SC_Compu
    ""
    TAB_VERB
    6
    0 "no_sensor"
    1 "IntkMnfld"
    2 "MnfldIcoDs"
    3 "ThrVlvUs"
    4 "CmprDs"
    5 "AirFltDs"


/end COMPU_VTAB

/begin COMPU_METHOD
    INTKAIRT_SNSR3POS_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF INTKAIRT_SNSR3POS_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    INTKAIRT_SNSR3POS_SC_Compu
    ""
    TAB_VERB
    6
    0 "no_sensor"
    1 "IntkMnfld"
    2 "MnfldIcoDs"
    3 "ThrVlvUs"
    4 "CmprDs"
    5 "AirFltDs"


/end COMPU_VTAB

/begin COMPU_METHOD
    INTKAIRT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF INTKAIRT_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    INTKAIRT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    IOEXTDEV_CJ260_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    IOEXTDEV_PORTEXP_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF IOEXTDEV_PORTEXP_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    IOEXTDEV_PORTEXP_SC_Compu
    ""
    TAB_VERB
    2
    0 "No_Port_Expander"
    1 "Port_Expander_I2C"


/end COMPU_VTAB

/begin COMPU_METHOD
    IPDUM_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF IPDUM_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    IPDUM_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    IUMPR_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF IUMPR_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    IUMPR_SY_Compu
    ""
    TAB_VERB
    2
    0 "NO_IUMPR_ACTIVE"
    1 "IUMPR_ACTIVE"


/end COMPU_VTAB

/begin COMPU_METHOD
    IUMPR_VERS_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF IUMPR_VERS_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    IUMPR_VERS_SY_Compu
    ""
    TAB_VERB
    4
    0 "IUMPR_2005"
    1 "IUMPR_2007"
    2 "IUMPR_2009"
    3 "IUMPR_2016"


/end COMPU_VTAB

/begin COMPU_METHOD
    J1939NM_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF J1939NM_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    J1939NM_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    J1939RM_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF J1939RM_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    J1939RM_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    J1939TP_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF J1939TP_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    J1939TP_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    Kd_pRail2Q_1
    ""
    RAT_FUNC
    "%7.6"
    "mm^3/s/hPa"

    COEFFS 0 40960 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Kd_Prc_COMPU
    ""
    RAT_FUNC
    "%6.5"
    "%"

    COEFFS 0 8000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Ki_pRail2Q_1
    ""
    RAT_FUNC
    "%7.6"
    "mm^3/s^2/hPa"

    COEFFS 0 10737.41824 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    KLINE_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF KLINE_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    KLINE_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    Kp_LmbdRec2InjMass_1
    ""
    RAT_FUNC
    "%6.4"
    "mg/stroke"

    COEFFS 0 81.92 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Kp_pRail2Q_1
    ""
    RAT_FUNC
    "%7.6"
    "mm^3/s/hPa"

    COEFFS 0 81920 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    L9779_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF L9779_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    L9779_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    L9959_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    L9966_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    lambda
    ""
    RAT_FUNC
    "%6.5"
    "-"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    lambdaRec
    ""
    RAT_FUNC
    "%7.6"
    "-"

    COEFFS 0 10000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    lambdaRecVal
    ""
    RAT_FUNC
    "%6.5"
    "-"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    LDCOM_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF LDCOM_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    LDCOM_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    Length
    ""
    RAT_FUNC
    "%6.2"
    "m"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    LengthMm
    ""
    RAT_FUNC
    "%6.2"
    "mm"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    LINIPCORETYPE_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF LINIPCORETYPE_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    LINIPCORETYPE_SC_Compu
    ""
    TAB_VERB
    2
    0 "0"
    1 "1"


/end COMPU_VTAB

/begin COMPU_METHOD
    LIN_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF LIN_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    LIN_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    LSM_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF LSM_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    LSM_SY_Compu
    ""
    TAB_VERB
    2
    0 "0"
    1 "1"


/end COMPU_VTAB

/begin COMPU_METHOD
    LSU_CT_SENSORS_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF LSU_CT_SENSORS_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    LSU_CT_SENSORS_SY_Compu
    ""
    TAB_VERB
    5
    0 "0"
    1 "1"
    2 "2"
    3 "3"
    4 "4"


/end COMPU_VTAB

/begin COMPU_METHOD
    MDG1CPUDEVICE_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MDG1CPUDEVICE_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MDG1CPUDEVICE_SC_Compu
    ""
    TAB_VERB
    9
    0 "None"
    1 "Device1"
    2 "Device2"
    3 "Device3"
    4 "Device4"
    5 "Device5"
    13 "Device3+"
    14 "Device4+"
    15 "Device5+"


/end COMPU_VTAB

/begin COMPU_METHOD
    MDG1CPUSTEP_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MDG1CPUSTEP_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MDG1CPUSTEP_SC_Compu
    ""
    TAB_VERB
    10
    0 "None"
    1 "1"
    2 "2"
    110 "110"
    120 "120"
    130 "130"
    140 "140"
    210 "210"
    220 "220"
    230 "230"


/end COMPU_VTAB

/begin COMPU_METHOD
    MDG1CPUVENDOR_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MDG1CPUVENDOR_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MDG1CPUVENDOR_SC_Compu
    ""
    TAB_VERB
    4
    0 "None"
    1 "IFX"
    2 "JDP"
    3 "ST"


/end COMPU_VTAB

/begin COMPU_METHOD

    md_q0p1
    ""
    RAT_FUNC
    "%6.3"
    "Nm"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    MEM_CENDIAGACTVD_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MEM_CENDIAGACTVD_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MEM_CENDIAGACTVD_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    MEM_DIAGACTVDEXTD_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MEM_DIAGACTVDEXTD_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MEM_DIAGACTVDEXTD_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    MILLMP_ENGSTRTWITH2SECCDN_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MILLMP_ENGSTRTWITH2SECCDN_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MILLMP_ENGSTRTWITH2SECCDN_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    MoCCom_stCheckState_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MoCCom_stCheckState_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MoCCom_stCheckState_Compu
    ""
    TAB_VERB
    8
    0 "MOCCOM_CO_COR_IN_TIME_AND_VALUE_1"
    1 "MOCCOM_CO_COR_IN_TIME_AND_VALUE_2"
    2 "MOCCOM_CO_TOO_EARLY"
    3 "MOCCOM_CO_COR_IN_TIME_AND_VALUE_3"
    4 "MOCCOM_CO_TOO_LATE"
    5 "MOCCOM_CO_COR_IN_TIME_AND_VALUE_4A"
    6 "MOCCOM_CO_COR_IN_TIME_AND_VALUE_4B"
    7 "MOCCOM_CO_COR_IN_TIME_INC_IN_VALUE"


/end COMPU_VTAB

/begin COMPU_METHOD
    MoCCom_stComState_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MoCCom_stComState_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MoCCom_stComState_Compu
    ""
    TAB_VERB
    3
    0 "MOCCOM_CO_SYNCHRONIZING"
    1 "MOCCOM_CO_RECEIVING_QUERY"
    2 "MOCCOM_CO_SENDING_RESP"


/end COMPU_VTAB

/begin COMPU_METHOD
    MOCCPU_IT_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MOCCPU_IT_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MOCCPU_IT_SY_Compu
    ""
    TAB_VERB
    7
    0 "CHISTE"
    1 "FIT"
    2 "OTCG"
    3 "CHISTEundOTCG"
    4 "FITundOTCG"
    5 "Lock-Step"
    6 "HW_CMPBL_SOLN"


/end COMPU_VTAB

/begin COMPU_METHOD
    MOCFC_GTMCLKMON_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MOCFC_GTMCLKMON_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MOCFC_GTMCLKMON_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    MOCFC_GTMCONNTYP_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MOCFC_GTMCONNTYP_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MOCFC_GTMCONNTYP_SC_Compu
    ""
    TAB_VERB
    2
    0 "PORT"
    1 "AUX_IN"


/end COMPU_VTAB

/begin COMPU_METHOD

    MOCFC_NRCYCBLK_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    MOCFC_NRFASTCYCBLK_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    MOCFC_POSTBLDCHKS_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MOCFC_POSTBLDCHKS_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MOCFC_POSTBLDCHKS_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    MOCFC_SCCERRREACTN_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MOCFC_SCCERRREACTN_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MOCFC_SCCERRREACTN_SC_Compu
    ""
    TAB_VERB
    2
    0 "Disable"
    1 "Enable"


/end COMPU_VTAB

/begin COMPU_METHOD
    MOCMM_ABESHTOFFPAHTESTENA_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MOCMM_ABESHTOFFPAHTESTENA_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MOCMM_ABESHTOFFPAHTESTENA_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    MOCMM_CANSHOFFPAHTESTENA_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MOCMM_CANSHOFFPAHTESTENA_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MOCMM_CANSHOFFPAHTESTENA_SC_Compu
    ""
    TAB_VERB
    2
    0 "Disabled"
    1 "Enabled"


/end COMPU_VTAB

/begin COMPU_METHOD
    MOCMM_FRSHOFFPAHTESTENA_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MOCMM_FRSHOFFPAHTESTENA_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MOCMM_FRSHOFFPAHTESTENA_SC_Compu
    ""
    TAB_VERB
    2
    0 "Disabled"
    1 "Enabled"


/end COMPU_VTAB

/begin COMPU_METHOD
    MOCMM_HWLAYOUT_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MOCMM_HWLAYOUT_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MOCMM_HWLAYOUT_SC_Compu
    ""
    TAB_VERB
    2
    1 "SOLUTION1"
    2 "SOLUTION2"


/end COMPU_VTAB

/begin COMPU_METHOD
    MOCMM_MCUINJSHTOFFPAHTESTENA_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MOCMM_MCUINJSHTOFFPAHTESTENA_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MOCMM_MCUINJSHTOFFPAHTESTENA_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    MOCMM_NROKRESP_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MOCMM_NROKRESP_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MOCMM_NROKRESP_SC_Compu
    ""
    TAB_VERB
    4
    0 "NO"
    1 "ONE"
    2 "TWO"
    3 "THREE"


/end COMPU_VTAB

/begin COMPU_METHOD

    MOCMM_NRTRCV_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    MOCMM_UCHIP_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MOCMM_UCHIP_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MOCMM_UCHIP_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    MoCSOP_stCheckStateCtrlline_mp_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MoCSOP_stCheckStateCtrlline_mp_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MoCSOP_stCheckStateCtrlline_mp_Compu
    ""
    TAB_VERB
    15
    0 "-"
    1 "MOCSOP_CO_OUT_OF_DRIVE"
    2 "MOCSOP_CO_POSITIVE_TEST_PREP"
    3 "MOCSOP_CO_POSITIVE_TEST_DIA"
    4 "MOCSOP_CO_WDA_TEST_PREP"
    5 "MOCSOP_CO_WDA_TEST_DIA"
    6 "MOCSOP_CO_ERRPIN_TEST_PREP"
    7 "MOCSOP_CO_ERRPIN_TEST_DIA"
    8 "MOCSOP_CO_CTRL_LINES_TEST_PREP"
    9 "MOCSOP_CO_CTRL_LINES_TEST_DIA"
    10 "MOCSOP_CO_OVERVOLTAGE_TEST_PREP"
    11 "MOCSOP_CO_OVERVOLTAGE_TEST_DIA"
    12 "MOCSOP_CO_ERR_CHECK"
    13 "MOCSOP_CO_ERR_REACTION"
    14 "MOCSOP_CO_TO_MOCCOM"


/end COMPU_VTAB

/begin COMPU_METHOD
    MoCSOP_stCtrlLineErrReactn_C_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MoCSOP_stCtrlLineErrReactn_C_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MoCSOP_stCtrlLineErrReactn_C_Compu
    ""
    TAB_VERB
    2
    1 "MOCSOP_CO_REACTN_ICO"
    2 "MOCSOP_CO_REACTN_RESETLOOP"


/end COMPU_VTAB

/begin COMPU_METHOD
    MoCSOP_stEmmStateIFX_MP_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MoCSOP_stEmmStateIFX_MP_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MoCSOP_stEmmStateIFX_MP_Compu
    ""
    TAB_VERB
    4
    0 "SSM_START"
    1 "SSM_RUN"
    2 "SSM_FAULT"
    32 "STATE_ERROR"


/end COMPU_VTAB

/begin COMPU_METHOD
    MoCSOP_stErrPin_MP_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MoCSOP_stErrPin_MP_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MoCSOP_stErrPin_MP_Compu
    ""
    TAB_VERB
    2
    0 "ERRPIN_ACTIVE"
    1 "ERRPIN_NOT_ACTIVE"


/end COMPU_VTAB

/begin COMPU_METHOD
    MoCSOP_stErrReactn_CA_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MoCSOP_stErrReactn_CA_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MoCSOP_stErrReactn_CA_Compu
    ""
    TAB_VERB
    3
    0 "MOCSOP_CO_REACTN_NORMAL_RUN"
    1 "MOCSOP_CO_REACTN_ICO"
    2 "MOCSOP_CO_REACTN_RESETLOOP"


/end COMPU_VTAB

/begin COMPU_METHOD
    MoCSOP_stOVErrReactn_C_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MoCSOP_stOVErrReactn_C_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MoCSOP_stOVErrReactn_C_Compu
    ""
    TAB_VERB
    2
    1 "MOCSOP_CO_REACTN_ICO"
    2 "MOCSOP_CO_REACTN_RESETLOOP"


/end COMPU_VTAB

/begin COMPU_METHOD
    MoExe_Co_PFC_ID_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MoExe_Co_PFC_ID_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MoExe_Co_PFC_ID_Compu
    ""
    TAB_VERB
    35
    0 "-"
    16777471 "MOCEMM_CO_REQERRPIN_ID_HW"
    16777217 "MOCEMM_CO_REQERRPIN_ID_MOCMEM"
    16777216 "MOCEMM_CO_REQERRPIN_ID_MOCCOM"
    16777218 "MOCEMM_CO_REQERRPIN_ID_MOCSOP"
    16777225 "MOCEMM_CO_REQERRPIN_ID_MOCADC"
    16777220 "MOCEMM_CO_REQERRPIN_ID_MOFWDA"
    16777219 "MOCEMM_CO_REQERRPIN_ID_MOCEMM"
    16777221 "MOCEMM_CO_REQERRPIN_ID_OCWDATEST"
    16777222 "MOCEMM_CO_REQERRPIN_ID_SWSHRL2"
    16777223 "MOCEMM_CO_REQERRPIN_ID_MOCGTM"
    16777224 "MOCEMM_CO_REQERRPIN_ID_MOCSCC"
    16777226 "MOCEMM_CO_REQERRPIN_ID_MOCIWDH"
    15 "MO_GLBL_PROC_CORE1_10MS_NR1_PFC_ID"
    20 "MO_GLBL_PROC_MANYCORE_CORE1_10MS_NR1_PFC_ID"
    21 "MOCCOM_CO_PROC_CORE1_10MS_NR1_PFC_ID"
    17 "MOCCPU_CO_PROC_CORE1_10MS_NR1_PFC_ID"
    9 "MOCEMM_CO_PROC_CORE1_10MS_NR1_PFC_ID"
    13 "MOCGTM_CO_PROC_CORE1_10MS_NR1_PFC_ID"
    18 "MOCIWDH_CO_PROC_CORE1_10MS_NR1_PFC_ID"
    4 "MOCMEM_CO_CHKCSA_PROC_CORE1_10MS_NR1_PFC_ID"
    11 "MOCMEM_CO_CHKRAM_PROC_CORE1_10MS_NR1_PFC_ID"
    12 "MOCMEM_CO_CHKROM_PROC_CORE1_10MS_NR1_PFC_ID"
    3 "MOCMEM_CO_CHKSTCK_PROC_CORE1_10MS_NR1_PFC_ID"
    14 "MOCMEM_CO_ERRHDL_PROC_CORE1_10MS_NR1_PFC_ID"
    19 "MOCPFC_CO_IWDH_PROC_CORE1_10MS_NR1_PFC_ID"
    16 "MOCPFC_CO_MANYCORE_PROC_CORE1_10MS_NR1_PFC_ID"
    10 "MOCSCC_CO_PROC_CORE1_10MS_NR1_PFC_ID"
    22 "MOCSOP_CO_PROC_CORE1_10MS_NR1_PFC_ID"
    8 "MOCSOP_CO_PROC_10MS_CORE1_10MS_NR1_PFC_ID"
    1 "MOEXE_CO_TASK_CORE1_TASK10MS_NR1_PFC_ID"
    5 "MOEXE_RBR_SLOTA_PROC_CORE1_10MS_NR1_PFC_ID"
    6 "MOFVAR_POSTBLDSEL_PROC_CORE1_10MS_NR1_PFC_ID"
    7 "MOFWDA_CO_PROC_CORE1_10MS_NR1_PFC_ID"
    2 "MOSYSCTRL_CO_PROC_CORE1_10MS_NR1_PFC_ID"


/end COMPU_VTAB

/begin COMPU_METHOD

    Molmass
    ""
    RAT_FUNC
    "%6.4"
    "g/mol"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Moment_Inertia
    ""
    RAT_FUNC
    "%6.4"
    "kg * m^2"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    MoXEMM_HwLTErrorSimnCode_VERB
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MoXEMM_HwLTErrorSimnCode_VERB
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MoXEMM_HwLTErrorSimnCode_VERB
    ""
    TAB_VERB
    12
    0 "MoXEMM_NO_ERROR"
    1 "MoXEMMHwLTMCUFW"
    2 "MoXEMMHwLTStbySMUAlvTest"
    3 "MoXEMMHwLTMonBIST"
    4 "MoXEMMHwLTRegMonTest"
    5 "MoXEMMHwLTTempSens"
    6 "MoXEMMHwLTUCBCfg"
    7 "RESERVED_7"
    8 "RESERVED_8"
    9 "MoXEMMHwLTMBIST"
    10 "MoXEMMHwLTLBIST"
    65535 "MoXEMM_CLR_ERROR"


/end COMPU_VTAB

/begin COMPU_METHOD
    MoXEMM_SMUErrorSimnCode_VERB
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MoXEMM_SMUErrorSimnCode_VERB
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MoXEMM_SMUErrorSimnCode_VERB
    ""
    TAB_VERB
    450
    0 "MoXEMM_NO_ERROR"
    1 "MoXEMM_SMU_ALM_0_0"
    2 "MoXEMM_SMU_ALM_0_1"
    3 "MoXEMM_SMU_ALM_0_2"
    4 "MoXEMM_reserved_0_3"
    5 "MoXEMM_SMU_ALM_0_4"
    6 "MoXEMM_SMU_ALM_0_5"
    7 "MoXEMM_reserved_0_6"
    8 "MoXEMM_SMU_ALM_0_7"
    9 "MoXEMM_SMU_ALM_0_8"
    10 "MoXEMM_reserved_0_9"
    11 "MoXEMM_SMU_ALM_0_10"
    12 "MoXEMM_SMU_ALM_0_11"
    13 "MoXEMM_reserved_0_12"
    14 "MoXEMM_SMU_ALM_0_13"
    15 "MoXEMM_SMU_ALM_0_14"
    16 "MoXEMM_reserved_0_15"
    17 "MoXEMM_reserved_0_16"
    18 "MoXEMM_reserved_0_17"
    19 "MoXEMM_reserved_0_18"
    20 "MoXEMM_reserved_0_19"
    21 "MoXEMM_reserved_0_20"
    22 "MoXEMM_reserved_0_21"
    23 "MoXEMM_SMU_ALM_0_22"
    24 "MoXEMM_SMU_ALM_0_23"
    25 "MoXEMM_reserved_0_24"
    26 "MoXEMM_reserved_0_25"
    27 "MoXEMM_reserved_0_26"
    28 "MoXEMM_reserved_0_27"
    29 "MoXEMM_reserved_0_28"
    30 "MoXEMM_reserved_0_29"
    31 "MoXEMM_reserved_0_30"
    32 "MoXEMM_reserved_0_31"
    33 "MoXEMM_SMU_ALM_1_0"
    34 "MoXEMM_SMU_ALM_1_1"
    35 "MoXEMM_SMU_ALM_1_2"
    36 "MoXEMM_reserved_1_3"
    37 "MoXEMM_SMU_ALM_1_4"
    38 "MoXEMM_SMU_ALM_1_5"
    39 "MoXEMM_reserved_1_6"
    40 "MoXEMM_SMU_ALM_1_7"
    41 "MoXEMM_SMU_ALM_1_8"
    42 "MoXEMM_reserved_1_9"
    43 "MoXEMM_SMU_ALM_1_10"
    44 "MoXEMM_SMU_ALM_1_11"
    45 "MoXEMM_reserved_1_12"
    46 "MoXEMM_SMU_ALM_1_13"
    47 "MoXEMM_SMU_ALM_1_14"
    48 "MoXEMM_reserved_1_15"
    49 "MoXEMM_reserved_1_16"
    50 "MoXEMM_reserved_1_17"
    51 "MoXEMM_reserved_1_18"
    52 "MoXEMM_reserved_1_19"
    53 "MoXEMM_reserved_1_20"
    54 "MoXEMM_reserved_1_21"
    55 "MoXEMM_SMU_ALM_1_22"
    56 "MoXEMM_SMU_ALM_1_23"
    57 "MoXEMM_reserved_1_24"
    58 "MoXEMM_reserved_1_25"
    59 "MoXEMM_reserved_1_26"
    60 "MoXEMM_reserved_1_27"
    61 "MoXEMM_reserved_1_28"
    62 "MoXEMM_reserved_1_29"
    63 "MoXEMM_reserved_1_30"
    64 "MoXEMM_reserved_1_31"
    65 "MoXEMM_reserved_2_0"
    66 "MoXEMM_SMU_ALM_2_1"
    67 "MoXEMM_SMU_ALM_2_2"
    68 "MoXEMM_reserved_2_3"
    69 "MoXEMM_SMU_ALM_2_4"
    70 "MoXEMM_SMU_ALM_2_5"
    71 "MoXEMM_reserved_2_6"
    72 "MoXEMM_SMU_ALM_2_7"
    73 "MoXEMM_SMU_ALM_2_8"
    74 "MoXEMM_reserved_2_9"
    75 "MoXEMM_SMU_ALM_2_10"
    76 "MoXEMM_SMU_ALM_2_11"
    77 "MoXEMM_reserved_2_12"
    78 "MoXEMM_SMU_ALM_2_13"
    79 "MoXEMM_SMU_ALM_2_14"
    80 "MoXEMM_reserved_2_15"
    81 "MoXEMM_reserved_2_16"
    82 "MoXEMM_reserved_2_17"
    83 "MoXEMM_reserved_2_18"
    84 "MoXEMM_reserved_2_19"
    85 "MoXEMM_reserved_2_20"
    86 "MoXEMM_reserved_2_21"
    87 "MoXEMM_SMU_ALM_2_22"
    88 "MoXEMM_SMU_ALM_2_23"
    89 "MoXEMM_reserved_2_24"
    90 "MoXEMM_reserved_2_25"
    91 "MoXEMM_reserved_2_26"
    92 "MoXEMM_reserved_2_27"
    93 "MoXEMM_reserved_2_28"
    94 "MoXEMM_reserved_2_29"
    95 "MoXEMM_reserved_2_30"
    96 "MoXEMM_reserved_2_31"
    97 "MoXEMM_reserved_3_0"
    98 "MoXEMM_SMU_ALM_3_1"
    99 "MoXEMM_SMU_ALM_3_2"
    100 "MoXEMM_reserved_3_3"
    101 "MoXEMM_SMU_ALM_3_4"
    102 "MoXEMM_SMU_ALM_3_5"
    103 "MoXEMM_reserved_3_6"
    104 "MoXEMM_SMU_ALM_3_7"
    105 "MoXEMM_SMU_ALM_3_8"
    106 "MoXEMM_reserved_3_9"
    107 "MoXEMM_SMU_ALM_3_10"
    108 "MoXEMM_SMU_ALM_3_11"
    109 "MoXEMM_reserved_3_12"
    110 "MoXEMM_SMU_ALM_3_13"
    111 "MoXEMM_SMU_ALM_3_14"
    112 "MoXEMM_reserved_3_15"
    113 "MoXEMM_reserved_3_16"
    114 "MoXEMM_reserved_3_17"
    115 "MoXEMM_reserved_3_18"
    116 "MoXEMM_reserved_3_19"
    117 "MoXEMM_reserved_3_20"
    118 "MoXEMM_reserved_3_21"
    119 "MoXEMM_SMU_ALM_3_22"
    120 "MoXEMM_SMU_ALM_3_23"
    121 "MoXEMM_reserved_3_24"
    122 "MoXEMM_reserved_3_25"
    123 "MoXEMM_reserved_3_26"
    124 "MoXEMM_reserved_3_27"
    125 "MoXEMM_reserved_3_28"
    126 "MoXEMM_reserved_3_29"
    127 "MoXEMM_reserved_3_30"
    128 "MoXEMM_reserved_3_31"
    129 "MoXEMM_reserved_4_0"
    130 "MoXEMM_reserved_4_1"
    131 "MoXEMM_reserved_4_2"
    132 "MoXEMM_reserved_4_3"
    133 "MoXEMM_reserved_4_4"
    134 "MoXEMM_reserved_4_5"
    135 "MoXEMM_reserved_4_6"
    136 "MoXEMM_reserved_4_7"
    137 "MoXEMM_reserved_4_8"
    138 "MoXEMM_reserved_4_9"
    139 "MoXEMM_reserved_4_10"
    140 "MoXEMM_reserved_4_11"
    141 "MoXEMM_reserved_4_12"
    142 "MoXEMM_reserved_4_13"
    143 "MoXEMM_reserved_4_14"
    144 "MoXEMM_reserved_4_15"
    145 "MoXEMM_reserved_4_16"
    146 "MoXEMM_reserved_4_17"
    147 "MoXEMM_reserved_4_18"
    148 "MoXEMM_reserved_4_19"
    149 "MoXEMM_reserved_4_20"
    150 "MoXEMM_reserved_4_21"
    151 "MoXEMM_reserved_4_22"
    152 "MoXEMM_reserved_4_23"
    153 "MoXEMM_reserved_4_24"
    154 "MoXEMM_reserved_4_25"
    155 "MoXEMM_reserved_4_26"
    156 "MoXEMM_reserved_4_27"
    157 "MoXEMM_reserved_4_28"
    158 "MoXEMM_reserved_4_29"
    159 "MoXEMM_reserved_4_30"
    160 "MoXEMM_reserved_4_31"
    161 "MoXEMM_reserved_5_0"
    162 "MoXEMM_reserved_5_1"
    163 "MoXEMM_reserved_5_2"
    164 "MoXEMM_reserved_5_3"
    165 "MoXEMM_reserved_5_4"
    166 "MoXEMM_reserved_5_5"
    167 "MoXEMM_reserved_5_6"
    168 "MoXEMM_reserved_5_7"
    169 "MoXEMM_reserved_5_8"
    170 "MoXEMM_reserved_5_9"
    171 "MoXEMM_reserved_5_10"
    172 "MoXEMM_reserved_5_11"
    173 "MoXEMM_reserved_5_12"
    174 "MoXEMM_reserved_5_13"
    175 "MoXEMM_reserved_5_14"
    176 "MoXEMM_reserved_5_15"
    177 "MoXEMM_reserved_5_16"
    178 "MoXEMM_reserved_5_17"
    179 "MoXEMM_reserved_5_18"
    180 "MoXEMM_reserved_5_19"
    181 "MoXEMM_reserved_5_20"
    182 "MoXEMM_reserved_5_21"
    183 "MoXEMM_reserved_5_22"
    184 "MoXEMM_reserved_5_23"
    185 "MoXEMM_reserved_5_24"
    186 "MoXEMM_reserved_5_25"
    187 "MoXEMM_reserved_5_26"
    188 "MoXEMM_reserved_5_27"
    189 "MoXEMM_reserved_5_28"
    190 "MoXEMM_reserved_5_29"
    191 "MoXEMM_reserved_5_30"
    192 "MoXEMM_reserved_5_31"
    193 "MoXEMM_SMU_ALM_6_0"
    194 "MoXEMM_reserved_6_1"
    195 "MoXEMM_SMU_ALM_6_2"
    196 "MoXEMM_reserved_6_3"
    197 "MoXEMM_SMU_ALM_6_4"
    198 "MoXEMM_SMU_ALM_6_5"
    199 "MoXEMM_reserved_6_6"
    200 "MoXEMM_SMU_ALM_6_7"
    201 "MoXEMM_SMU_ALM_6_8"
    202 "MoXEMM_reserved_6_9"
    203 "MoXEMM_reserved_6_10"
    204 "MoXEMM_SMU_ALM_6_11"
    205 "MoXEMM_SMU_ALM_6_12"
    206 "MoXEMM_reserved_6_13"
    207 "MoXEMM_SMU_ALM_6_14"
    208 "MoXEMM_SMU_ALM_6_15"
    209 "MoXEMM_reserved_6_16"
    210 "MoXEMM_SMU_ALM_6_17"
    211 "MoXEMM_SMU_ALM_6_18"
    212 "MoXEMM_reserved_6_19"
    213 "MoXEMM_SMU_ALM_6_20"
    214 "MoXEMM_SMU_ALM_6_21"
    215 "MoXEMM_reserved_6_22"
    216 "MoXEMM_reserved_6_23"
    217 "MoXEMM_reserved_6_24"
    218 "MoXEMM_SMU_ALM_6_25"
    219 "MoXEMM_reserved_6_26"
    220 "MoXEMM_reserved_6_27"
    221 "MoXEMM_reserved_6_28"
    222 "MoXEMM_reserved_6_29"
    223 "MoXEMM_reserved_6_30"
    224 "MoXEMM_reserved_6_31"
    225 "MoXEMM_reserved_7_0"
    226 "MoXEMM_SMU_ALM_7_1"
    227 "MoXEMM_SMU_ALM_7_2"
    228 "MoXEMM_reserved_7_3"
    229 "MoXEMM_reserved_7_4"
    230 "MoXEMM_reserved_7_5"
    231 "MoXEMM_reserved_7_6"
    232 "MoXEMM_reserved_7_7"
    233 "MoXEMM_reserved_7_8"
    234 "MoXEMM_reserved_7_9"
    235 "MoXEMM_reserved_7_10"
    236 "MoXEMM_reserved_7_11"
    237 "MoXEMM_SMU_ALM_7_12"
    238 "MoXEMM_SMU_ALM_7_13"
    239 "MoXEMM_SMU_ALM_7_14"
    240 "MoXEMM_SMU_ALM_7_15"
    241 "MoXEMM_SMU_ALM_7_16"
    242 "MoXEMM_SMU_ALM_7_17"
    243 "MoXEMM_reserved_7_18"
    244 "MoXEMM_reserved_7_19"
    245 "MoXEMM_SMU_ALM_7_20"
    246 "MoXEMM_reserved_7_21"
    247 "MoXEMM_reserved_7_22"
    248 "MoXEMM_reserved_7_23"
    249 "MoXEMM_reserved_7_24"
    250 "MoXEMM_SMU_ALM_7_25"
    251 "MoXEMM_SMU_ALM_7_26"
    252 "MoXEMM_reserved_7_27"
    253 "MoXEMM_SMU_ALM_7_28"
    254 "MoXEMM_SMU_ALM_7_29"
    255 "MoXEMM_SMU_ALM_7_30"
    256 "MoXEMM_SMU_ALM_7_31"
    257 "MoXEMM_SMU_ALM_8_0"
    258 "MoXEMM_SMU_ALM_8_1"
    259 "MoXEMM_SMU_ALM_8_2"
    260 "MoXEMM_SMU_ALM_8_3"
    261 "MoXEMM_SMU_ALM_8_4"
    262 "MoXEMM_reserved_8_5"
    263 "MoXEMM_reserved_8_6"
    264 "MoXEMM_reserved_8_7"
    265 "MoXEMM_SMU_ALM_8_8"
    266 "MoXEMM_SMU_ALM_8_9"
    267 "MoXEMM_SMU_ALM_8_10"
    268 "MoXEMM_SMU_ALM_8_11"
    269 "MoXEMM_SMU_ALM_8_12"
    270 "MoXEMM_SMU_ALM_8_13"
    271 "MoXEMM_reserved_8_14"
    272 "MoXEMM_reserved_8_15"
    273 "MoXEMM_SMU_ALM_8_16"
    274 "MoXEMM_reserved_8_17"
    275 "MoXEMM_SMU_ALM_8_18"
    276 "MoXEMM_reserved_8_19"
    277 "MoXEMM_reserved_8_20"
    278 "MoXEMM_reserved_8_21"
    279 "MoXEMM_reserved_8_22"
    280 "MoXEMM_reserved_8_23"
    281 "MoXEMM_reserved_8_24"
    282 "MoXEMM_reserved_8_25"
    283 "MoXEMM_reserved_8_26"
    284 "MoXEMM_reserved_8_27"
    285 "MoXEMM_reserved_8_28"
    286 "MoXEMM_reserved_8_29"
    287 "MoXEMM_SMU_ALM_8_30"
    288 "MoXEMM_SMU_ALM_8_31"
    289 "MoXEMM_SMU_ALM_9_0"
    290 "MoXEMM_SMU_ALM_9_1"
    291 "MoXEMM_reserved_9_2"
    292 "MoXEMM_SMU_ALM_9_3"
    293 "MoXEMM_reserved_9_4"
    294 "MoXEMM_reserved_9_5"
    295 "MoXEMM_reserved_9_6"
    296 "MoXEMM_reserved_9_7"
    297 "MoXEMM_reserved_9_8"
    298 "MoXEMM_reserved_9_9"
    299 "MoXEMM_reserved_9_10"
    300 "MoXEMM_reserved_9_11"
    301 "MoXEMM_reserved_9_12"
    302 "MoXEMM_reserved_9_13"
    303 "MoXEMM_reserved_9_14"
    304 "MoXEMM_SMU_ALM_9_15"
    305 "MoXEMM_reserved_9_16"
    306 "MoXEMM_reserved_9_17"
    307 "MoXEMM_reserved_9_18"
    308 "MoXEMM_reserved_9_19"
    309 "MoXEMM_reserved_9_20"
    310 "MoXEMM_reserved_9_21"
    311 "MoXEMM_reserved_9_22"
    312 "MoXEMM_reserved_9_23"
    313 "MoXEMM_reserved_9_24"
    314 "MoXEMM_reserved_9_25"
    315 "MoXEMM_reserved_9_26"
    316 "MoXEMM_reserved_9_27"
    317 "MoXEMM_reserved_9_28"
    318 "MoXEMM_reserved_9_29"
    319 "MoXEMM_reserved_9_30"
    320 "MoXEMM_reserved_9_31"
    321 "MoXEMM_reserved_10_0"
    322 "MoXEMM_reserved_10_1"
    323 "MoXEMM_reserved_10_2"
    324 "MoXEMM_reserved_10_3"
    325 "MoXEMM_reserved_10_4"
    326 "MoXEMM_reserved_10_5"
    327 "MoXEMM_reserved_10_6"
    328 "MoXEMM_reserved_10_7"
    329 "MoXEMM_reserved_10_8"
    330 "MoXEMM_reserved_10_9"
    331 "MoXEMM_reserved_10_10"
    332 "MoXEMM_reserved_10_11"
    333 "MoXEMM_reserved_10_12"
    334 "MoXEMM_reserved_10_13"
    335 "MoXEMM_reserved_10_14"
    336 "MoXEMM_reserved_10_15"
    337 "MoXEMM_SMU_ALM_10_16"
    338 "MoXEMM_SMU_ALM_10_17"
    339 "MoXEMM_reserved_10_18"
    340 "MoXEMM_reserved_10_19"
    341 "MoXEMM_reserved_10_20"
    342 "MoXEMM_SMU_ALM_10_21"
    343 "MoXEMM_reserved_10_22"
    344 "MoXEMM_reserved_10_23"
    345 "MoXEMM_reserved_10_24"
    346 "MoXEMM_reserved_10_25"
    347 "MoXEMM_reserved_10_26"
    348 "MoXEMM_reserved_10_27"
    349 "MoXEMM_reserved_10_28"
    350 "MoXEMM_reserved_10_29"
    351 "MoXEMM_reserved_10_30"
    352 "MoXEMM_reserved_10_31"
    353 "MoXEMM_SMU_ALM_11_0"
    354 "MoXEMM_SMU_ALM_11_1"
    355 "MoXEMM_SMU_ALM_11_2"
    356 "MoXEMM_SMU_ALM_11_3"
    357 "MoXEMM_SMU_ALM_11_4"
    358 "MoXEMM_SMU_ALM_11_5"
    359 "MoXEMM_reserved_11_6"
    360 "MoXEMM_reserved_11_7"
    361 "MoXEMM_SMU_ALM_11_8"
    362 "MoXEMM_SMU_ALM_11_9"
    363 "MoXEMM_reserved_11_10"
    364 "MoXEMM_reserved_11_11"
    365 "MoXEMM_reserved_11_12"
    366 "MoXEMM_reserved_11_13"
    367 "MoXEMM_reserved_11_14"
    368 "MoXEMM_reserved_11_15"
    369 "MoXEMM_reserved_11_16"
    370 "MoXEMM_reserved_11_17"
    371 "MoXEMM_reserved_11_18"
    372 "MoXEMM_reserved_11_19"
    373 "MoXEMM_reserved_11_20"
    374 "MoXEMM_reserved_11_21"
    375 "MoXEMM_reserved_11_22"
    376 "MoXEMM_reserved_11_23"
    377 "MoXEMM_reserved_11_24"
    378 "MoXEMM_reserved_11_25"
    379 "MoXEMM_reserved_11_26"
    380 "MoXEMM_reserved_11_27"
    381 "MoXEMM_reserved_11_28"
    382 "MoXEMM_reserved_11_29"
    383 "MoXEMM_reserved_11_30"
    384 "MoXEMM_reserved_11_31"
    641 "MoXEMM_reserved_20_0"
    642 "MoXEMM_reserved_20_1"
    643 "MoXEMM_reserved_20_2"
    644 "MoXEMM_reserved_20_3"
    645 "MoXEMM_reserved_20_4"
    646 "MoXEMM_reserved_20_5"
    647 "MoXEMM_reserved_20_6"
    648 "MoXEMM_reserved_20_7"
    649 "MoXEMM_reserved_20_8"
    650 "MoXEMM_reserved_20_9"
    651 "MoXEMM_reserved_20_10"
    652 "MoXEMM_reserved_20_11"
    653 "MoXEMM_reserved_20_12"
    654 "MoXEMM_reserved_20_13"
    655 "MoXEMM_reserved_20_14"
    656 "MoXEMM_reserved_20_15"
    657 "MoXEMM_reserved_20_16"
    658 "MoXEMM_reserved_20_17"
    659 "MoXEMM_reserved_20_18"
    660 "MoXEMM_reserved_20_19"
    661 "MoXEMM_reserved_20_20"
    662 "MoXEMM_reserved_20_21"
    663 "MoXEMM_reserved_20_22"
    664 "MoXEMM_reserved_20_23"
    665 "MoXEMM_reserved_20_24"
    666 "MoXEMM_reserved_20_25"
    667 "MoXEMM_reserved_20_26"
    668 "MoXEMM_reserved_20_27"
    669 "MoXEMM_reserved_20_28"
    670 "MoXEMM_reserved_20_29"
    671 "MoXEMM_reserved_20_30"
    672 "MoXEMM_reserved_20_31"
    673 "MoXEMM_SMU_ALM_21_0"
    674 "MoXEMM_reserved_21_1"
    675 "MoXEMM_reserved_21_2"
    676 "MoXEMM_SMU_ALM_21_3"
    677 "MoXEMM_reserved_21_4"
    678 "MoXEMM_reserved_21_5"
    679 "MoXEMM_reserved_21_6"
    680 "MoXEMM_reserved_21_7"
    681 "MoXEMM_reserved_21_8"
    682 "MoXEMM_reserved_21_9"
    683 "MoXEMM_reserved_21_10"
    684 "MoXEMM_reserved_21_11"
    685 "MoXEMM_reserved_21_12"
    686 "MoXEMM_reserved_21_13"
    687 "MoXEMM_reserved_21_14"
    688 "MoXEMM_reserved_21_15"
    689 "MoXEMM_SMU_ALM_21_16"
    690 "MoXEMM_reserved_21_17"
    691 "MoXEMM_reserved_21_18"
    692 "MoXEMM_reserved_21_19"
    693 "MoXEMM_reserved_21_20"
    694 "MoXEMM_reserved_21_21"
    695 "MoXEMM_reserved_21_22"
    696 "MoXEMM_reserved_21_23"
    697 "MoXEMM_reserved_21_24"
    698 "MoXEMM_reserved_21_25"
    699 "MoXEMM_reserved_21_26"
    700 "MoXEMM_reserved_21_27"
    701 "MoXEMM_reserved_21_28"
    702 "MoXEMM_reserved_21_29"
    703 "MoXEMM_reserved_21_30"
    704 "MoXEMM_reserved_21_31"
    65535 "MoXEMM_CLR_ERROR"


/end COMPU_VTAB

/begin COMPU_METHOD
    MO_CMNDSLGSLSW_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MO_CMNDSLGSLSW_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MO_CMNDSLGSLSW_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    MO_EXTDTSK_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MO_EXTDTSK_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MO_EXTDTSK_SC_Compu
    ""
    TAB_VERB
    4
    0 "Disabled"
    2 "2ms"
    4 "4ms"
    5 "5ms"


/end COMPU_VTAB

/begin COMPU_METHOD
    MO_FRDMINTFRMETHOD_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MO_FRDMINTFRMETHOD_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MO_FRDMINTFRMETHOD_SC_Compu
    ""
    TAB_VERB
    3
    0 "CPL"
    1 "MPU"
    2 "CPL_MPU"


/end COMPU_VTAB

/begin COMPU_METHOD
    MO_LBISTENA_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MO_LBISTENA_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MO_LBISTENA_SC_Compu
    ""
    TAB_VERB
    2
    0 "Disabled"
    1 "Enabled"


/end COMPU_VTAB

/begin COMPU_METHOD
    MO_MAXVALINDCR_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MO_MAXVALINDCR_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MO_MAXVALINDCR_SC_Compu
    ""
    TAB_VERB
    2
    0 "Disabled"
    1 "Enabled"


/end COMPU_VTAB

/begin COMPU_METHOD

    MO_NRSLOTS_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    MO_NRUSEDCORESFTY_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MO_NRUSEDCORESFTY_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MO_NRUSEDCORESFTY_SC_Compu
    ""
    TAB_VERB
    15
    1 "Core0"
    2 "Core1"
    3 "Core0_and_Core1"
    4 "Core2"
    5 "Core0_and_Core2"
    6 "Core1_and_Core2"
    7 "Core0_Core1_and_Core2"
    8 "Core3"
    9 "Core0_and_Core3"
    10 "Core1_and_Core3"
    11 "Core0_Core1_and_Core3"
    12 "Core2_and_Core3"
    13 "Core0_Core2_and_Core3"
    14 "Core1_Core2_and_Core3"
    15 "Core0_Core1_Core2_and_Core3"


/end COMPU_VTAB

/begin COMPU_METHOD
    MO_RAMCHKTYP_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MO_RAMCHKTYP_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MO_RAMCHKTYP_SC_Compu
    ""
    TAB_VERB
    2
    1 "Default"
    2 "MBIST"


/end COMPU_VTAB

/begin COMPU_METHOD
    MO_ROM_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MO_ROM_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MO_ROM_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    MO_VDD5MONHWTYP_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MO_VDD5MONHWTYP_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MO_VDD5MONHWTYP_SC_Compu
    ""
    TAB_VERB
    2
    0 "ASIC"
    1 "DIPO_CIRC"


/end COMPU_VTAB

/begin COMPU_METHOD
    MRLY_STACTDSQENA_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MRLY_STACTDSQENA_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MRLY_STACTDSQENA_SC_Compu
    ""
    TAB_VERB
    2
    0 "Disabled"
    1 "Enabled"


/end COMPU_VTAB

/begin COMPU_METHOD

    mSoot_g
    ""
    RAT_FUNC
    "%6.4"
    "g"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    MsPerVol
    ""
    RAT_FUNC
    "%6.5"
    "g/l"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Ms_O2
    ""
    RAT_FUNC
    "%6.5"
    "g"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Ms_SOx
    ""
    RAT_FUNC
    "%6.5"
    "g"

    COEFFS 0 3278.68852459016 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Ms_SOxLdTot
    ""
    RAT_FUNC
    "%6.3"
    "mg"

    COEFFS 0 2 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Ms_SOxNOx
    ""
    RAT_FUNC
    "%8.7"
    "g"

    COEFFS 0 100000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    MULTIHSS_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MULTIHSS_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MULTIHSS_SC_Compu
    ""
    TAB_VERB
    7
    0 "no_MultiHss"
    1 "one_MultiHss"
    2 "two_MultiHss"
    3 "three_MultiHss"
    4 "four_MultiHss"
    5 "five_MultiHss"
    6 "six_MultiHss"


/end COMPU_VTAB

/begin COMPU_METHOD

    M_NOxLd_LoRes
    ""
    RAT_FUNC
    "%6.4"
    "g"

    COEFFS 0 250 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    NOINIDRV_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF NOINIDRV_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    NOINIDRV_SC_Compu
    ""
    TAB_VERB
    2
    0 "IniDrv"
    1 "NoIniDrv"


/end COMPU_VTAB

/begin COMPU_METHOD
    NOREINI_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF NOREINI_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    NOREINI_SC_Compu
    ""
    TAB_VERB
    2
    0 "Reini"
    1 "NoReini"


/end COMPU_VTAB

/begin COMPU_METHOD

    nox
    ""
    RAT_FUNC
    "%6.2"
    "ppm"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    NOxFlwEG
    ""
    RAT_FUNC
    "%6.4"
    "Gram/s"

    COEFFS 0 40 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    NOxMassFlw
    ""
    RAT_FUNC
    "%6.5"
    "mg/s"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    NSCRgn_Time_S
    ""
    RAT_FUNC
    "%6.4"
    "s"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    NSC_CT_SENSORS_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF NSC_CT_SENSORS_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    NSC_CT_SENSORS_SY_Compu
    ""
    TAB_VERB
    5
    0 "ZERO"
    1 "ONE"
    2 "TWO"
    3 "THREE"
    4 "FOUR"


/end COMPU_VTAB

/begin COMPU_METHOD
    NUMCYLACT_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF NUMCYLACT_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    NUMCYLACT_SY_Compu
    ""
    TAB_VERB
    11
    1 "ONE_CLYL"
    2 "TWO_CYL"
    3 "THREE_CYL"
    4 "FOUR_CYL"
    5 "FIVE_CYL"
    6 "SIX_CYL"
    7 "SEVEN_CYL"
    8 "EIGHT_CYL"
    10 "TEN_CYL"
    12 "TWELVE_CYL"
    16 "SIXTEEN_CYL"


/end COMPU_VTAB

/begin COMPU_METHOD
    NUMCYLCAL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF NUMCYLCAL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    NUMCYLCAL_SY_Compu
    ""
    TAB_VERB
    2
    0 "FIX"
    1 "CAL"


/end COMPU_VTAB

/begin COMPU_METHOD
    NUMCYLMAX_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF NUMCYLMAX_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    NUMCYLMAX_SY_Compu
    ""
    TAB_VERB
    11
    1 "ONE_CLYL"
    2 "TWO_CYL"
    3 "THREE_CYL"
    4 "FOUR_CYL"
    5 "FIVE_CYL"
    6 "SIX_CYL"
    7 "SEVEN_CYL"
    8 "EIGHT_CYL"
    10 "TEN_CYL"
    12 "TWELVE_CYL"
    16 "SIXTEEN_CYL"


/end COMPU_VTAB

/begin COMPU_METHOD
    NUMPSICCHP_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF NUMPSICCHP_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    NUMPSICCHP_SY_Compu
    ""
    TAB_VERB
    5
    1 "1"
    2 "2"
    3 "3"
    4 "4"
    5 "5"


/end COMPU_VTAB

/begin COMPU_METHOD

    O2
    ""
    RAT_FUNC
    "%8.7"
    "-"

    COEFFS 0 100000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    OBD_PHYSMEDM_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF OBD_PHYSMEDM_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    OBD_PHYSMEDM_SY_Compu
    ""
    TAB_VERB
    2
    0 "OBD_PHYSMEDM_CAN"
    1 "OBD_PHYSMEDM_KLINE"


/end COMPU_VTAB

/begin COMPU_METHOD
    OBS_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF OBS_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    OBS_SY_Compu
    ""
    TAB_VERB
    2
    0 "NOOBS"
    1 "SMP480"


/end COMPU_VTAB

/begin COMPU_METHOD
    OCWDA_stErrSimn_C_compu_VERB
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF OCWDA_stErrSimn_C_compu_VERB
    
/end COMPU_METHOD

/begin COMPU_VTAB

    OCWDA_stErrSimn_C_compu_VERB
    ""
    TAB_VERB
    9
    0 "OCWDA_CO_SIMN_OFF"
    1 "OCWDA_CO_SIMNERRPINON"
    2 "OCWDA_CO_SIMNERRPINOFF"
    3 "OCWDA_CO_SIMNWDAACTV"
    4 "OCWDA_CO_SIMNWDAOFF"
    5 "OCWDA_CO_SIMNOVRVLTG"
    6 "OCWDA_CO_SIMNNORMVLTG"
    7 "OCWDA_CO_SIMNABEACTV"
    8 "OCWDA_CO_SIMNABEOFF"


/end COMPU_VTAB

/begin COMPU_METHOD
    OCWDA_swtOffRst_C_compu_VERB
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF OCWDA_swtOffRst_C_compu_VERB
    
/end COMPU_METHOD

/begin COMPU_VTAB

    OCWDA_swtOffRst_C_compu_VERB
    ""
    TAB_VERB
    2
    0 "OCWDA_RESET_ACTIVE"
    1 "OCWDA_RESET_INACTIVE"


/end COMPU_VTAB

/begin COMPU_METHOD
    OILCOOLRDST_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF OILCOOLRDST_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    OILCOOLRDST_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    OilMFl_mgps_q0p1
    ""
    RAT_FUNC
    "%6.3"
    "mg/s"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    OilMsPrc_q0p01
    ""
    RAT_FUNC
    "%6.4"
    "%"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    OilMs_mg
    ""
    RAT_FUNC
    "%6.2"
    "mg"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    OilMs_q0p1
    ""
    RAT_FUNC
    "%6.3"
    "g"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    OilMs_q10
    ""
    RAT_FUNC
    "%6.1"
    "g"

    COEFFS 0 0.1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    OILP_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF OILP_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    OILP_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    OILSWMPT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF OILSWMPT_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    OILSWMPT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    OILT_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF OILT_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    OILT_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    Oil_lvl_mm_q0p004
    ""
    RAT_FUNC
    "%6.4"
    "mm"

    COEFFS 0 250 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    OneToOne
    ""
    RAT_FUNC
    "%6.2"
    "-"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    OneToTenCarb
    ""
    RAT_FUNC
    "%6.1"
    "-"

    COEFFS 0 0.1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    PAIRFLTDS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF PAIRFLTDS_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    PAIRFLTDS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    PASSDOORRDNT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF PASSDOORRDNT_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    PASSDOORRDNT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    PERMSPLYSYS_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF PERMSPLYSYS_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    PERMSPLYSYS_SY_Compu
    ""
    TAB_VERB
    2
    0 "non-permanently supplied system"
    1 "permanently supplied system"


/end COMPU_VTAB

/begin COMPU_METHOD
    PEXHMNFLD_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF PEXHMNFLD_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    PEXHMNFLD_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    PFltPOpPrcPerSec_COMPU
    ""
    RAT_FUNC
    "%6.3"
    "%/s"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    PiIClb_InjMassS32
    ""
    RAT_FUNC
    "%9.8"
    "mg/hub"

    COEFFS 0 6553600 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    PINTKVUS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF PINTKVUS_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    PINTKVUS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    PmpQnt
    ""
    RAT_FUNC
    "%6.3"
    "mm^3/rev"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    POILVT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF POILVT_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    POILVT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    POSTDRV_SOFTRST_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF POSTDRV_SOFTRST_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    POSTDRV_SOFTRST_SY_Compu
    ""
    TAB_VERB
    2
    0 "false"
    1 "true"


/end COMPU_VTAB

/begin COMPU_METHOD
    POUTLVLVDS_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF POUTLVLVDS_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    POUTLVLVDS_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "FALSE"
    1 "TRUE"


/end COMPU_VTAB

/begin COMPU_METHOD
    PPFLTDIFFASICT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF PPFLTDIFFASICT_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    PPFLTDIFFASICT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    PPFLTDIFFCH1_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF PPFLTDIFFCH1_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    PPFLTDIFFCH1_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    PPFLTDIFFCH2_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF PPFLTDIFFCH2_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    PPFLTDIFFCH2_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    PPFLTDIFF_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF PPFLTDIFF_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    PPFLTDIFF_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    PPFLTDIFF_TYPTWINFLW_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF PPFLTDIFF_TYPTWINFLW_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    PPFLTDIFF_TYPTWINFLW_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    PPFLTDS_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF PPFLTDS_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    PPFLTDS_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    PPFLTUS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF PPFLTUS_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    PPFLTUS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    Prc
    ""
    RAT_FUNC
    "%6.4"
    "%"

    COEFFS 0 81.92 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    PrcPerSec_4ms
    ""
    RAT_FUNC
    "%6.2"
    "%/s"

    COEFFS 0 0.32768 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Prc_Fact100
    ""
    RAT_FUNC
    "%6.4"
    "%"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Prc_trq
    ""
    RAT_FUNC
    "%6.2"
    "%"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    PresRail_sec
    ""
    RAT_FUNC
    "%6.0"
    "hPa/s"

    COEFFS 0 0.0025 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Pres_hPa
    ""
    RAT_FUNC
    "%6.2"
    "hPa"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Pres_Rail
    ""
    RAT_FUNC
    "%6.0"
    "hPa"

    COEFFS 0 0.01 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    PRKGHEATR_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF PRKGHEATR_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    PRKGHEATR_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    PSSCP1481VAR_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF PSSCP1481VAR_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    PSSCP1481VAR_SC_Compu
    ""
    TAB_VERB
    4
    0 "None"
    1 "MD1CE100"
    2 "MD1CE101"
    3 "MD1CE108"


/end COMPU_VTAB

/begin COMPU_METHOD
    PSSC_FIATCV_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF PSSC_FIATCV_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    PSSC_FIATCV_SY_Compu
    ""
    TAB_VERB
    9
    0 "None"
    1 "P1168"
    2 "P842"
    3 "P662"
    4 "P826"
    5 "P1208"
    6 "P1096"
    7 "P1291"
    8 "P1369"


/end COMPU_VTAB

/begin COMPU_METHOD

    PS_NUMSENS_SY_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    PTACTVN_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF PTACTVN_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    PTACTVN_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    PTHRVLVDS_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF PTHRVLVDS_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    PTHRVLVDS_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    PTRBNABSLTUS_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF PTRBNABSLTUS_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    PTRBNABSLTUS_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    PTRBNDS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF PTRBNDS_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    PTRBNDS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    PTRBNUS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF PTRBNUS_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    PTRBNUS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    Pwr
    ""
    RAT_FUNC
    "%6.2"
    "W"

    COEFFS 0 0.10610329539459 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Pwr2
    ""
    RAT_FUNC
    "%6.1"
    "W"

    COEFFS 0 0.0530516476972949 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Pwr2Temp_q0p001
    ""
    RAT_FUNC
    "%6.4"
    "W/K"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Pwr2Temp_q0p1
    ""
    RAT_FUNC
    "%6.3"
    "W/K"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    PwrSq2TempSq_q0p01
    ""
    RAT_FUNC
    "%6.4"
    "W^2/K^2"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Pwr_50
    ""
    RAT_FUNC
    "%6.1"
    "W"

    COEFFS 0 1 0 0 0 50 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Pwr_kW
    ""
    RAT_FUNC
    "%6.4"
    "kW"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Pwr_q1
    ""
    RAT_FUNC
    "%6.2"
    "W"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    P_hPa_q0p078125_COMPU
    ""
    RAT_FUNC
    "%6.4"
    "hPa"

    COEFFS 0 12.8 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    p_q1_Pa
    ""
    RAT_FUNC
    "%6.2"
    "Pa"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    QCKSTRTSPCVERS_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF QCKSTRTSPCVERS_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    QCKSTRTSPCVERS_SC_Compu
    ""
    TAB_VERB
    3
    0 "SHTRP_ACTV"
    1 "QUICKSTART_INITIAL"
    2 "QUICKSTART_FULL"


/end COMPU_VTAB

/begin COMPU_METHOD

    QntR
    ""
    RAT_FUNC
    "%6.5"
    "-"

    COEFFS 0 1024 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Qp_mm3_sec
    ""
    RAT_FUNC
    "%6.1"
    "mm3/s"

    COEFFS 0 0.1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RatAirMass
    ""
    RAT_FUNC
    "%6.4"
    "-"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RatAirMassHigh
    ""
    RAT_FUNC
    "%6.5"
    "-"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RatAirPres_COMPU
    ""
    RAT_FUNC
    "%6.5"
    "-"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RatCOMass
    ""
    RAT_FUNC
    "%9.8"
    "-"

    COEFFS 0 1000000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RatHiRes_COMPU
    ""
    RAT_FUNC
    "%6.5"
    "-"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RatHiRes_CPP_COMPU
    ""
    RAT_FUNC
    "%7.6"
    "-"

    COEFFS 0 10000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    RBANDSTYPE_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF RBANDSTYPE_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    RBANDSTYPE_SC_Compu
    ""
    TAB_VERB
    4
    0 "NO_RBANDS"
    1 "ONLY_RBANDS"
    2 "MIXED_RBANDS"
    3 "MSR_RBANDS"


/end COMPU_VTAB

/begin COMPU_METHOD
    rba_SvbbEtk_SpName
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF rba_SvbbEtk_SpName
    
/end COMPU_METHOD

/begin COMPU_VTAB

    rba_SvbbEtk_SpName
    ""
    TAB_VERB
    5
    0 "Disable"
    1 "rba_Svbb_DummyActivate"
    2 "rba_SvbbEtk_Seg1Byp"
    3 "rba_SvbbEtk_T10msByp"
    4 "test_bypass_rba_Svbb_10ms_Proc"


/end COMPU_VTAB

/begin COMPU_METHOD

    rba_Svbb_Time_us
    ""
    RAT_FUNC
    "%6.4"
    ""

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    RBA_SWTRACEENA_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF RBA_SWTRACEENA_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    RBA_SWTRACEENA_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    RBPtCel_a_1p0_1
    ""
    RAT_FUNC
    "%6.2"
    "m/s^2"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RBPtCel_dst_1p0_4
    ""
    RAT_FUNC
    "%6.2"
    "km"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RBPtCel_fac_1p0_8
    ""
    RAT_FUNC
    "%6.2"
    "%/s"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RBPtCel_fPerp_1p0_1
    ""
    RAT_FUNC
    "%6.2"
    "N/Bar"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RBPtCel_frq_1p0_1
    ""
    RAT_FUNC
    "%6.2"
    "1/s"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RBPtCel_fti_1p0_1
    ""
    RAT_FUNC
    "%6.2"
    "Ns"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RBPtCel_f_1p0_1
    ""
    RAT_FUNC
    "%6.2"
    "N"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RBPtCel_i_1p0_2
    ""
    RAT_FUNC
    "%6.2"
    "A"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RBPtCel_nGrdt_1p0_1
    ""
    RAT_FUNC
    "%6.2"
    "rpm/s"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RBPtCel_n_1p0_1
    ""
    RAT_FUNC
    "%6.2"
    "rpm"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RBPtCel_Perc_1p0_1
    ""
    RAT_FUNC
    "%6.2"
    "%"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RBPtCel_p_1p0_1
    ""
    RAT_FUNC
    "%6.2"
    "hPa"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RBPtCel_p_1p0_2
    ""
    RAT_FUNC
    "%6.2"
    "Bar"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RBPtCel_ti_0p4_1
    ""
    RAT_FUNC
    "%6.3"
    "us"

    COEFFS 0 5 0 0 0 2 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RBPtCel_ti_1p0_2
    ""
    RAT_FUNC
    "%6.2"
    "s"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RBPtCel_tq_1p0_1
    ""
    RAT_FUNC
    "%6.2"
    "Nm"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RBPtCel_t_0p1om273p14_1
    ""
    RAT_FUNC
    "%6.1"
    "Deg C"

    COEFFS 0 10 2731.4 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RBPtCel_t_1p0_3
    ""
    RAT_FUNC
    "%6.2"
    "Deg C"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RBPtCel_u_1p0_1
    ""
    RAT_FUNC
    "%6.2"
    "V"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RBPtCel_vf_1p0_2
    ""
    RAT_FUNC
    "%6.2"
    "l/min"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RBPtCel_v_1p0_1
    ""
    RAT_FUNC
    "%6.2"
    "km/h"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Resist
    ""
    RAT_FUNC
    "%6.3"
    "Ohm"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Res_hPaSPerCM
    ""
    RAT_FUNC
    "%6.5"
    "hPa/(m^3*s/h)"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RhoFuel
    ""
    RAT_FUNC
    "%6.3"
    "kg/m^3"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    RHUSTGYPRS_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF RHUSTGYPRS_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    RHUSTGYPRS_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    RMTAPP_ENBL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF RMTAPP_ENBL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    RMTAPP_ENBL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    SCR_DCU17SASW_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SCR_DCU17SASW_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SCR_DCU17SASW_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    SCR_kPa_10
    ""
    RAT_FUNC
    "%6.1"
    "kPa"

    COEFFS 0 0.1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    SCR_kPa_100
    ""
    RAT_FUNC
    "%6.0"
    "kPa"

    COEFFS 0 0.01 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    SCR_SYSVRNT_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SCR_SYSVRNT_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SCR_SYSVRNT_SC_Compu
    ""
    TAB_VERB
    8
    51 "DNOX 5.1"
    52 "DNOX 5.2"
    61 "DNOX 6.1"
    62 "DNOX 6.2"
    63 "DNOX 6.3"
    65 "DNOX 6.5"
    66 "DNOX 6-HD 2.2 (evo)"
    69 "DNOX_6_9"


/end COMPU_VTAB

/begin COMPU_METHOD
    SCR_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SCR_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SCR_SY_Compu
    ""
    TAB_VERB
    4
    0 "NOSCR"
    1 "RBSCR"
    2 "INERGYSCR"
    3 "AGKSCR"


/end COMPU_VTAB

/begin COMPU_METHOD

    SCR_Volt_q0p0001227
    ""
    RAT_FUNC
    "%6.5"
    "V"

    COEFFS 0 8192 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    SCTPMP1T_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SCTPMP1T_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SCTPMP1T_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    SD_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SD_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SD_SC_Compu
    ""
    TAB_VERB
    2
    0 "INACTIVE"
    1 "ACTIVE"


/end COMPU_VTAB

/begin COMPU_METHOD
    SEAWTRP_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SEAWTRP_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SEAWTRP_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    SEAWTRT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SEAWTRT_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SEAWTRT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    SECULIBS_VAR_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SECULIBS_VAR_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SECULIBS_VAR_SY_Compu
    ""
    TAB_VERB
    3
    3 "VWW"
    5 "AUD"
    999 "ALL"


/end COMPU_VTAB

/begin COMPU_METHOD
    SECUPCK_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SECUPCK_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SECUPCK_SC_Compu
    ""
    TAB_VERB
    4
    0 "None"
    1 "SecuMgr"
    2 "EcuSecu_HSM"
    3 "EcuSecu_SSM"


/end COMPU_VTAB

/begin COMPU_METHOD
    SENTIPCORETYPE_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SENTIPCORETYPE_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SENTIPCORETYPE_SC_Compu
    ""
    TAB_VERB
    2
    0 "0"
    1 "1"


/end COMPU_VTAB

/begin COMPU_METHOD
    SENT_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SENT_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SENT_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    SETPOINTCALC_TRQBASED_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SETPOINTCALC_TRQBASED_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SETPOINTCALC_TRQBASED_SY_Compu
    ""
    TAB_VERB
    2
    0 "QUANTITY"
    1 "TORQUE"


/end COMPU_VTAB

/begin COMPU_METHOD
    SFTYHW_ETHSHTOFFPAHTESTENA_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SFTYHW_ETHSHTOFFPAHTESTENA_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SFTYHW_ETHSHTOFFPAHTESTENA_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    Signals_IntSigNumVerb
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF Signals_IntSigNumVerb
    
/end COMPU_METHOD

/begin COMPU_VTAB

    Signals_IntSigNumVerb
    ""
    TAB_VERB
    113
    0 "SIGNALS_Signals_Default"
    1 "SIGNALS_APP1_uRaw_s"
    2 "SIGNALS_BattU_u"
    3 "SIGNALS_BattU_uRaw_s"
    4 "SIGNALS_BrkP_uRaw_s"
    5 "SIGNALS_Dummy_signal"
    6 "SIGNALS_Dummy_signal_02"
    7 "SIGNALS_EngDa_tEng_s"
    8 "SIGNALS_EnvCustomer_Parameter_0"
    9 "SIGNALS_EnvCustomer_Parameter_1"
    10 "SIGNALS_EnvCustomer_Parameter_2"
    11 "SIGNALS_EnvCustomer_Parameter_3"
    12 "SIGNALS_EnvCustomer_Parameter_4"
    13 "SIGNALS_EnvCustomer_Parameter_5"
    14 "SIGNALS_EnvT_uRaw_s"
    15 "SIGNALS_EpmCrS_tiIncPer_s"
    16 "SIGNALS_Epm_nEng_s"
    17 "SIGNALS_Epm_tiSpd2Zero_s"
    18 "SIGNALS_I15031_PID13h"
    19 "SIGNALS_I15031_PID1Dh"
    20 "SIGNALS_I15031_PID65Ah"
    21 "SIGNALS_I15031_PID66Ah"
    22 "SIGNALS_I15031_PID67Ah"
    23 "SIGNALS_I15031_PID68Ah"
    24 "SIGNALS_I15031_PID69Ah"
    25 "SIGNALS_I15031_PID6AAh"
    26 "SIGNALS_I15031_PID6BAh"
    27 "SIGNALS_I15031_PID6CAh"
    28 "SIGNALS_I15031_PID6DAh"
    29 "SIGNALS_I15031_PID6EAh"
    30 "SIGNALS_I15031_PID6FAh"
    31 "SIGNALS_I15031_PID70Ah"
    32 "SIGNALS_I15031_PID71Ah"
    33 "SIGNALS_I15031_PID72Ah"
    34 "SIGNALS_I15031_PID73Ah"
    35 "SIGNALS_I15031_PID74Ah"
    36 "SIGNALS_I15031_PID75Ah"
    37 "SIGNALS_I15031_PID76Ah"
    38 "SIGNALS_I15031_PID77Ah"
    39 "SIGNALS_I15031_PID78Ah"
    40 "SIGNALS_I15031_PID79Ah"
    41 "SIGNALS_I15031_PID7AAh"
    42 "SIGNALS_I15031_PID7BAh"
    43 "SIGNALS_I15031_PID7CAh"
    44 "SIGNALS_I15031_PID7FAh"
    45 "SIGNALS_I15031_PID81Ah"
    46 "SIGNALS_I15031_PID82Ah"
    47 "SIGNALS_I15031_PID85Ah"
    48 "SIGNALS_I15031_PID86Ah"
    49 "SIGNALS_I15031_PID87Ah"
    50 "SIGNALS_I15031_PID89Ah"
    51 "SIGNALS_I15031_PID8AAh"
    52 "SIGNALS_I15031_PID8FAh"
    53 "SIGNALS_I15031_PID92Ah"
    54 "SIGNALS_I15031_PID93Ah"
    55 "SIGNALS_I15031_PID94Ah"
    56 "SIGNALS_I15031_PID97Ah"
    57 "SIGNALS_I15031_PID98Ah"
    58 "SIGNALS_I15031_PID99Ah"
    59 "SIGNALS_I15031_PID9CAh"
    60 "SIGNALS_I15031_PIDA3Ah"
    61 "SIGNALS_I15031_PIDA4Ah"
    62 "SIGNALS_I15031_PIDA5Ah"
    63 "SIGNALS_I15031_PIDA9Ah"
    64 "SIGNALS_I15031_PIDACAh"
    65 "SIGNALS_OilP_p_s"
    66 "SIGNALS_PID01h"
    67 "SIGNALS_PID1Ch"
    68 "SIGNALS_PID21h"
    69 "SIGNALS_PID30h"
