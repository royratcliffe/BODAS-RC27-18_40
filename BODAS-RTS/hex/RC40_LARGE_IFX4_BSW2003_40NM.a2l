    70 "SIGNALS_PID31h"
    71 "SIGNALS_PID4FAh"
    72 "SIGNALS_PID4FBh"
    73 "SIGNALS_PID4FCh"
    74 "SIGNALS_PID4FDh"
    75 "SIGNALS_PID50Ah"
    76 "SIGNALS_PID50Bh"
    77 "SIGNALS_PID50Ch"
    78 "SIGNALS_PID50Dh"
    79 "SIGNALS_PID5Fh"
    80 "SIGNALS_PID8BAh"
    81 "SIGNALS_PID8CAh"
    82 "SIGNALS_PID9AAh"
    83 "SIGNALS_PID9FAh"
    84 "SIGNALS_PID_FILLSIG_1BIT"
    85 "SIGNALS_PID_FILLSIG_1BITNZ"
    86 "SIGNALS_PID_FILLSIG_1BYTE"
    87 "SIGNALS_PID_FILLSIG_1BYTENZ"
    88 "SIGNALS_PID_FILLSIG_2BIT"
    89 "SIGNALS_PID_FILLSIG_2BITNZ"
    90 "SIGNALS_PID_FILLSIG_2BYTE"
    91 "SIGNALS_PID_FILLSIG_2BYTENZ"
    92 "SIGNALS_PID_FILLSIG_3BIT"
    93 "SIGNALS_PID_FILLSIG_3BITNZ"
    94 "SIGNALS_PID_FILLSIG_4BIT"
    95 "SIGNALS_PID_FILLSIG_4BITNZ"
    96 "SIGNALS_PID_FILLSIG_4BYTE"
    97 "SIGNALS_PID_FILLSIG_4BYTENZ"
    98 "SIGNALS_PID_FILLSIG_5BIT"
    99 "SIGNALS_PID_FILLSIG_5BITNZ"
    100 "SIGNALS_PID_FILLSIG_6BIT"
    101 "SIGNALS_PID_FILLSIG_6BITNZ"
    102 "SIGNALS_PID_FILLSIG_7BIT"
    103 "SIGNALS_PID_FILLSIG_7BITNZ"
    104 "SIGNALS_SyC_tiDrv_s"
    105 "SIGNALS_TECU_t_s"
    106 "SIGNALS_ExtFloat_SyC_tiDrv_l_s"
    107 "SIGNALS_PID83h_A_BitCombineSignal"
    108 "SIGNALS_PID9Bh_A_BitCombineSignal"
    109 "SIGNALS_PIDA1h_A_BitCombineSignal"
    110 "SIGNALS_PIDA7h_A_BitCombineSignal"
    111 "SIGNALS_PIDA8h_A_BitCombineSignal"
    112 "SIGNALS_Virtual_bitfield_1003"


/end COMPU_VTAB

/begin COMPU_METHOD
    SIGNALS_OBDDIDSUPRT_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SIGNALS_OBDDIDSUPRT_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SIGNALS_OBDDIDSUPRT_SC_Compu
    ""
    TAB_VERB
    2
    0 "Disabled"
    1 "Enabled"


/end COMPU_VTAB

/begin COMPU_METHOD

    Signals_OneToOne
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    SigQly_COMPU_VERB
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SigQly_COMPU_VERB
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SigQly_COMPU_VERB
    ""
    TAB_VERB
    16
    0 "SIGQLY_NOTCALC"
    1 "SIGQLY_INIT"
    2 "SIGQLY_OK"
    3 "SIGQLY_MODEL"
    4 "SIGQLY_REPLACEMENT"
    5 "SIGQLY_FROZEN"
    6 "SIGQLY_INVALID"
    7 "SIGQLY_RESERVED_7"
    8 "SIGQLY_RESERVED_8"
    9 "SIGQLY_RESERVED_9"
    10 "SIGQLY_RESERVED_10"
    11 "SIGQLY_RESERVED_11"
    12 "SIGQLY_RESERVED_12"
    13 "SIGQLY_RESERVED_13"
    14 "SIGQLY_RESERVED_14"
    15 "SIGQLY_RESERVED_15"


/end COMPU_VTAB

/begin COMPU_METHOD

    Sig_I15031_LeanAppl_SY_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    SotMassPerSec
    ""
    RAT_FUNC
    "%6.3"
    "g/s"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    SpaVel
    ""
    RAT_FUNC
    "%6.1"
    "l/h"

    COEFFS 0 0.1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    SpecificHeat
    ""
    RAT_FUNC
    "%7.6"
    "J/g/K"

    COEFFS 0 10000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    spg_q0p00488
    ""
    RAT_FUNC
    "%6.4"
    "V"

    COEFFS 0 1024 0 0 0 5 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    spg_uw_q0p00488
    ""
    RAT_FUNC
    "%6.4"
    "V"

    COEFFS 0 1024 0 0 0 5 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    spg_uw_q0p00488_o1
    ""
    RAT_FUNC
    "%6.3"
    "V"

    COEFFS 0 1024 1024 0 0 5 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    STOPLMP_ATSINTVMOD_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF STOPLMP_ATSINTVMOD_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    STOPLMP_ATSINTVMOD_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    STOPLMP_PSPRS_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF STOPLMP_PSPRS_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    STOPLMP_PSPRS_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    STOPLMP_REDSTOPLAMPENA_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF STOPLMP_REDSTOPLAMPENA_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    STOPLMP_REDSTOPLAMPENA_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    STSP_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF STSP_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    STSP_SY_Compu
    ""
    TAB_VERB
    2
    0 "FALSE"
    1 "TRUE"


/end COMPU_VTAB

/begin COMPU_METHOD
    SVS_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SVS_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SVS_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    SYC_AFTRUNDIAG_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SYC_AFTRUNDIAG_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SYC_AFTRUNDIAG_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    SYC_CAL_PERMSPLYSYS_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SYC_CAL_PERMSPLYSYS_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SYC_CAL_PERMSPLYSYS_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    SYC_CNTPOSTDRV_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SYC_CNTPOSTDRV_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SYC_CNTPOSTDRV_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    SYC_COORD_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SYC_COORD_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SYC_COORD_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    SYC_ENALCYPROLG_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SYC_ENALCYPROLG_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SYC_ENALCYPROLG_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    SYC_FSTSWOFF_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SYC_FSTSWOFF_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SYC_FSTSWOFF_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    SyC_PostDrv_State
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SyC_PostDrv_State
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SyC_PostDrv_State
    ""
    TAB_VERB
    9
    0 "SYC_POSTDRV_INACTV"
    1 "SYC_POSTDRV_DSM_BGN"
    2 "SYC_POSTDRV_EEP_BGN"
    3 "SYC_POSTDRV_WAIT"
    4 "SYC_POSTDRV_NWM"
    5 "SYC_POSTDRV_DSM_END"
    6 "SYC_POSTDRV_EEP_END"
    7 "SYC_POSTDRV_MIN_TIME"
    8 "SYC_POSTDRV_DONE"


/end COMPU_VTAB

/begin COMPU_METHOD
    SyC_PreDrv_State
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SyC_PreDrv_State
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SyC_PreDrv_State
    ""
    TAB_VERB
    10
    0 "SYC_PREDRV_INI_DRV"
    1 "SYC_PREDRV_DONE"
    2 "SYC_PREDRV_INI_SHDWN"
    3 "SYC_PREDRV_PROLONG"
    4 "SYC_PREDRV_NWM"
    5 "SYC_PREDRV_EEP"
    6 "SYC_PREDRV_DSM"
    7 "SYC_PREDRV_MR"
    8 "SYC_PREDRV_MOM"
    9 "SYC_PREDRV_EXIT"


/end COMPU_VTAB

/begin COMPU_METHOD
    SYC_PROLGPREDRV_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SYC_PROLGPREDRV_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SYC_PROLGPREDRV_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    SYC_SYSTYP_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SYC_SYSTYP_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SYC_SYSTYP_SC_Compu
    ""
    TAB_VERB
    2
    0 "SysB"
    1 "EcuCtrl"


/end COMPU_VTAB

/begin COMPU_METHOD
    SYC_T15POSTPREDRV_SWRST_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SYC_T15POSTPREDRV_SWRST_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SYC_T15POSTPREDRV_SWRST_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    SYSA_DSQACTVT_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SYSA_DSQACTVT_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SYSA_DSQACTVT_SC_Compu
    ""
    TAB_VERB
    2
    0 "Inactive"
    1 "Active"


/end COMPU_VTAB

/begin COMPU_METHOD
    SYSB_PHYTERMINAL15_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SYSB_PHYTERMINAL15_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SYSB_PHYTERMINAL15_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    SYSDIAG_NRAFTRUNCOORRARRELEM_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    SY_ATMTURB_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SY_ATMTURB_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SY_ATMTURB_Compu
    ""
    TAB_VERB
    2
    0 "ATMTURB_NOPRES"
    1 "ATMTURB_PRES"


/end COMPU_VTAB

/begin COMPU_METHOD
    SY_CNG_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SY_CNG_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SY_CNG_Compu
    ""
    TAB_VERB
    6
    0 "Kein System mit CNG"
    1 "System mit CNG"
    2 "System mit CNG und EOBD"
    3 "System mit CNG Fehlerpfade ASV1...5"
    4 "System mit CNG Plattform"
    5 "System with customer options on CNG platform"


/end COMPU_VTAB

/begin COMPU_METHOD
    SY_DLDP_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SY_DLDP_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SY_DLDP_Compu
    ""
    TAB_VERB
    2
    0 "kein DLDP System"
    1 "DLDP System"


/end COMPU_VTAB

/begin COMPU_METHOD

    SY_DMDSTQ_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    SY_DMTL_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SY_DMTL_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SY_DMTL_Compu
    ""
    TAB_VERB
    2
    0 "DMTL nicht vorhanden"
    1 "DMTL vorhanden"


/end COMPU_VTAB

/begin COMPU_METHOD
    SY_DSPACE_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SY_DSPACE_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SY_DSPACE_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    SY_HEV_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SY_HEV_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SY_HEV_Compu
    ""
    TAB_VERB
    8
    0 "0"
    1 "HEVTYP_SER"
    2 "HEVTYP_SERPARL"
    3 "HEVTYP_PWRSPLT"
    4 "HEVTYP_PARL"
    5 "HEVTYP_EAD"
    6 "HEVTYP_EDCT"
    7 "HEVTYP_PARLSER"


/end COMPU_VTAB

/begin COMPU_METHOD

    SY_KORRZ_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    SY_KT_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    SY_LAYER_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SY_LAYER_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SY_LAYER_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    SY_MDMXEXC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SY_MDMXEXC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SY_MDMXEXC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    SY_NVLD_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SY_NVLD_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SY_NVLD_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    SY_PTL_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SY_PTL_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SY_PTL_Compu
    ""
    TAB_VERB
    2
    0 "relative inner moment"
    1 "Physical Torque Levels"


/end COMPU_VTAB

/begin COMPU_METHOD
    SY_PTO_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SY_PTO_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SY_PTO_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    SY_SGANZ_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SY_SGANZ_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SY_SGANZ_Compu
    ""
    TAB_VERB
    3
    1 "Ein Steuergeräte Motormanagement Konzept"
    2 "Zwei Steuergeräte Motormanagement Konzept"
    3 "Drei Steuergeräte Motormanagement Konzept"


/end COMPU_VTAB

/begin COMPU_METHOD
    SY_SVBB_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SY_SVBB_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SY_SVBB_Compu
    ""
    TAB_VERB
    2
    0 "NOSVBB"
    1 "SVBBETAS"


/end COMPU_VTAB

/begin COMPU_METHOD
    SY_TEETH_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SY_TEETH_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SY_TEETH_Compu
    ""
    TAB_VERB
    2
    36 "number of crankshaft wheel teeth is 36 minus x"
    60 "number of crankshaft wheel teeth is 60 minus x"


/end COMPU_VTAB

/begin COMPU_METHOD

    SY_UBSQ_W_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    SY_WFS_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    SY_WNBM_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    SY_ZYLZA_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SY_ZYLZA_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SY_ZYLZA_Compu
    ""
    TAB_VERB
    11
    1 "1"
    2 "2"
    3 "3"
    4 "4"
    5 "5"
    6 "6"
    8 "8"
    10 "10"
    12 "12"
    16 "16"
    18 "18"


/end COMPU_VTAB

/begin COMPU_METHOD

    SY_ZYLZG_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    T15RAWDSQENA_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF T15RAWDSQENA_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    T15RAWDSQENA_SC_Compu
    ""
    TAB_VERB
    2
    0 "Disabled"
    1 "Enabled"


/end COMPU_VTAB

/begin COMPU_METHOD
    T15_WKDETN_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF T15_WKDETN_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    T15_WKDETN_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    TBLOWBYHEATR_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TBLOWBYHEATR_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TBLOWBYHEATR_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    TDC_ADAP_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TDC_ADAP_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TDC_ADAP_SY_Compu
    ""
    TAB_VERB
    4
    0 "NO_TDC_ADAP"
    1 "TDC_ADAP"
    2 "TDC_ADAP_CPP"
    3 "STAT_TDC_ADAP"


/end COMPU_VTAB

/begin COMPU_METHOD
    TDC_UNEQLGEOM_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TDC_UNEQLGEOM_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TDC_UNEQLGEOM_SY_Compu
    ""
    TAB_VERB
    2
    0 "EQL_TDC"
    1 "UNEQL_TDC"


/end COMPU_VTAB

/begin COMPU_METHOD
    TECU_SMP480SENSPRS_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TECU_SMP480SENSPRS_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TECU_SMP480SENSPRS_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    TECU_TMSGFMT_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TECU_TMSGFMT_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TECU_TMSGFMT_SC_Compu
    ""
    TAB_VERB
    2
    1 "MSG"
    2 "MSG_ARRAY"


/end COMPU_VTAB

/begin COMPU_METHOD
    TEGRCLR2DS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TEGRCLR2DS_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TEGRCLR2DS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "0"
    1 "1"


/end COMPU_VTAB

/begin COMPU_METHOD
    TEGRCLRDS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TEGRCLRDS_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TEGRCLRDS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    TEGRCLRLPDS_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TEGRCLRLPDS_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TEGRCLRLPDS_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    TEGRCLRUS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TEGRCLRUS_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TEGRCLRUS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    TEGRVLVHOTDS_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TEGRVLVHOTDS_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TEGRVLVHOTDS_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    TempC_float
    ""
    RAT_FUNC
    "%6.1"
    "deg C"

    COEFFS 0 1 273.14 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    TempDiff_1Deg
    ""
    RAT_FUNC
    "%6.2"
    "deg C"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    TempDiff_Kelv
    ""
    RAT_FUNC
    "%6.3"
    "K"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    TempK_float
    ""
    RAT_FUNC
    "%6.2"
    "K"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Temp_Cels
    ""
    RAT_FUNC
    "%6.1"
    "deg C"

    COEFFS 0 10 2731.4 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    THRVLVI_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF THRVLVI_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    THRVLVI_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    THRVLVUST_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF THRVLVUST_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    THRVLVUST_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    TimeDelay_s_2
    ""
    RAT_FUNC
    "%13.6"
    "s"

    COEFFS 0 0 1 0 0.0596046447753906 0 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    TimeDT
    ""
    RAT_FUNC
    "%6.2"
    "us"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    TimeEngOn
    ""
    RAT_FUNC
    "%6.2"
    "s"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Time_ms
    ""
    RAT_FUNC
    "%6.1"
    "ms"

    COEFFS 0 0.1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Time_msec_q10_COMPU
    ""
    RAT_FUNC
    "%6.1"
    "ms"

    COEFFS 0 1 0 0 0 10 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Time_msec_q1_COMPU
    ""
    RAT_FUNC
    "%6.2"
    "ms"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Time_s
    ""
    RAT_FUNC
    "%6.4"
    "s"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Time_sec_q1_COMPU
    ""
    RAT_FUNC
    "%6.2"
    "s"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Time_s_LoRes
    ""
    RAT_FUNC
    "%6.2"
    "s"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Time_usec_q1_COMPU
    ""
    RAT_FUNC
    "%6.2"
    "us"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    TINTKVUS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TINTKVUS_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TINTKVUS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    TLE7244_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TLE7244_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TLE7244_SC_Compu
    ""
    TAB_VERB
    3
    0 "No_TLE7244"
    1 "One_TLE7244"
    2 "Two_TLE7244"


/end COMPU_VTAB

/begin COMPU_METHOD
    TLE75602_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TLE75602_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TLE75602_SC_Compu
    ""
    TAB_VERB
    4
    0 "no Tle75602"
    1 "one Tle75602"
    2 "two Tle75602"
    3 "three Tle75602"


/end COMPU_VTAB

/begin COMPU_METHOD
    TOTENGREV_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TOTENGREV_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TOTENGREV_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    TOXDCAT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TOXDCAT_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TOXDCAT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    TOXICATDS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TOXICATDS_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TOXICATDS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    TOXICATUS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TOXICATUS_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TOXICATUS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    TPFLTDS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TPFLTDS_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TPFLTDS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    TPFLTUS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TPFLTUS_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TPFLTUS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    TPS65917_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TPS65917_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TPS65917_SC_Compu
    ""
    TAB_VERB
    2
    0 "no_device"
    1 "one_device"


/end COMPU_VTAB

/begin COMPU_METHOD
    TRBCHINSDT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TRBCHINSDT_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TRBCHINSDT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    TRBHP2I_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TRBHP2I_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TRBHP2I_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    TRBHPBYPI_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TRBHPBYPI_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TRBHPBYPI_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    TRBHPI_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TRBHPI_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TRBHPI_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    TRBLPI_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TRBLPI_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TRBLPI_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    TRBNBYVLV1INSDT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TRBNBYVLV1INSDT_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TRBNBYVLV1INSDT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    TRBNBYVLV2INSDT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TRBNBYVLV2INSDT_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TRBNBYVLV2INSDT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    Trq
    ""
    RAT_FUNC
    "%6.3"
    "Nm"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Trq_PrcHi
    ""
    RAT_FUNC
    "%6.3"
    ""

    COEFFS 0 8 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    TTRBNUS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TTRBNUS_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TTRBNUS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    TTRBUSASICT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TTRBUSASICT_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TTRBUSASICT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    TWALLTC_MDLAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TWALLTC_MDLAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TWALLTC_MDLAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    TWCOR_HIRES_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TWCOR_HIRES_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TWCOR_HIRES_SC_Compu
    ""
    TAB_VERB
    2
    0 "RES_S8"
    1 "RES_S16"


/end COMPU_VTAB

/begin COMPU_METHOD
    TWTRCOOLRDS_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TWTRCOOLRDS_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TWTRCOOLRDS_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    t_q0p1
    ""
    RAT_FUNC
    "%6.3"
    "s"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    UART_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF UART_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    UART_SY_Compu
    ""
    TAB_VERB
    2
    0 "UART not used"
    1 "UART used"


/end COMPU_VTAB

/begin COMPU_METHOD
    UCATDST2_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF UCATDST2_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    UCATDST2_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    UCATDST_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF UCATDST_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    UCATDST_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    UCATUST2_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF UCATUST2_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    UCATUST2_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    UCATUST_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF UCATUST_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    UCATUST_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    UDPNM_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF UDPNM_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    UDPNM_SC_Compu
    ""
    TAB_VERB
    2
    0 "INACTIVE"
    1 "ACTIVE"


/end COMPU_VTAB

/begin COMPU_METHOD
    VCRTYP_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF VCRTYP_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    VCRTYP_SC_Compu
    ""
    TAB_VERB
    2
    0 "Fixed"
    1 "Continuous"


/end COMPU_VTAB

/begin COMPU_METHOD
    VEHTYP_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF VEHTYP_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    VEHTYP_SC_Compu
    ""
    TAB_VERB
    2
    1 "Two_Wheeler"
    2 "Four_Wheeler"


/end COMPU_VTAB

/begin COMPU_METHOD

    Vel
    ""
    RAT_FUNC
    "%6.4"
    "km/h"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    VIRTETH_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF VIRTETH_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    VIRTETH_SC_Compu
    ""
    TAB_VERB
    2
    0 "NO_VIRTETH"
    1 "VIRTETH_USED"


/end COMPU_VTAB

/begin COMPU_METHOD
    VLVLFTI_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF VLVLFTI_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    VLVLFTI_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    VNQ6040_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF VNQ6040_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    VNQ6040_SC_Compu
    ""
    TAB_VERB
    4
    0 "NoneASIC"
    1 "OneASIC"
    2 "TwoASICs"
    3 "ThreeASICs"


/end COMPU_VTAB

/begin COMPU_METHOD

    Vol1
    ""
    RAT_FUNC
    "%9.8"
    "l"

    COEFFS 0 3600000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    volFilgLvl_ml
    ""
    RAT_FUNC
    "%6.2"
    "ml"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Volt
    ""
    RAT_FUNC
    "%6.3"
    "mV"

    COEFFS 0 5 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Volt_Batt
    ""
    RAT_FUNC
    "%6.1"
    "mV"

    COEFFS 0 0.05 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Vol_NSC
    ""
    RAT_FUNC
    "%7.6"
    "L"

    COEFFS 0 10000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    VSWVLVI_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF VSWVLVI_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    VSWVLVI_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    WDGS_CFGADPR_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF WDGS_CFGADPR_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    WDGS_CFGADPR_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    WHRCOOLTPDIF_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF WHRCOOLTPDIF_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    WHRCOOLTPDIF_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    WRNLMP_AMBERWARNLAMPENA_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF WRNLMP_AMBERWARNLAMPENA_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    WRNLMP_AMBERWARNLAMPENA_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    WRNLMP_ATSINTVMOD_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF WRNLMP_ATSINTVMOD_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    WRNLMP_ATSINTVMOD_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    WRNLMP_PSPRS_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF WRNLMP_PSPRS_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    WRNLMP_PSPRS_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    WTRCACT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF WTRCACT_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    WTRCACT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    WTRCOOLTP1_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF WTRCOOLTP1_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    WTRCOOLTP1_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    WTRCOOLTP_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF WTRCOOLTP_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    WTRCOOLTP_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    XCORECDD_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF XCORECDD_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    XCORECDD_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    XCPVERS_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF XCPVERS_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    XCPVERS_SC_Compu
    ""
    TAB_VERB
    3
    1 "XCP_1_0"
    2 "XCP_1_1"
    3 "XCP_1_2"


/end COMPU_VTAB

/begin COMPU_METHOD
    XCP_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF XCP_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    XCP_SY_Compu
    ""
    TAB_VERB
    2
    0 "No XCP"
    1 "XCP"


/end COMPU_VTAB

/begin COMPU_METHOD
    XDI_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF XDI_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    XDI_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    default
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    defaultAscii
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD



/***********   Start of merged RECORD_LAYOUT blocks    ***********/


/begin RECORD_LAYOUT    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_boolean
    FNC_VALUES        1 UBYTE COLUMN_DIR DIRECT
    STATIC_ADDRESS_OFFSETS

/end RECORD_LAYOUT


/begin RECORD_LAYOUT    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint16
    FNC_VALUES        1 UWORD COLUMN_DIR DIRECT
    STATIC_ADDRESS_OFFSETS

/end RECORD_LAYOUT


/begin RECORD_LAYOUT    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint8
    FNC_VALUES        1 UBYTE COLUMN_DIR DIRECT
    STATIC_ADDRESS_OFFSETS

/end RECORD_LAYOUT


/begin RECORD_LAYOUT    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint32
    FNC_VALUES        1 ULONG COLUMN_DIR DIRECT
    STATIC_ADDRESS_OFFSETS

/end RECORD_LAYOUT

/***********   End of merged RECORD_LAYOUT blocks    ***********/
/begin RECORD_LAYOUT KwbUb

    FNC_VALUES        1 UBYTE COLUMN_DIR DIRECT

/end RECORD_LAYOUT

/begin RECORD_LAYOUT KwUb

    FNC_VALUES        1 UBYTE COLUMN_DIR DIRECT

/end RECORD_LAYOUT

/begin RECORD_LAYOUT KwWU16

    FNC_VALUES        1 UWORD COLUMN_DIR DIRECT

/end RECORD_LAYOUT

/begin RECORD_LAYOUT KwWU8

    FNC_VALUES        1 UBYTE COLUMN_DIR DIRECT

/end RECORD_LAYOUT

/begin RECORD_LAYOUT Kw_Ws16

    FNC_VALUES        1 SWORD COLUMN_DIR DIRECT

/end RECORD_LAYOUT

/begin RECORD_LAYOUT RB_Val_Ws16

    FNC_VALUES        1 SWORD COLUMN_DIR DIRECT

/end RECORD_LAYOUT

/begin RECORD_LAYOUT RB_Val_Wu16

    FNC_VALUES        1 UWORD COLUMN_DIR DIRECT

/end RECORD_LAYOUT

/begin RECORD_LAYOUT RB_Val_Wu8

    FNC_VALUES        1 UBYTE COLUMN_DIR DIRECT

/end RECORD_LAYOUT

/begin RECORD_LAYOUT ValA_Wu16

    FNC_VALUES        1 UWORD COLUMN_DIR DIRECT

/end RECORD_LAYOUT

/begin RECORD_LAYOUT ValA_Wu32

    FNC_VALUES        1 ULONG COLUMN_DIR DIRECT

/end RECORD_LAYOUT

/begin RECORD_LAYOUT ValA_Wu8

    FNC_VALUES        1 UBYTE COLUMN_DIR DIRECT

/end RECORD_LAYOUT

/begin RECORD_LAYOUT Val_Ws16

    FNC_VALUES        1 SWORD COLUMN_DIR DIRECT

/end RECORD_LAYOUT

/begin RECORD_LAYOUT Val_Ws32

    FNC_VALUES        1 SLONG COLUMN_DIR DIRECT

/end RECORD_LAYOUT

/begin RECORD_LAYOUT Val_Wu16

    FNC_VALUES        1 UWORD COLUMN_DIR DIRECT

/end RECORD_LAYOUT

/begin RECORD_LAYOUT Val_Wu32

    FNC_VALUES        1 ULONG COLUMN_DIR DIRECT

/end RECORD_LAYOUT

/begin RECORD_LAYOUT Val_Wu8

    FNC_VALUES        1 UBYTE COLUMN_DIR DIRECT

/end RECORD_LAYOUT

  

/***********   Start of merged UNIT blocks    ***********/

/begin UNIT

    RB_RBA_Common_CentralElements_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_CanIf_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_CanSM_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_Com_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_ComM_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_EthSM_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_LinIf_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_LinSM_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_PduR_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_TcpIp_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    Mcan_Can_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_BypDrv_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_CalWup_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_Etks_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_IoDiagHlfBr_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_IoSigHlfBr_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_MRly_Units_NoUnit
    "No Unit"
    "nounit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_MRly_Units_ms
    "Millisecond"
    "ms"
    EXTENDED_SI
    SI_EXPONENTS 0 0 1 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_OsShell_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_OsMeasmt_Units_Perc
    "Percent"
    "%"
    EXTENDED_SI

/end UNIT

/begin UNIT

    RB_RBA_rba_OsMeasmt_Units_MicroSec
    "Micro Second"
    "us"
    EXTENDED_SI

/end UNIT

/begin UNIT

    RB_RBA_rba_OsShell_Units_MicroSec
    "Micro Second"
    "us"
    EXTENDED_SI

/end UNIT

/begin UNIT

    RB_RBA_rba_OsMeasmt_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_OsShell_Units_Perc
    "Percent"
    "%"
    EXTENDED_SI

/end UNIT

/begin UNIT

    RB_RBA_rba_Reset_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_Runtime_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_Runtime_Units_MicroSec
    "Micro Second"
    "us"
    EXTENDED_SI
    SI_EXPONENTS 0 0 1 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_Runtime_Units_Perc
    "Percent"
    "%"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_SvbbDrv_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_SvbbEtk_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_SyC_States_Units_rba_SyC_States_NoUnit
    "No Unit"
    "nounit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_SyC_States_Units_rba_SyC_States_1second
    "Seconds"
    "s"
    EXTENDED_SI
    SI_EXPONENTS 0 0 1 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_T15_Units_NoUnit
    "No Unit"
    "nounit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_T15_Units_ms
    "Millisecond"
    "ms"
    EXTENDED_SI
    SI_EXPONENTS 0 0 1 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_AISpecification_Units_Rpm
    "Rpm"
    "rpm"
    EXTENDED_SI
    SI_EXPONENTS 0 0 -1 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_CanNm_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_CanTrcv_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_Eth_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_EthIf_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_EthTrcv_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_Fee_Units_Fee_NoUnit
    "Fee No Unit"
    "Fee_NoUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_IpduM_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_Lin_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_LinTrcv_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_Nm_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_NvM_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_AISpecification_Units_Bar
    "Bar"
    "bar"
    EXTENDED_SI
    SI_EXPONENTS -1 1 -2 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_AISpecification_Units_DegCgrd
    "Degree Centigrade"
    "degC"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 1 0 0

/end UNIT

/begin UNIT

    AUTOSAR_AISpecification_Units_HectoPa
    "Hecto Pascal"
    "hPa"
    EXTENDED_SI
    SI_EXPONENTS -1 1 -2 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_AISpecification_Units_Hz
    "Hertz"
    "Hz"
    EXTENDED_SI
    SI_EXPONENTS 0 0 -1 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_AISpecification_Units_Kelvin
    "Kelvin"
    "K"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 1 0 0

/end UNIT

/begin UNIT

    AUTOSAR_AISpecification_Units_KiloGr
    "Kilo Gram"
    "kg"
    EXTENDED_SI
    SI_EXPONENTS 0 1 0 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_AISpecification_Units_KiloHz
    "Kilo Hertz"
    "kHz"
    EXTENDED_SI
    SI_EXPONENTS 0 0 -1 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_AISpecification_Units_KiloMtr
    "Kilo Meter"
    "km"
    EXTENDED_SI
    SI_EXPONENTS 1 0 0 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_AISpecification_Units_Mtr
    "Meter"
    "m"
    EXTENDED_SI
    SI_EXPONENTS 1 0 0 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_AISpecification_Units_MtrPerSec
    "Meter per Second"
    "m/s"
    EXTENDED_SI
    SI_EXPONENTS 1 0 -1 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_AISpecification_Units_MtrPerSecCubd
    "Meter per Second Cubed"
    "m/s^3"
    EXTENDED_SI
    SI_EXPONENTS 1 0 -3 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_AISpecification_Units_MtrPerSecSqd
    "Meter per Second Squared"
    "m/s^2"
    EXTENDED_SI
    SI_EXPONENTS 1 0 -2 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_AISpecification_Units_MtrRecpr
    "Meter Reciprocal"
    "1/m"
    EXTENDED_SI
    SI_EXPONENTS -1 0 0 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_AISpecification_Units_NoUnit
    "No Unit"
    "-"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_AISpecification_Units_Nwt
    "Newton"
    "N"
    EXTENDED_SI
    SI_EXPONENTS 1 1 -2 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_AISpecification_Units_NwtMtr
    "Newton Meter"
    "Nm"
    EXTENDED_SI
    SI_EXPONENTS 2 1 -2 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_AISpecification_Units_NwtMtrPerSec
    "Newton Meter per Second"
    "Nm/s"
    EXTENDED_SI
    SI_EXPONENTS 2 1 -3 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_AISpecification_Units_NwtPerMtr
    "Newton per Meter"
    "N/m"
    EXTENDED_SI
    SI_EXPONENTS 0 1 -2 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_AISpecification_Units_NwtSecPerMtr
    "Newton Second per Meter"
    "Ns/m"
    EXTENDED_SI
    SI_EXPONENTS 0 1 -1 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_AISpecification_Units_Pa
    "Pascal"
    "Pa"
    EXTENDED_SI
    SI_EXPONENTS -1 1 -2 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_AISpecification_Units_Perc
    "Percent"
    "%"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_AISpecification_Units_PercPerSec
    "Percent per Second"
    "%/s"
    EXTENDED_SI
    SI_EXPONENTS 0 0 -1 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_AISpecification_Units_Rad
    "Radian"
    "rad"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_AISpecification_Units_RadPerSec
    "Radian per Second"
    "rad/s"
    EXTENDED_SI
    SI_EXPONENTS 0 0 -1 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_AISpecification_Units_RadPerSecSqd
    "Radian per Second Squared"
    "rad/s^2"
    EXTENDED_SI
    SI_EXPONENTS 0 0 -2 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_AISpecification_Units_RpmPerSec
    "Revolutions per minute per Second"
    "rpm/s"
    EXTENDED_SI
    SI_EXPONENTS 0 0 -2 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_AISpecification_Units_Sec
    "Second"
    "s"
    EXTENDED_SI
    SI_EXPONENTS 0 0 1 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_AISpecification_Units_Volt
    "Volt"
    "V"
    EXTENDED_SI
    SI_EXPONENTS 2 1 -3 -1 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_BypEtk_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_BypInt_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_BypXcp_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_ComScl_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_Dme_Units_NoUnit
    ""
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_FrOsSync_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_IoDiagHbr_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_IoDiagPs_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_IoDiagPwr_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_IoExtCy326_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_IoExtDipo_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_IoExtLib_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_IoSigAdc_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_IoSigDio_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_IoSigFsc_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_IoSigHbr_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_IoSigIcu_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_IoSigObs_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_IoSigPwm_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_IoSigPwm_Units_MicroSeconds
    ""
    "us"
    EXTENDED_SI

/end UNIT

/begin UNIT

    RB_RBA_rba_IoSigPwr_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_IoSigRtc_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_LtcySpy_Units_MicroSec
    "Micro Second"
    "us"
    EXTENDED_SI

/end UNIT

/begin UNIT

    RB_RBA_rba_LtcySpy_Units_MilliSec
    "Milli Second"
    "ms"
    EXTENDED_SI

/end UNIT

/begin UNIT

    RB_RBA_rba_LtcySpy_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_MRly_Units_mV
    "Millivolt"
    "mV"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_SentIf_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_Svbb_Units_MicroSec
    "Micro Second"
    "us"
    EXTENDED_SI

/end UNIT

/begin UNIT

    RB_RBA_rba_SvbbXcp_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_SyC_Units_rba_SyC_1millisecond
    "Milliseconds"
    "ms"
    EXTENDED_SI

/end UNIT

/begin UNIT

    RB_RBA_rba_SyC_Units_rba_SyC_10millisecond
    "10 Milliseconds"
    "ms"
    EXTENDED_SI

/end UNIT

/begin UNIT

    RB_RBA_rba_SyC_Units_NoUnit
    "No Unit"
    "nounit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_SyC_Units_rba_SyC_100millisecond
    "100 Milliseconds"
    "ms"
    EXTENDED_SI

/end UNIT

/begin UNIT

    RB_RBA_rba_SyC_Units_rba_SyC_1second
    "Seconds"
    "s"
    EXTENDED_SI

/end UNIT

/begin UNIT

    RB_RBA_rba_SyC_Rtc_Units_rba_SyC_Rtc_1millisecond
    "Milliseconds"
    "ms"
    EXTENDED_SI

/end UNIT

/begin UNIT

    RB_RBA_rba_SyC_Rtc_Units_rba_SyC_Rtc_10millisecond
    "10 Milliseconds"
    "ms"
    EXTENDED_SI

/end UNIT

/begin UNIT

    RB_RBA_rba_SyC_Rtc_Units_NoUnit
    "No Unit"
    "nounit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_SyC_Rtc_Units_rba_SyC_Rtc_100millisecond
    "100 Milliseconds"
    "ms"
    EXTENDED_SI

/end UNIT

/begin UNIT

    RB_RBA_rba_SyC_Rtc_Units_rba_SyC_Rtc_1second
    "Seconds"
    "s"
    EXTENDED_SI

/end UNIT

/begin UNIT

    RB_RBA_rba_SyC_States_Units_rba_SyC_States_1millisecond
    "Milliseconds"
    "ms"
    EXTENDED_SI
    SI_EXPONENTS 0 0 1 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_SyC_States_Units_rba_SyC_States_10millisecond
    "10 Milliseconds"
    "ms"
    EXTENDED_SI
    SI_EXPONENTS 0 0 1 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_SyC_States_Units_rba_SyC_States_100millisecond
    "100 Milliseconds"
    "ms"
    EXTENDED_SI
    SI_EXPONENTS 0 0 1 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_SoAd_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_Xcp_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/***********   End of merged UNIT blocks    ***********/
/end MODULE
/end PROJECT